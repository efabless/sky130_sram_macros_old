* Functional test stimulus file for 10ns period

* TT process corner
.lib "/home/software/PDKs/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "sky130_sram_4kbyte_1rw_32x1024_8.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsky130_sram_4kbyte_1rw_32x1024_8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 a0_9 a0_10 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 vdd gnd sky130_sram_4kbyte_1rw_32x1024_8

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f

* Important signals for debug
* bl:	xsky130_sram_4kbyte_1rw_32x1024_8.xbank0.bl_0_0
* br:	xsky130_sram_4kbyte_1rw_32x1024_8.xbank0.br_0_0
* s_en:	xsky130_sram_4kbyte_1rw_32x1024_8.s_en
* q:	xsky130_sram_4kbyte_1rw_32x1024_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q
* qbar:	xsky130_sram_4kbyte_1rw_32x1024_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+10101101100011111000111010010100  to  address 00000000010 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+01110000111100010011111001001011  to  address 00000000010 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+11011111001001010100100010101110  to  address 00000000101 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+01110000111100010011111001001011 from address 00000000010 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 0+01110000111100010011111001001011 from address 00000000010 (from port 0) during cycle 5 (50ns - 60ns)
*	Writing (partial) 0+11111010001111101010000100101110  to  address 00000000010 with mask bit 1011 (from port 0) during cycle 6 (60ns - 70ns)
*	Writing 0+00001011010101101111101101011010  to  address 10000000001 (from port 0) during cycle 7 (70ns - 80ns)
*	Reading 0+11111010111100011010000100101110 from address 00000000010 (from port 0) during cycle 8 (80ns - 90ns)
*	Writing (partial) 0+11110110011111110000001011011000  to  address 00000000101 with mask bit 0101 (from port 0) during cycle 9 (90ns - 100ns)
*	Writing (partial) 0+11001001111001110010000110011000  to  address 00000000101 with mask bit 0001 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 0+11111010111100011010000100101110 from address 00000000010 (from port 0) during cycle 11 (110ns - 120ns)
*	Writing (partial) 0+00001001101101000101100010100110  to  address 10000000001 with mask bit 0100 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 0+00111000010110011110111100100101  to  address 10000000001 (from port 0) during cycle 13 (130ns - 140ns)
*	Writing (partial) 0+01111111110111001010000101000011  to  address 00000000101 with mask bit 0110 (from port 0) during cycle 14 (140ns - 150ns)
*	Reading 0+11111010111100011010000100101110 from address 00000000010 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 0+11011111110111001010000110011000 from address 00000000101 (from port 0) during cycle 18 (180ns - 190ns)
*	Reading 0+11111010111100011010000100101110 from address 00000000010 (from port 0) during cycle 19 (190ns - 200ns)
*	Reading 0+11111010111100011010000100101110 from address 00000000010 (from port 0) during cycle 20 (200ns - 210ns)
*	Writing (partial) 0+11111011011000010111011110110000  to  address 00000000010 with mask bit 1011 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 0+11011111110111001010000110011000 from address 00000000101 (from port 0) during cycle 22 (220ns - 230ns)
*	Writing (partial) 0+00000101011111110111100010100000  to  address 10000000001 with mask bit 0001 (from port 0) during cycle 23 (230ns - 240ns)
*	Reading 0+11111011111100010111011110110000 from address 00000000010 (from port 0) during cycle 24 (240ns - 250ns)
*	Writing (partial) 0+01001011010011111100001111001111  to  address 10000000001 with mask bit 1001 (from port 0) during cycle 25 (250ns - 260ns)
*	Writing (partial) 0+11000000010010101111100101011110  to  address 00000000010 with mask bit 0010 (from port 0) during cycle 27 (270ns - 280ns)
*	Reading 0+11011111110111001010000110011000 from address 00000000101 (from port 0) during cycle 28 (280ns - 290ns)
*	Reading 0+01001011010110011110111111001111 from address 10000000001 (from port 0) during cycle 29 (290ns - 300ns)
*	Writing 0+11100101011101101100110010000000  to  address 00000000010 (from port 0) during cycle 30 (300ns - 310ns)
*	Writing (partial) 0+10110110010010011000011101100000  to  address 00000000101 with mask bit 1010 (from port 0) during cycle 32 (320ns - 330ns)
*	Reading 0+11100101011101101100110010000000 from address 00000000010 (from port 0) during cycle 34 (340ns - 350ns)
*	Writing 0+01101111111010011101101100011111  to  address 10000000100 (from port 0) during cycle 35 (350ns - 360ns)
*	Writing (partial) 0+00010000110011011101001101100011  to  address 00000000101 with mask bit 1110 (from port 0) during cycle 36 (360ns - 370ns)
*	Writing 0+10010011000001100111000001101000  to  address 10000000010 (from port 0) during cycle 37 (370ns - 380ns)
*	Writing 0+10000111110010111111000110100101  to  address 00000000010 (from port 0) during cycle 38 (380ns - 390ns)
*	Writing 0+11110100100010100111011000001001  to  address 10000000010 (from port 0) during cycle 40 (400ns - 410ns)
*	Writing (partial) 0+00100010101110011000110001100110  to  address 00000000010 with mask bit 1100 (from port 0) during cycle 41 (410ns - 420ns)
*	Writing (partial) 0+00000101000110000101100100011101  to  address 10000000001 with mask bit 0111 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 0+00010000110011011101001110011000 from address 00000000101 (from port 0) during cycle 44 (440ns - 450ns)
*	Writing (partial) 0+11110000010010101111100001000110  to  address 10000000100 with mask bit 0111 (from port 0) during cycle 45 (450ns - 460ns)
*	Writing 0+01010100001011111110101110010011  to  address 00000000101 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 0+01101111010010101111100001000110 from address 10000000100 (from port 0) during cycle 52 (520ns - 530ns)
*	Writing (partial) 0+01000101000100111010110010101011  to  address 10000000010 with mask bit 1011 (from port 0) during cycle 54 (540ns - 550ns)
*	Writing 0+11101000111100010001011000011101  to  address 10000000010 (from port 0) during cycle 55 (550ns - 560ns)
*	Writing (partial) 0+10010011110000001010100000011011  to  address 10000000010 with mask bit 0001 (from port 0) during cycle 56 (560ns - 570ns)
*	Writing 0+00011110011001101011010111110010  to  address 00000000001 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 0+01101111010010101111100001000110 from address 10000000100 (from port 0) during cycle 58 (580ns - 590ns)
*	Writing (partial) 0+00100011000010100100110101000100  to  address 00000000101 with mask bit 0111 (from port 0) during cycle 59 (590ns - 600ns)
*	Reading 0+00011110011001101011010111110010 from address 00000000001 (from port 0) during cycle 61 (610ns - 620ns)
*	Reading 0+01101111010010101111100001000110 from address 10000000100 (from port 0) during cycle 63 (630ns - 640ns)
*	Reading 0+01001011000110000101100100011101 from address 10000000001 (from port 0) during cycle 64 (640ns - 650ns)
*	Writing (partial) 0+10011111010001000101001101011000  to  address 10000000001 with mask bit 0101 (from port 0) during cycle 65 (650ns - 660ns)
*	Reading 0+00011110011001101011010111110010 from address 00000000001 (from port 0) during cycle 66 (660ns - 670ns)
*	Reading 0+00011110011001101011010111110010 from address 00000000001 (from port 0) during cycle 68 (680ns - 690ns)
*	Reading 0+00100010101110011111000110100101 from address 00000000010 (from port 0) during cycle 69 (690ns - 700ns)
*	Writing 0+00111110000011011100011000100101  to  address 10000000001 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 0+00011110011001101011010111110010 from address 00000000001 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 0+01010100000010100100110101000100 from address 00000000101 (from port 0) during cycle 72 (720ns - 730ns)
*	Writing 0+11100101010101010010000001000111  to  address 10000000001 (from port 0) during cycle 74 (740ns - 750ns)
*	Reading 0+01101111010010101111100001000110 from address 10000000100 (from port 0) during cycle 75 (750ns - 760ns)
*	Writing 0+11011001110110100010010001100111  to  address 00000000111 (from port 0) during cycle 76 (760ns - 770ns)
*	Writing 0+11010101110100001100010010001100  to  address 00000000010 (from port 0) during cycle 77 (770ns - 780ns)
*	Reading 0+00011110011001101011010111110010 from address 00000000001 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 0+11010101110100001100010010001100 from address 00000000010 (from port 0) during cycle 79 (790ns - 800ns)
*	Reading 0+01010100000010100100110101000100 from address 00000000101 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 0+11100101010101010010000001000111 from address 10000000001 (from port 0) during cycle 81 (810ns - 820ns)
*	Writing (partial) 0+10001010000100011001010100000010  to  address 10000000010 with mask bit 1110 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 0+01010100000010100100110101000100 from address 00000000101 (from port 0) during cycle 83 (830ns - 840ns)
*	Reading 0+11010101110100001100010010001100 from address 00000000010 (from port 0) during cycle 84 (840ns - 850ns)
*	Reading 0+11100101010101010010000001000111 from address 10000000001 (from port 0) during cycle 85 (850ns - 860ns)
*	Reading 0+11011001110110100010010001100111 from address 00000000111 (from port 0) during cycle 86 (860ns - 870ns)
*	Writing 0+10100101100100011010001011111110  to  address 00000000101 (from port 0) during cycle 87 (870ns - 880ns)
*	Reading 0+11011001110110100010010001100111 from address 00000000111 (from port 0) during cycle 88 (880ns - 890ns)
*	Writing (partial) 0+00100101000100100010110101110000  to  address 00000000001 with mask bit 1110 (from port 0) during cycle 89 (890ns - 900ns)
*	Reading 0+10001010000100011001010100011011 from address 10000000010 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 0+10001010000100011001010100011011 from address 10000000010 (from port 0) during cycle 91 (910ns - 920ns)
*	Reading 0+11011001110110100010010001100111 from address 00000000111 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 0+01101111010010101111100001000110 from address 10000000100 (from port 0) during cycle 93 (930ns - 940ns)
*	Writing (partial) 0+11101111101111110111111100011110  to  address 10000000001 with mask bit 0110 (from port 0) during cycle 94 (940ns - 950ns)
*	Writing 0+11110000000011111010000010111101  to  address 00000000111 (from port 0) during cycle 95 (950ns - 960ns)
*	Writing (partial) 0+01111011001001101000101010011011  to  address 00000000010 with mask bit 0100 (from port 0) during cycle 97 (970ns - 980ns)
*	Writing (partial) 0+01000111101000010011111100100001  to  address 00000000010 with mask bit 1000 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 0+00100101000100100010110111110010 from address 00000000001 (from port 0) during cycle 100 (1000ns - 1010ns)
*	Reading 0+10100101100100011010001011111110 from address 00000000101 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+00100101000100100010110111110010 from address 00000000001 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 0+01101111010010101111100001000110 from address 10000000100 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Reading 0+11100101101111110111111101000111 from address 10000000001 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Writing 0+11101011010110110110110110100001  to  address 10000000100 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Reading 0+11101011010110110110110110100001 from address 10000000100 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 0+11101011010110110110110110100001 from address 10000000100 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Writing 0+11011000101101010101110100001001  to  address 10000000000 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Writing (partial) 0+10000011011100100110110111110011  to  address 10000000010 with mask bit 1000 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Writing (partial) 0+11000101110111000001100100011010  to  address 00000000111 with mask bit 0100 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Writing 0+11010001101000010000100101011101  to  address 10000000011 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 0+10100101100100011010001011111110 from address 00000000101 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Writing 0+11100010100110111011100111111000  to  address 00000000100 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Writing (partial) 0+10110101000010110011010101110001  to  address 00000000010 with mask bit 0110 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 0+11100101101111110111111101000111 from address 10000000001 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 0+11010001101000010000100101011101 from address 10000000011 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Writing 0+10011100000100011111111001110011  to  address 00000000011 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 0+10011100000100011111111001110011 from address 00000000011 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 0+01000111000010110011010110001100 from address 00000000010 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 0+10011100000100011111111001110011 from address 00000000011 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Writing 0+11111110101100111111111011101010  to  address 00000000001 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Writing 0+10101011000010101101011100000010  to  address 10000000110 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 0+11101011010110110110110110100001 from address 10000000100 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Reading 0+10011100000100011111111001110011 from address 00000000011 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 0+11100010100110111011100111111000 from address 00000000100 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Writing (partial) 0+01011110101111100011111001001001  to  address 10000000100 with mask bit 1001 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 0+11010001101000010000100101011101 from address 10000000011 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Writing (partial) 0+00110000000101111111000111011001  to  address 10000000010 with mask bit 1100 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Reading 0+11100101101111110111111101000111 from address 10000000001 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Writing 0+11110011000010111101011010011011  to  address 10000000110 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Reading 0+01011110010110110110110101001001 from address 10000000100 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Writing 0+10111100100110010101011111000000  to  address 00000000110 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Writing (partial) 0+01010001001100100101110000111010  to  address 00000000001 with mask bit 1010 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 0+01010001101100110101110011101010 from address 00000000001 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Writing 0+11000111011111011111010110111000  to  address 10000000001 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Reading 0+10011100000100011111111001110011 from address 00000000011 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Writing (partial) 0+00100111010011110111000101101110  to  address 10000000011 with mask bit 1110 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Reading 0+01010001101100110101110011101010 from address 00000000001 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Writing 0+10010010001101000111010000100001  to  address 00000000101 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Writing 0+01101000010101111010111101101100  to  address 10000000011 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 0+10011100000100011111111001110011 from address 00000000011 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Writing (partial) 0+10010000010010011000100010110100  to  address 00000000110 with mask bit 1100 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 0+11000111011111011111010110111000 from address 10000000001 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Reading 0+11011000101101010101110100001001 from address 10000000000 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Writing 0+10111000100010110010100101010001  to  address 00000000111 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Reading 0+11011000101101010101110100001001 from address 10000000000 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 0+01010001101100110101110011101010 from address 00000000001 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Reading 0+11110011000010111101011010011011 from address 10000000110 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 0+11100010100110111011100111111000 from address 00000000100 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Writing 0+11100110010100011101110110011111  to  address 00000000110 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 0+11000111011111011111010110111000 from address 10000000001 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Reading 0+01011110010110110110110101001001 from address 10000000100 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Writing (partial) 0+11100111000010010101110000000101  to  address 10000000100 with mask bit 1011 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Reading 0+10010010001101000111010000100001 from address 00000000101 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Writing (partial) 0+01111111000101111110010100000110  to  address 10000000000 with mask bit 1101 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Reading 0+11100110010100011101110110011111 from address 00000000110 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Writing 0+10110011001101101001011111101001  to  address 00000000111 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Writing 0+11011010010111101000101100010101  to  address 00000000100 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Writing 0+11100101000101001100101100000100  to  address 00000000111 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Writing (partial) 0+11110010001100000100011001011100  to  address 00000000001 with mask bit 0100 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Writing 0+00001100000011000010010010111111  to  address 00000000011 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Writing (partial) 0+11010110100110001000110101101111  to  address 00000000010 with mask bit 1101 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Writing 0+01011110101000000111000100010111  to  address 10000000011 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing 0+01010110100000001010101100001101  to  address 00000000101 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 0+11010110100110000011010101101111 from address 00000000010 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Writing 0+00000101000010110001100011110111  to  address 10000000000 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 0+11110011000010111101011010011011 from address 10000000110 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 0+11000111011111011111010110111000 from address 10000000001 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Writing 0+11000000111001110110000110011111  to  address 10000000011 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 0+01010110100000001010101100001101 from address 00000000101 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing 0+11011011001001000111001101111000  to  address 10000000011 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Writing (partial) 0+01000010100101101000111000101001  to  address 10000000110 with mask bit 0001 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Writing 0+00011001110111110111000011000110  to  address 10000000010 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Reading 0+11011010010111101000101100010101 from address 00000000100 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 1), (50, 1), (60, 1), (70, 0), (80, 1), (90, 0), (100, 0), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 0), (840, 1), (850, 0), (860, 1), (870, 0), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 0), (200, 0), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 0), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_9  a0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 1), (410, 0), (420, 1), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 0), (730, 0), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_10  a0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 1), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 0), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of wmask signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 1.8 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 50
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=50.05n

* CHECK dout0_9 Vdout0_9ck4 = 1.8 time = 50
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=50.05n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 50
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=50.05n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 50
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=50.05n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 50
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=50.05n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 50
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=50.05n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 50
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=50.05n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 50
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=50.05n

* CHECK dout0_16 Vdout0_16ck4 = 1.8 time = 50
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=50.05n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 50
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=50.05n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 50
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=50.05n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 50
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=50.05n

* CHECK dout0_20 Vdout0_20ck4 = 1.8 time = 50
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=50.05n

* CHECK dout0_21 Vdout0_21ck4 = 1.8 time = 50
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=50.05n

* CHECK dout0_22 Vdout0_22ck4 = 1.8 time = 50
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=50.05n

* CHECK dout0_23 Vdout0_23ck4 = 1.8 time = 50
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=50.05n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 50
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=50.05n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 50
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=50.05n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 50
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=50.05n

* CHECK dout0_27 Vdout0_27ck4 = 0 time = 50
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=50.05n

* CHECK dout0_28 Vdout0_28ck4 = 1.8 time = 50
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=50.05n

* CHECK dout0_29 Vdout0_29ck4 = 1.8 time = 50
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=50.05n

* CHECK dout0_30 Vdout0_30ck4 = 1.8 time = 50
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=50.05n

* CHECK dout0_31 Vdout0_31ck4 = 0 time = 50
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=50.05n

* CHECK dout0_32 Vdout0_32ck4 = 0 time = 50
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=50.05n

* CHECK dout0_0 Vdout0_0ck5 = 1.8 time = 60
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=60.05n

* CHECK dout0_1 Vdout0_1ck5 = 1.8 time = 60
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=60.05n

* CHECK dout0_2 Vdout0_2ck5 = 0 time = 60
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=60.05n

* CHECK dout0_3 Vdout0_3ck5 = 1.8 time = 60
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=60.05n

* CHECK dout0_4 Vdout0_4ck5 = 0 time = 60
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=60.05n

* CHECK dout0_5 Vdout0_5ck5 = 0 time = 60
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=60.05n

* CHECK dout0_6 Vdout0_6ck5 = 1.8 time = 60
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=60.05n

* CHECK dout0_7 Vdout0_7ck5 = 0 time = 60
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=60.05n

* CHECK dout0_8 Vdout0_8ck5 = 0 time = 60
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=60.05n

* CHECK dout0_9 Vdout0_9ck5 = 1.8 time = 60
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=60.05n

* CHECK dout0_10 Vdout0_10ck5 = 1.8 time = 60
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=60.05n

* CHECK dout0_11 Vdout0_11ck5 = 1.8 time = 60
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=60.05n

* CHECK dout0_12 Vdout0_12ck5 = 1.8 time = 60
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=60.05n

* CHECK dout0_13 Vdout0_13ck5 = 1.8 time = 60
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=60.05n

* CHECK dout0_14 Vdout0_14ck5 = 0 time = 60
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=60.05n

* CHECK dout0_15 Vdout0_15ck5 = 0 time = 60
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=60.05n

* CHECK dout0_16 Vdout0_16ck5 = 1.8 time = 60
.meas tran vdout0_16ck5 FIND v(dout0_16) AT=60.05n

* CHECK dout0_17 Vdout0_17ck5 = 0 time = 60
.meas tran vdout0_17ck5 FIND v(dout0_17) AT=60.05n

* CHECK dout0_18 Vdout0_18ck5 = 0 time = 60
.meas tran vdout0_18ck5 FIND v(dout0_18) AT=60.05n

* CHECK dout0_19 Vdout0_19ck5 = 0 time = 60
.meas tran vdout0_19ck5 FIND v(dout0_19) AT=60.05n

* CHECK dout0_20 Vdout0_20ck5 = 1.8 time = 60
.meas tran vdout0_20ck5 FIND v(dout0_20) AT=60.05n

* CHECK dout0_21 Vdout0_21ck5 = 1.8 time = 60
.meas tran vdout0_21ck5 FIND v(dout0_21) AT=60.05n

* CHECK dout0_22 Vdout0_22ck5 = 1.8 time = 60
.meas tran vdout0_22ck5 FIND v(dout0_22) AT=60.05n

* CHECK dout0_23 Vdout0_23ck5 = 1.8 time = 60
.meas tran vdout0_23ck5 FIND v(dout0_23) AT=60.05n

* CHECK dout0_24 Vdout0_24ck5 = 0 time = 60
.meas tran vdout0_24ck5 FIND v(dout0_24) AT=60.05n

* CHECK dout0_25 Vdout0_25ck5 = 0 time = 60
.meas tran vdout0_25ck5 FIND v(dout0_25) AT=60.05n

* CHECK dout0_26 Vdout0_26ck5 = 0 time = 60
.meas tran vdout0_26ck5 FIND v(dout0_26) AT=60.05n

* CHECK dout0_27 Vdout0_27ck5 = 0 time = 60
.meas tran vdout0_27ck5 FIND v(dout0_27) AT=60.05n

* CHECK dout0_28 Vdout0_28ck5 = 1.8 time = 60
.meas tran vdout0_28ck5 FIND v(dout0_28) AT=60.05n

* CHECK dout0_29 Vdout0_29ck5 = 1.8 time = 60
.meas tran vdout0_29ck5 FIND v(dout0_29) AT=60.05n

* CHECK dout0_30 Vdout0_30ck5 = 1.8 time = 60
.meas tran vdout0_30ck5 FIND v(dout0_30) AT=60.05n

* CHECK dout0_31 Vdout0_31ck5 = 0 time = 60
.meas tran vdout0_31ck5 FIND v(dout0_31) AT=60.05n

* CHECK dout0_32 Vdout0_32ck5 = 0 time = 60
.meas tran vdout0_32ck5 FIND v(dout0_32) AT=60.05n

* CHECK dout0_0 Vdout0_0ck8 = 0 time = 90
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=90.05n

* CHECK dout0_1 Vdout0_1ck8 = 1.8 time = 90
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=90.05n

* CHECK dout0_2 Vdout0_2ck8 = 1.8 time = 90
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=90.05n

* CHECK dout0_3 Vdout0_3ck8 = 1.8 time = 90
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=90.05n

* CHECK dout0_4 Vdout0_4ck8 = 0 time = 90
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=90.05n

* CHECK dout0_5 Vdout0_5ck8 = 1.8 time = 90
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=90.05n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 90
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=90.05n

* CHECK dout0_7 Vdout0_7ck8 = 0 time = 90
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=90.05n

* CHECK dout0_8 Vdout0_8ck8 = 1.8 time = 90
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=90.05n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 90
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=90.05n

* CHECK dout0_10 Vdout0_10ck8 = 0 time = 90
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=90.05n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 90
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=90.05n

* CHECK dout0_12 Vdout0_12ck8 = 0 time = 90
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=90.05n

* CHECK dout0_13 Vdout0_13ck8 = 1.8 time = 90
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=90.05n

* CHECK dout0_14 Vdout0_14ck8 = 0 time = 90
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=90.05n

* CHECK dout0_15 Vdout0_15ck8 = 1.8 time = 90
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=90.05n

* CHECK dout0_16 Vdout0_16ck8 = 1.8 time = 90
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=90.05n

* CHECK dout0_17 Vdout0_17ck8 = 0 time = 90
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=90.05n

* CHECK dout0_18 Vdout0_18ck8 = 0 time = 90
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=90.05n

* CHECK dout0_19 Vdout0_19ck8 = 0 time = 90
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=90.05n

* CHECK dout0_20 Vdout0_20ck8 = 1.8 time = 90
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=90.05n

* CHECK dout0_21 Vdout0_21ck8 = 1.8 time = 90
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=90.05n

* CHECK dout0_22 Vdout0_22ck8 = 1.8 time = 90
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=90.05n

* CHECK dout0_23 Vdout0_23ck8 = 1.8 time = 90
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=90.05n

* CHECK dout0_24 Vdout0_24ck8 = 0 time = 90
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=90.05n

* CHECK dout0_25 Vdout0_25ck8 = 1.8 time = 90
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=90.05n

* CHECK dout0_26 Vdout0_26ck8 = 0 time = 90
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=90.05n

* CHECK dout0_27 Vdout0_27ck8 = 1.8 time = 90
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=90.05n

* CHECK dout0_28 Vdout0_28ck8 = 1.8 time = 90
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=90.05n

* CHECK dout0_29 Vdout0_29ck8 = 1.8 time = 90
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=90.05n

* CHECK dout0_30 Vdout0_30ck8 = 1.8 time = 90
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=90.05n

* CHECK dout0_31 Vdout0_31ck8 = 1.8 time = 90
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=90.05n

* CHECK dout0_32 Vdout0_32ck8 = 0 time = 90
.meas tran vdout0_32ck8 FIND v(dout0_32) AT=90.05n

* CHECK dout0_0 Vdout0_0ck11 = 0 time = 120
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=120.05n

* CHECK dout0_1 Vdout0_1ck11 = 1.8 time = 120
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=120.05n

* CHECK dout0_2 Vdout0_2ck11 = 1.8 time = 120
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=120.05n

* CHECK dout0_3 Vdout0_3ck11 = 1.8 time = 120
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=120.05n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 120
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=120.05n

* CHECK dout0_5 Vdout0_5ck11 = 1.8 time = 120
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=120.05n

* CHECK dout0_6 Vdout0_6ck11 = 0 time = 120
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=120.05n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 120
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=120.05n

* CHECK dout0_8 Vdout0_8ck11 = 1.8 time = 120
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=120.05n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 120
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=120.05n

* CHECK dout0_10 Vdout0_10ck11 = 0 time = 120
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=120.05n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 120
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=120.05n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 120
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=120.05n

* CHECK dout0_13 Vdout0_13ck11 = 1.8 time = 120
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=120.05n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 120
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=120.05n

* CHECK dout0_15 Vdout0_15ck11 = 1.8 time = 120
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=120.05n

* CHECK dout0_16 Vdout0_16ck11 = 1.8 time = 120
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=120.05n

* CHECK dout0_17 Vdout0_17ck11 = 0 time = 120
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=120.05n

* CHECK dout0_18 Vdout0_18ck11 = 0 time = 120
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=120.05n

* CHECK dout0_19 Vdout0_19ck11 = 0 time = 120
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=120.05n

* CHECK dout0_20 Vdout0_20ck11 = 1.8 time = 120
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=120.05n

* CHECK dout0_21 Vdout0_21ck11 = 1.8 time = 120
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=120.05n

* CHECK dout0_22 Vdout0_22ck11 = 1.8 time = 120
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=120.05n

* CHECK dout0_23 Vdout0_23ck11 = 1.8 time = 120
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=120.05n

* CHECK dout0_24 Vdout0_24ck11 = 0 time = 120
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=120.05n

* CHECK dout0_25 Vdout0_25ck11 = 1.8 time = 120
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=120.05n

* CHECK dout0_26 Vdout0_26ck11 = 0 time = 120
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=120.05n

* CHECK dout0_27 Vdout0_27ck11 = 1.8 time = 120
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=120.05n

* CHECK dout0_28 Vdout0_28ck11 = 1.8 time = 120
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=120.05n

* CHECK dout0_29 Vdout0_29ck11 = 1.8 time = 120
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=120.05n

* CHECK dout0_30 Vdout0_30ck11 = 1.8 time = 120
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=120.05n

* CHECK dout0_31 Vdout0_31ck11 = 1.8 time = 120
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=120.05n

* CHECK dout0_32 Vdout0_32ck11 = 0 time = 120
.meas tran vdout0_32ck11 FIND v(dout0_32) AT=120.05n

* CHECK dout0_0 Vdout0_0ck16 = 0 time = 170
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=170.05n

* CHECK dout0_1 Vdout0_1ck16 = 1.8 time = 170
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=170.05n

* CHECK dout0_2 Vdout0_2ck16 = 1.8 time = 170
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=170.05n

* CHECK dout0_3 Vdout0_3ck16 = 1.8 time = 170
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=170.05n

* CHECK dout0_4 Vdout0_4ck16 = 0 time = 170
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=170.05n

* CHECK dout0_5 Vdout0_5ck16 = 1.8 time = 170
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=170.05n

* CHECK dout0_6 Vdout0_6ck16 = 0 time = 170
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=170.05n

* CHECK dout0_7 Vdout0_7ck16 = 0 time = 170
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=170.05n

* CHECK dout0_8 Vdout0_8ck16 = 1.8 time = 170
.meas tran vdout0_8ck16 FIND v(dout0_8) AT=170.05n

* CHECK dout0_9 Vdout0_9ck16 = 0 time = 170
.meas tran vdout0_9ck16 FIND v(dout0_9) AT=170.05n

* CHECK dout0_10 Vdout0_10ck16 = 0 time = 170
.meas tran vdout0_10ck16 FIND v(dout0_10) AT=170.05n

* CHECK dout0_11 Vdout0_11ck16 = 0 time = 170
.meas tran vdout0_11ck16 FIND v(dout0_11) AT=170.05n

* CHECK dout0_12 Vdout0_12ck16 = 0 time = 170
.meas tran vdout0_12ck16 FIND v(dout0_12) AT=170.05n

* CHECK dout0_13 Vdout0_13ck16 = 1.8 time = 170
.meas tran vdout0_13ck16 FIND v(dout0_13) AT=170.05n

* CHECK dout0_14 Vdout0_14ck16 = 0 time = 170
.meas tran vdout0_14ck16 FIND v(dout0_14) AT=170.05n

* CHECK dout0_15 Vdout0_15ck16 = 1.8 time = 170
.meas tran vdout0_15ck16 FIND v(dout0_15) AT=170.05n

* CHECK dout0_16 Vdout0_16ck16 = 1.8 time = 170
.meas tran vdout0_16ck16 FIND v(dout0_16) AT=170.05n

* CHECK dout0_17 Vdout0_17ck16 = 0 time = 170
.meas tran vdout0_17ck16 FIND v(dout0_17) AT=170.05n

* CHECK dout0_18 Vdout0_18ck16 = 0 time = 170
.meas tran vdout0_18ck16 FIND v(dout0_18) AT=170.05n

* CHECK dout0_19 Vdout0_19ck16 = 0 time = 170
.meas tran vdout0_19ck16 FIND v(dout0_19) AT=170.05n

* CHECK dout0_20 Vdout0_20ck16 = 1.8 time = 170
.meas tran vdout0_20ck16 FIND v(dout0_20) AT=170.05n

* CHECK dout0_21 Vdout0_21ck16 = 1.8 time = 170
.meas tran vdout0_21ck16 FIND v(dout0_21) AT=170.05n

* CHECK dout0_22 Vdout0_22ck16 = 1.8 time = 170
.meas tran vdout0_22ck16 FIND v(dout0_22) AT=170.05n

* CHECK dout0_23 Vdout0_23ck16 = 1.8 time = 170
.meas tran vdout0_23ck16 FIND v(dout0_23) AT=170.05n

* CHECK dout0_24 Vdout0_24ck16 = 0 time = 170
.meas tran vdout0_24ck16 FIND v(dout0_24) AT=170.05n

* CHECK dout0_25 Vdout0_25ck16 = 1.8 time = 170
.meas tran vdout0_25ck16 FIND v(dout0_25) AT=170.05n

* CHECK dout0_26 Vdout0_26ck16 = 0 time = 170
.meas tran vdout0_26ck16 FIND v(dout0_26) AT=170.05n

* CHECK dout0_27 Vdout0_27ck16 = 1.8 time = 170
.meas tran vdout0_27ck16 FIND v(dout0_27) AT=170.05n

* CHECK dout0_28 Vdout0_28ck16 = 1.8 time = 170
.meas tran vdout0_28ck16 FIND v(dout0_28) AT=170.05n

* CHECK dout0_29 Vdout0_29ck16 = 1.8 time = 170
.meas tran vdout0_29ck16 FIND v(dout0_29) AT=170.05n

* CHECK dout0_30 Vdout0_30ck16 = 1.8 time = 170
.meas tran vdout0_30ck16 FIND v(dout0_30) AT=170.05n

* CHECK dout0_31 Vdout0_31ck16 = 1.8 time = 170
.meas tran vdout0_31ck16 FIND v(dout0_31) AT=170.05n

* CHECK dout0_32 Vdout0_32ck16 = 0 time = 170
.meas tran vdout0_32ck16 FIND v(dout0_32) AT=170.05n

* CHECK dout0_0 Vdout0_0ck18 = 0 time = 190
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=190.05n

* CHECK dout0_1 Vdout0_1ck18 = 0 time = 190
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=190.05n

* CHECK dout0_2 Vdout0_2ck18 = 0 time = 190
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=190.05n

* CHECK dout0_3 Vdout0_3ck18 = 1.8 time = 190
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=190.05n

* CHECK dout0_4 Vdout0_4ck18 = 1.8 time = 190
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=190.05n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 190
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=190.05n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 190
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=190.05n

* CHECK dout0_7 Vdout0_7ck18 = 1.8 time = 190
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=190.05n

* CHECK dout0_8 Vdout0_8ck18 = 1.8 time = 190
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=190.05n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 190
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=190.05n

* CHECK dout0_10 Vdout0_10ck18 = 0 time = 190
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=190.05n

* CHECK dout0_11 Vdout0_11ck18 = 0 time = 190
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=190.05n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 190
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=190.05n

* CHECK dout0_13 Vdout0_13ck18 = 1.8 time = 190
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=190.05n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 190
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=190.05n

* CHECK dout0_15 Vdout0_15ck18 = 1.8 time = 190
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=190.05n

* CHECK dout0_16 Vdout0_16ck18 = 0 time = 190
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=190.05n

* CHECK dout0_17 Vdout0_17ck18 = 0 time = 190
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=190.05n

* CHECK dout0_18 Vdout0_18ck18 = 1.8 time = 190
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=190.05n

* CHECK dout0_19 Vdout0_19ck18 = 1.8 time = 190
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=190.05n

* CHECK dout0_20 Vdout0_20ck18 = 1.8 time = 190
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=190.05n

* CHECK dout0_21 Vdout0_21ck18 = 0 time = 190
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=190.05n

* CHECK dout0_22 Vdout0_22ck18 = 1.8 time = 190
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=190.05n

* CHECK dout0_23 Vdout0_23ck18 = 1.8 time = 190
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=190.05n

* CHECK dout0_24 Vdout0_24ck18 = 1.8 time = 190
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=190.05n

* CHECK dout0_25 Vdout0_25ck18 = 1.8 time = 190
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=190.05n

* CHECK dout0_26 Vdout0_26ck18 = 1.8 time = 190
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=190.05n

* CHECK dout0_27 Vdout0_27ck18 = 1.8 time = 190
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=190.05n

* CHECK dout0_28 Vdout0_28ck18 = 1.8 time = 190
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=190.05n

* CHECK dout0_29 Vdout0_29ck18 = 0 time = 190
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=190.05n

* CHECK dout0_30 Vdout0_30ck18 = 1.8 time = 190
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=190.05n

* CHECK dout0_31 Vdout0_31ck18 = 1.8 time = 190
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=190.05n

* CHECK dout0_32 Vdout0_32ck18 = 0 time = 190
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=190.05n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 200
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=200.05n

* CHECK dout0_1 Vdout0_1ck19 = 1.8 time = 200
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=200.05n

* CHECK dout0_2 Vdout0_2ck19 = 1.8 time = 200
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=200.05n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 200
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=200.05n

* CHECK dout0_4 Vdout0_4ck19 = 0 time = 200
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=200.05n

* CHECK dout0_5 Vdout0_5ck19 = 1.8 time = 200
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=200.05n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 200
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=200.05n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 200
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=200.05n

* CHECK dout0_8 Vdout0_8ck19 = 1.8 time = 200
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=200.05n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 200
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=200.05n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 200
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=200.05n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 200
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=200.05n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 200
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=200.05n

* CHECK dout0_13 Vdout0_13ck19 = 1.8 time = 200
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=200.05n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 200
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=200.05n

* CHECK dout0_15 Vdout0_15ck19 = 1.8 time = 200
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=200.05n

* CHECK dout0_16 Vdout0_16ck19 = 1.8 time = 200
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=200.05n

* CHECK dout0_17 Vdout0_17ck19 = 0 time = 200
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=200.05n

* CHECK dout0_18 Vdout0_18ck19 = 0 time = 200
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=200.05n

* CHECK dout0_19 Vdout0_19ck19 = 0 time = 200
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=200.05n

* CHECK dout0_20 Vdout0_20ck19 = 1.8 time = 200
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=200.05n

* CHECK dout0_21 Vdout0_21ck19 = 1.8 time = 200
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=200.05n

* CHECK dout0_22 Vdout0_22ck19 = 1.8 time = 200
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=200.05n

* CHECK dout0_23 Vdout0_23ck19 = 1.8 time = 200
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=200.05n

* CHECK dout0_24 Vdout0_24ck19 = 0 time = 200
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=200.05n

* CHECK dout0_25 Vdout0_25ck19 = 1.8 time = 200
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=200.05n

* CHECK dout0_26 Vdout0_26ck19 = 0 time = 200
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=200.05n

* CHECK dout0_27 Vdout0_27ck19 = 1.8 time = 200
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=200.05n

* CHECK dout0_28 Vdout0_28ck19 = 1.8 time = 200
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=200.05n

* CHECK dout0_29 Vdout0_29ck19 = 1.8 time = 200
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=200.05n

* CHECK dout0_30 Vdout0_30ck19 = 1.8 time = 200
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=200.05n

* CHECK dout0_31 Vdout0_31ck19 = 1.8 time = 200
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=200.05n

* CHECK dout0_32 Vdout0_32ck19 = 0 time = 200
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=200.05n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 210
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=210.05n

* CHECK dout0_1 Vdout0_1ck20 = 1.8 time = 210
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=210.05n

* CHECK dout0_2 Vdout0_2ck20 = 1.8 time = 210
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=210.05n

* CHECK dout0_3 Vdout0_3ck20 = 1.8 time = 210
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=210.05n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 210
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=210.05n

* CHECK dout0_5 Vdout0_5ck20 = 1.8 time = 210
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=210.05n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 210
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=210.05n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 210
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=210.05n

* CHECK dout0_8 Vdout0_8ck20 = 1.8 time = 210
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=210.05n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 210
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=210.05n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 210
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=210.05n

* CHECK dout0_11 Vdout0_11ck20 = 0 time = 210
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=210.05n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 210
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=210.05n

* CHECK dout0_13 Vdout0_13ck20 = 1.8 time = 210
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=210.05n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 210
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=210.05n

* CHECK dout0_15 Vdout0_15ck20 = 1.8 time = 210
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=210.05n

* CHECK dout0_16 Vdout0_16ck20 = 1.8 time = 210
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=210.05n

* CHECK dout0_17 Vdout0_17ck20 = 0 time = 210
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=210.05n

* CHECK dout0_18 Vdout0_18ck20 = 0 time = 210
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=210.05n

* CHECK dout0_19 Vdout0_19ck20 = 0 time = 210
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=210.05n

* CHECK dout0_20 Vdout0_20ck20 = 1.8 time = 210
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=210.05n

* CHECK dout0_21 Vdout0_21ck20 = 1.8 time = 210
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=210.05n

* CHECK dout0_22 Vdout0_22ck20 = 1.8 time = 210
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=210.05n

* CHECK dout0_23 Vdout0_23ck20 = 1.8 time = 210
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=210.05n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 210
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=210.05n

* CHECK dout0_25 Vdout0_25ck20 = 1.8 time = 210
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=210.05n

* CHECK dout0_26 Vdout0_26ck20 = 0 time = 210
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=210.05n

* CHECK dout0_27 Vdout0_27ck20 = 1.8 time = 210
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=210.05n

* CHECK dout0_28 Vdout0_28ck20 = 1.8 time = 210
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=210.05n

* CHECK dout0_29 Vdout0_29ck20 = 1.8 time = 210
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=210.05n

* CHECK dout0_30 Vdout0_30ck20 = 1.8 time = 210
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=210.05n

* CHECK dout0_31 Vdout0_31ck20 = 1.8 time = 210
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=210.05n

* CHECK dout0_32 Vdout0_32ck20 = 0 time = 210
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=210.05n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 230
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=230.05n

* CHECK dout0_1 Vdout0_1ck22 = 0 time = 230
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=230.05n

* CHECK dout0_2 Vdout0_2ck22 = 0 time = 230
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=230.05n

* CHECK dout0_3 Vdout0_3ck22 = 1.8 time = 230
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=230.05n

* CHECK dout0_4 Vdout0_4ck22 = 1.8 time = 230
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=230.05n

* CHECK dout0_5 Vdout0_5ck22 = 0 time = 230
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=230.05n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 230
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=230.05n

* CHECK dout0_7 Vdout0_7ck22 = 1.8 time = 230
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=230.05n

* CHECK dout0_8 Vdout0_8ck22 = 1.8 time = 230
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=230.05n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 230
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=230.05n

* CHECK dout0_10 Vdout0_10ck22 = 0 time = 230
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=230.05n

* CHECK dout0_11 Vdout0_11ck22 = 0 time = 230
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=230.05n

* CHECK dout0_12 Vdout0_12ck22 = 0 time = 230
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=230.05n

* CHECK dout0_13 Vdout0_13ck22 = 1.8 time = 230
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=230.05n

* CHECK dout0_14 Vdout0_14ck22 = 0 time = 230
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=230.05n

* CHECK dout0_15 Vdout0_15ck22 = 1.8 time = 230
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=230.05n

* CHECK dout0_16 Vdout0_16ck22 = 0 time = 230
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=230.05n

* CHECK dout0_17 Vdout0_17ck22 = 0 time = 230
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=230.05n

* CHECK dout0_18 Vdout0_18ck22 = 1.8 time = 230
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=230.05n

* CHECK dout0_19 Vdout0_19ck22 = 1.8 time = 230
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=230.05n

* CHECK dout0_20 Vdout0_20ck22 = 1.8 time = 230
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=230.05n

* CHECK dout0_21 Vdout0_21ck22 = 0 time = 230
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=230.05n

* CHECK dout0_22 Vdout0_22ck22 = 1.8 time = 230
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=230.05n

* CHECK dout0_23 Vdout0_23ck22 = 1.8 time = 230
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=230.05n

* CHECK dout0_24 Vdout0_24ck22 = 1.8 time = 230
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=230.05n

* CHECK dout0_25 Vdout0_25ck22 = 1.8 time = 230
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=230.05n

* CHECK dout0_26 Vdout0_26ck22 = 1.8 time = 230
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=230.05n

* CHECK dout0_27 Vdout0_27ck22 = 1.8 time = 230
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=230.05n

* CHECK dout0_28 Vdout0_28ck22 = 1.8 time = 230
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=230.05n

* CHECK dout0_29 Vdout0_29ck22 = 0 time = 230
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=230.05n

* CHECK dout0_30 Vdout0_30ck22 = 1.8 time = 230
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=230.05n

* CHECK dout0_31 Vdout0_31ck22 = 1.8 time = 230
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=230.05n

* CHECK dout0_32 Vdout0_32ck22 = 0 time = 230
.meas tran vdout0_32ck22 FIND v(dout0_32) AT=230.05n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 250
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=250.05n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 250
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=250.05n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 250
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=250.05n

* CHECK dout0_3 Vdout0_3ck24 = 0 time = 250
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=250.05n

* CHECK dout0_4 Vdout0_4ck24 = 1.8 time = 250
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=250.05n

* CHECK dout0_5 Vdout0_5ck24 = 1.8 time = 250
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=250.05n

* CHECK dout0_6 Vdout0_6ck24 = 0 time = 250
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=250.05n

* CHECK dout0_7 Vdout0_7ck24 = 1.8 time = 250
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=250.05n

* CHECK dout0_8 Vdout0_8ck24 = 1.8 time = 250
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=250.05n

* CHECK dout0_9 Vdout0_9ck24 = 1.8 time = 250
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=250.05n

* CHECK dout0_10 Vdout0_10ck24 = 1.8 time = 250
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=250.05n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 250
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=250.05n

* CHECK dout0_12 Vdout0_12ck24 = 1.8 time = 250
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=250.05n

* CHECK dout0_13 Vdout0_13ck24 = 1.8 time = 250
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=250.05n

* CHECK dout0_14 Vdout0_14ck24 = 1.8 time = 250
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=250.05n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 250
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=250.05n

* CHECK dout0_16 Vdout0_16ck24 = 1.8 time = 250
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=250.05n

* CHECK dout0_17 Vdout0_17ck24 = 0 time = 250
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=250.05n

* CHECK dout0_18 Vdout0_18ck24 = 0 time = 250
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=250.05n

* CHECK dout0_19 Vdout0_19ck24 = 0 time = 250
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=250.05n

* CHECK dout0_20 Vdout0_20ck24 = 1.8 time = 250
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=250.05n

* CHECK dout0_21 Vdout0_21ck24 = 1.8 time = 250
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=250.05n

* CHECK dout0_22 Vdout0_22ck24 = 1.8 time = 250
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=250.05n

* CHECK dout0_23 Vdout0_23ck24 = 1.8 time = 250
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=250.05n

* CHECK dout0_24 Vdout0_24ck24 = 1.8 time = 250
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=250.05n

* CHECK dout0_25 Vdout0_25ck24 = 1.8 time = 250
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=250.05n

* CHECK dout0_26 Vdout0_26ck24 = 0 time = 250
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=250.05n

* CHECK dout0_27 Vdout0_27ck24 = 1.8 time = 250
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=250.05n

* CHECK dout0_28 Vdout0_28ck24 = 1.8 time = 250
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=250.05n

* CHECK dout0_29 Vdout0_29ck24 = 1.8 time = 250
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=250.05n

* CHECK dout0_30 Vdout0_30ck24 = 1.8 time = 250
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=250.05n

* CHECK dout0_31 Vdout0_31ck24 = 1.8 time = 250
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=250.05n

* CHECK dout0_32 Vdout0_32ck24 = 0 time = 250
.meas tran vdout0_32ck24 FIND v(dout0_32) AT=250.05n

* CHECK dout0_0 Vdout0_0ck28 = 0 time = 290
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=290.05n

* CHECK dout0_1 Vdout0_1ck28 = 0 time = 290
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=290.05n

* CHECK dout0_2 Vdout0_2ck28 = 0 time = 290
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=290.05n

* CHECK dout0_3 Vdout0_3ck28 = 1.8 time = 290
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=290.05n

* CHECK dout0_4 Vdout0_4ck28 = 1.8 time = 290
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=290.05n

* CHECK dout0_5 Vdout0_5ck28 = 0 time = 290
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=290.05n

* CHECK dout0_6 Vdout0_6ck28 = 0 time = 290
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=290.05n

* CHECK dout0_7 Vdout0_7ck28 = 1.8 time = 290
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=290.05n

* CHECK dout0_8 Vdout0_8ck28 = 1.8 time = 290
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=290.05n

* CHECK dout0_9 Vdout0_9ck28 = 0 time = 290
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=290.05n

* CHECK dout0_10 Vdout0_10ck28 = 0 time = 290
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=290.05n

* CHECK dout0_11 Vdout0_11ck28 = 0 time = 290
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=290.05n

* CHECK dout0_12 Vdout0_12ck28 = 0 time = 290
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=290.05n

* CHECK dout0_13 Vdout0_13ck28 = 1.8 time = 290
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=290.05n

* CHECK dout0_14 Vdout0_14ck28 = 0 time = 290
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=290.05n

* CHECK dout0_15 Vdout0_15ck28 = 1.8 time = 290
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=290.05n

* CHECK dout0_16 Vdout0_16ck28 = 0 time = 290
.meas tran vdout0_16ck28 FIND v(dout0_16) AT=290.05n

* CHECK dout0_17 Vdout0_17ck28 = 0 time = 290
.meas tran vdout0_17ck28 FIND v(dout0_17) AT=290.05n

* CHECK dout0_18 Vdout0_18ck28 = 1.8 time = 290
.meas tran vdout0_18ck28 FIND v(dout0_18) AT=290.05n

* CHECK dout0_19 Vdout0_19ck28 = 1.8 time = 290
.meas tran vdout0_19ck28 FIND v(dout0_19) AT=290.05n

* CHECK dout0_20 Vdout0_20ck28 = 1.8 time = 290
.meas tran vdout0_20ck28 FIND v(dout0_20) AT=290.05n

* CHECK dout0_21 Vdout0_21ck28 = 0 time = 290
.meas tran vdout0_21ck28 FIND v(dout0_21) AT=290.05n

* CHECK dout0_22 Vdout0_22ck28 = 1.8 time = 290
.meas tran vdout0_22ck28 FIND v(dout0_22) AT=290.05n

* CHECK dout0_23 Vdout0_23ck28 = 1.8 time = 290
.meas tran vdout0_23ck28 FIND v(dout0_23) AT=290.05n

* CHECK dout0_24 Vdout0_24ck28 = 1.8 time = 290
.meas tran vdout0_24ck28 FIND v(dout0_24) AT=290.05n

* CHECK dout0_25 Vdout0_25ck28 = 1.8 time = 290
.meas tran vdout0_25ck28 FIND v(dout0_25) AT=290.05n

* CHECK dout0_26 Vdout0_26ck28 = 1.8 time = 290
.meas tran vdout0_26ck28 FIND v(dout0_26) AT=290.05n

* CHECK dout0_27 Vdout0_27ck28 = 1.8 time = 290
.meas tran vdout0_27ck28 FIND v(dout0_27) AT=290.05n

* CHECK dout0_28 Vdout0_28ck28 = 1.8 time = 290
.meas tran vdout0_28ck28 FIND v(dout0_28) AT=290.05n

* CHECK dout0_29 Vdout0_29ck28 = 0 time = 290
.meas tran vdout0_29ck28 FIND v(dout0_29) AT=290.05n

* CHECK dout0_30 Vdout0_30ck28 = 1.8 time = 290
.meas tran vdout0_30ck28 FIND v(dout0_30) AT=290.05n

* CHECK dout0_31 Vdout0_31ck28 = 1.8 time = 290
.meas tran vdout0_31ck28 FIND v(dout0_31) AT=290.05n

* CHECK dout0_32 Vdout0_32ck28 = 0 time = 290
.meas tran vdout0_32ck28 FIND v(dout0_32) AT=290.05n

* CHECK dout0_0 Vdout0_0ck29 = 1.8 time = 300
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=300.05n

* CHECK dout0_1 Vdout0_1ck29 = 1.8 time = 300
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=300.05n

* CHECK dout0_2 Vdout0_2ck29 = 1.8 time = 300
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=300.05n

* CHECK dout0_3 Vdout0_3ck29 = 1.8 time = 300
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=300.05n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 300
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=300.05n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 300
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=300.05n

* CHECK dout0_6 Vdout0_6ck29 = 1.8 time = 300
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=300.05n

* CHECK dout0_7 Vdout0_7ck29 = 1.8 time = 300
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=300.05n

* CHECK dout0_8 Vdout0_8ck29 = 1.8 time = 300
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=300.05n

* CHECK dout0_9 Vdout0_9ck29 = 1.8 time = 300
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=300.05n

* CHECK dout0_10 Vdout0_10ck29 = 1.8 time = 300
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=300.05n

* CHECK dout0_11 Vdout0_11ck29 = 1.8 time = 300
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=300.05n

* CHECK dout0_12 Vdout0_12ck29 = 0 time = 300
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=300.05n

* CHECK dout0_13 Vdout0_13ck29 = 1.8 time = 300
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=300.05n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 300
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=300.05n

* CHECK dout0_15 Vdout0_15ck29 = 1.8 time = 300
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=300.05n

* CHECK dout0_16 Vdout0_16ck29 = 1.8 time = 300
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=300.05n

* CHECK dout0_17 Vdout0_17ck29 = 0 time = 300
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=300.05n

* CHECK dout0_18 Vdout0_18ck29 = 0 time = 300
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=300.05n

* CHECK dout0_19 Vdout0_19ck29 = 1.8 time = 300
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=300.05n

* CHECK dout0_20 Vdout0_20ck29 = 1.8 time = 300
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=300.05n

* CHECK dout0_21 Vdout0_21ck29 = 0 time = 300
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=300.05n

* CHECK dout0_22 Vdout0_22ck29 = 1.8 time = 300
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=300.05n

* CHECK dout0_23 Vdout0_23ck29 = 0 time = 300
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=300.05n

* CHECK dout0_24 Vdout0_24ck29 = 1.8 time = 300
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=300.05n

* CHECK dout0_25 Vdout0_25ck29 = 1.8 time = 300
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=300.05n

* CHECK dout0_26 Vdout0_26ck29 = 0 time = 300
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=300.05n

* CHECK dout0_27 Vdout0_27ck29 = 1.8 time = 300
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=300.05n

* CHECK dout0_28 Vdout0_28ck29 = 0 time = 300
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=300.05n

* CHECK dout0_29 Vdout0_29ck29 = 0 time = 300
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=300.05n

* CHECK dout0_30 Vdout0_30ck29 = 1.8 time = 300
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=300.05n

* CHECK dout0_31 Vdout0_31ck29 = 0 time = 300
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=300.05n

* CHECK dout0_32 Vdout0_32ck29 = 0 time = 300
.meas tran vdout0_32ck29 FIND v(dout0_32) AT=300.05n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 350
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=350.05n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 350
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=350.05n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 350
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=350.05n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 350
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=350.05n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 350
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=350.05n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 350
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=350.05n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 350
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=350.05n

* CHECK dout0_7 Vdout0_7ck34 = 1.8 time = 350
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=350.05n

* CHECK dout0_8 Vdout0_8ck34 = 0 time = 350
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=350.05n

* CHECK dout0_9 Vdout0_9ck34 = 0 time = 350
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=350.05n

* CHECK dout0_10 Vdout0_10ck34 = 1.8 time = 350
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=350.05n

* CHECK dout0_11 Vdout0_11ck34 = 1.8 time = 350
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=350.05n

* CHECK dout0_12 Vdout0_12ck34 = 0 time = 350
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=350.05n

* CHECK dout0_13 Vdout0_13ck34 = 0 time = 350
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=350.05n

* CHECK dout0_14 Vdout0_14ck34 = 1.8 time = 350
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=350.05n

* CHECK dout0_15 Vdout0_15ck34 = 1.8 time = 350
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=350.05n

* CHECK dout0_16 Vdout0_16ck34 = 0 time = 350
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=350.05n

* CHECK dout0_17 Vdout0_17ck34 = 1.8 time = 350
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=350.05n

* CHECK dout0_18 Vdout0_18ck34 = 1.8 time = 350
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=350.05n

* CHECK dout0_19 Vdout0_19ck34 = 0 time = 350
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=350.05n

* CHECK dout0_20 Vdout0_20ck34 = 1.8 time = 350
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=350.05n

* CHECK dout0_21 Vdout0_21ck34 = 1.8 time = 350
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=350.05n

* CHECK dout0_22 Vdout0_22ck34 = 1.8 time = 350
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=350.05n

* CHECK dout0_23 Vdout0_23ck34 = 0 time = 350
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=350.05n

* CHECK dout0_24 Vdout0_24ck34 = 1.8 time = 350
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=350.05n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 350
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=350.05n

* CHECK dout0_26 Vdout0_26ck34 = 1.8 time = 350
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=350.05n

* CHECK dout0_27 Vdout0_27ck34 = 0 time = 350
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=350.05n

* CHECK dout0_28 Vdout0_28ck34 = 0 time = 350
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=350.05n

* CHECK dout0_29 Vdout0_29ck34 = 1.8 time = 350
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=350.05n

* CHECK dout0_30 Vdout0_30ck34 = 1.8 time = 350
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=350.05n

* CHECK dout0_31 Vdout0_31ck34 = 1.8 time = 350
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=350.05n

* CHECK dout0_32 Vdout0_32ck34 = 0 time = 350
.meas tran vdout0_32ck34 FIND v(dout0_32) AT=350.05n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 450
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=450.05n

* CHECK dout0_1 Vdout0_1ck44 = 0 time = 450
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=450.05n

* CHECK dout0_2 Vdout0_2ck44 = 0 time = 450
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=450.05n

* CHECK dout0_3 Vdout0_3ck44 = 1.8 time = 450
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=450.05n

* CHECK dout0_4 Vdout0_4ck44 = 1.8 time = 450
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=450.05n

* CHECK dout0_5 Vdout0_5ck44 = 0 time = 450
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=450.05n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 450
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=450.05n

* CHECK dout0_7 Vdout0_7ck44 = 1.8 time = 450
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=450.05n

* CHECK dout0_8 Vdout0_8ck44 = 1.8 time = 450
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=450.05n

* CHECK dout0_9 Vdout0_9ck44 = 1.8 time = 450
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=450.05n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 450
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=450.05n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 450
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=450.05n

* CHECK dout0_12 Vdout0_12ck44 = 1.8 time = 450
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=450.05n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 450
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=450.05n

* CHECK dout0_14 Vdout0_14ck44 = 1.8 time = 450
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=450.05n

* CHECK dout0_15 Vdout0_15ck44 = 1.8 time = 450
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=450.05n

* CHECK dout0_16 Vdout0_16ck44 = 1.8 time = 450
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=450.05n

* CHECK dout0_17 Vdout0_17ck44 = 0 time = 450
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=450.05n

* CHECK dout0_18 Vdout0_18ck44 = 1.8 time = 450
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=450.05n

* CHECK dout0_19 Vdout0_19ck44 = 1.8 time = 450
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=450.05n

* CHECK dout0_20 Vdout0_20ck44 = 0 time = 450
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=450.05n

* CHECK dout0_21 Vdout0_21ck44 = 0 time = 450
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=450.05n

* CHECK dout0_22 Vdout0_22ck44 = 1.8 time = 450
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=450.05n

* CHECK dout0_23 Vdout0_23ck44 = 1.8 time = 450
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=450.05n

* CHECK dout0_24 Vdout0_24ck44 = 0 time = 450
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=450.05n

* CHECK dout0_25 Vdout0_25ck44 = 0 time = 450
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=450.05n

* CHECK dout0_26 Vdout0_26ck44 = 0 time = 450
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=450.05n

* CHECK dout0_27 Vdout0_27ck44 = 0 time = 450
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=450.05n

* CHECK dout0_28 Vdout0_28ck44 = 1.8 time = 450
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=450.05n

* CHECK dout0_29 Vdout0_29ck44 = 0 time = 450
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=450.05n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 450
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=450.05n

* CHECK dout0_31 Vdout0_31ck44 = 0 time = 450
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=450.05n

* CHECK dout0_32 Vdout0_32ck44 = 0 time = 450
.meas tran vdout0_32ck44 FIND v(dout0_32) AT=450.05n

* CHECK dout0_0 Vdout0_0ck52 = 0 time = 530
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=530.05n

* CHECK dout0_1 Vdout0_1ck52 = 1.8 time = 530
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=530.05n

* CHECK dout0_2 Vdout0_2ck52 = 1.8 time = 530
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=530.05n

* CHECK dout0_3 Vdout0_3ck52 = 0 time = 530
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=530.05n

* CHECK dout0_4 Vdout0_4ck52 = 0 time = 530
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=530.05n

* CHECK dout0_5 Vdout0_5ck52 = 0 time = 530
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=530.05n

* CHECK dout0_6 Vdout0_6ck52 = 1.8 time = 530
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=530.05n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 530
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=530.05n

* CHECK dout0_8 Vdout0_8ck52 = 0 time = 530
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=530.05n

* CHECK dout0_9 Vdout0_9ck52 = 0 time = 530
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=530.05n

* CHECK dout0_10 Vdout0_10ck52 = 0 time = 530
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=530.05n

* CHECK dout0_11 Vdout0_11ck52 = 1.8 time = 530
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=530.05n

* CHECK dout0_12 Vdout0_12ck52 = 1.8 time = 530
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=530.05n

* CHECK dout0_13 Vdout0_13ck52 = 1.8 time = 530
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=530.05n

* CHECK dout0_14 Vdout0_14ck52 = 1.8 time = 530
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=530.05n

* CHECK dout0_15 Vdout0_15ck52 = 1.8 time = 530
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=530.05n

* CHECK dout0_16 Vdout0_16ck52 = 0 time = 530
.meas tran vdout0_16ck52 FIND v(dout0_16) AT=530.05n

* CHECK dout0_17 Vdout0_17ck52 = 1.8 time = 530
.meas tran vdout0_17ck52 FIND v(dout0_17) AT=530.05n

* CHECK dout0_18 Vdout0_18ck52 = 0 time = 530
.meas tran vdout0_18ck52 FIND v(dout0_18) AT=530.05n

* CHECK dout0_19 Vdout0_19ck52 = 1.8 time = 530
.meas tran vdout0_19ck52 FIND v(dout0_19) AT=530.05n

* CHECK dout0_20 Vdout0_20ck52 = 0 time = 530
.meas tran vdout0_20ck52 FIND v(dout0_20) AT=530.05n

* CHECK dout0_21 Vdout0_21ck52 = 0 time = 530
.meas tran vdout0_21ck52 FIND v(dout0_21) AT=530.05n

* CHECK dout0_22 Vdout0_22ck52 = 1.8 time = 530
.meas tran vdout0_22ck52 FIND v(dout0_22) AT=530.05n

* CHECK dout0_23 Vdout0_23ck52 = 0 time = 530
.meas tran vdout0_23ck52 FIND v(dout0_23) AT=530.05n

* CHECK dout0_24 Vdout0_24ck52 = 1.8 time = 530
.meas tran vdout0_24ck52 FIND v(dout0_24) AT=530.05n

* CHECK dout0_25 Vdout0_25ck52 = 1.8 time = 530
.meas tran vdout0_25ck52 FIND v(dout0_25) AT=530.05n

* CHECK dout0_26 Vdout0_26ck52 = 1.8 time = 530
.meas tran vdout0_26ck52 FIND v(dout0_26) AT=530.05n

* CHECK dout0_27 Vdout0_27ck52 = 1.8 time = 530
.meas tran vdout0_27ck52 FIND v(dout0_27) AT=530.05n

* CHECK dout0_28 Vdout0_28ck52 = 0 time = 530
.meas tran vdout0_28ck52 FIND v(dout0_28) AT=530.05n

* CHECK dout0_29 Vdout0_29ck52 = 1.8 time = 530
.meas tran vdout0_29ck52 FIND v(dout0_29) AT=530.05n

* CHECK dout0_30 Vdout0_30ck52 = 1.8 time = 530
.meas tran vdout0_30ck52 FIND v(dout0_30) AT=530.05n

* CHECK dout0_31 Vdout0_31ck52 = 0 time = 530
.meas tran vdout0_31ck52 FIND v(dout0_31) AT=530.05n

* CHECK dout0_32 Vdout0_32ck52 = 0 time = 530
.meas tran vdout0_32ck52 FIND v(dout0_32) AT=530.05n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 590
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=590.05n

* CHECK dout0_1 Vdout0_1ck58 = 1.8 time = 590
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=590.05n

* CHECK dout0_2 Vdout0_2ck58 = 1.8 time = 590
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=590.05n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 590
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=590.05n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 590
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=590.05n

* CHECK dout0_5 Vdout0_5ck58 = 0 time = 590
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=590.05n

* CHECK dout0_6 Vdout0_6ck58 = 1.8 time = 590
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=590.05n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 590
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=590.05n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 590
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=590.05n

* CHECK dout0_9 Vdout0_9ck58 = 0 time = 590
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=590.05n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 590
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=590.05n

* CHECK dout0_11 Vdout0_11ck58 = 1.8 time = 590
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=590.05n

* CHECK dout0_12 Vdout0_12ck58 = 1.8 time = 590
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=590.05n

* CHECK dout0_13 Vdout0_13ck58 = 1.8 time = 590
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=590.05n

* CHECK dout0_14 Vdout0_14ck58 = 1.8 time = 590
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=590.05n

* CHECK dout0_15 Vdout0_15ck58 = 1.8 time = 590
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=590.05n

* CHECK dout0_16 Vdout0_16ck58 = 0 time = 590
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=590.05n

* CHECK dout0_17 Vdout0_17ck58 = 1.8 time = 590
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=590.05n

* CHECK dout0_18 Vdout0_18ck58 = 0 time = 590
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=590.05n

* CHECK dout0_19 Vdout0_19ck58 = 1.8 time = 590
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=590.05n

* CHECK dout0_20 Vdout0_20ck58 = 0 time = 590
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=590.05n

* CHECK dout0_21 Vdout0_21ck58 = 0 time = 590
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=590.05n

* CHECK dout0_22 Vdout0_22ck58 = 1.8 time = 590
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=590.05n

* CHECK dout0_23 Vdout0_23ck58 = 0 time = 590
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=590.05n

* CHECK dout0_24 Vdout0_24ck58 = 1.8 time = 590
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=590.05n

* CHECK dout0_25 Vdout0_25ck58 = 1.8 time = 590
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=590.05n

* CHECK dout0_26 Vdout0_26ck58 = 1.8 time = 590
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=590.05n

* CHECK dout0_27 Vdout0_27ck58 = 1.8 time = 590
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=590.05n

* CHECK dout0_28 Vdout0_28ck58 = 0 time = 590
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=590.05n

* CHECK dout0_29 Vdout0_29ck58 = 1.8 time = 590
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=590.05n

* CHECK dout0_30 Vdout0_30ck58 = 1.8 time = 590
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=590.05n

* CHECK dout0_31 Vdout0_31ck58 = 0 time = 590
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=590.05n

* CHECK dout0_32 Vdout0_32ck58 = 0 time = 590
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=590.05n

* CHECK dout0_0 Vdout0_0ck61 = 0 time = 620
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=620.05n

* CHECK dout0_1 Vdout0_1ck61 = 1.8 time = 620
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=620.05n

* CHECK dout0_2 Vdout0_2ck61 = 0 time = 620
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=620.05n

* CHECK dout0_3 Vdout0_3ck61 = 0 time = 620
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=620.05n

* CHECK dout0_4 Vdout0_4ck61 = 1.8 time = 620
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=620.05n

* CHECK dout0_5 Vdout0_5ck61 = 1.8 time = 620
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=620.05n

* CHECK dout0_6 Vdout0_6ck61 = 1.8 time = 620
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=620.05n

* CHECK dout0_7 Vdout0_7ck61 = 1.8 time = 620
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=620.05n

* CHECK dout0_8 Vdout0_8ck61 = 1.8 time = 620
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=620.05n

* CHECK dout0_9 Vdout0_9ck61 = 0 time = 620
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=620.05n

* CHECK dout0_10 Vdout0_10ck61 = 1.8 time = 620
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=620.05n

* CHECK dout0_11 Vdout0_11ck61 = 0 time = 620
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=620.05n

* CHECK dout0_12 Vdout0_12ck61 = 1.8 time = 620
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=620.05n

* CHECK dout0_13 Vdout0_13ck61 = 1.8 time = 620
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=620.05n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 620
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=620.05n

* CHECK dout0_15 Vdout0_15ck61 = 1.8 time = 620
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=620.05n

* CHECK dout0_16 Vdout0_16ck61 = 0 time = 620
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=620.05n

* CHECK dout0_17 Vdout0_17ck61 = 1.8 time = 620
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=620.05n

* CHECK dout0_18 Vdout0_18ck61 = 1.8 time = 620
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=620.05n

* CHECK dout0_19 Vdout0_19ck61 = 0 time = 620
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=620.05n

* CHECK dout0_20 Vdout0_20ck61 = 0 time = 620
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=620.05n

* CHECK dout0_21 Vdout0_21ck61 = 1.8 time = 620
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=620.05n

* CHECK dout0_22 Vdout0_22ck61 = 1.8 time = 620
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=620.05n

* CHECK dout0_23 Vdout0_23ck61 = 0 time = 620
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=620.05n

* CHECK dout0_24 Vdout0_24ck61 = 0 time = 620
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=620.05n

* CHECK dout0_25 Vdout0_25ck61 = 1.8 time = 620
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=620.05n

* CHECK dout0_26 Vdout0_26ck61 = 1.8 time = 620
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=620.05n

* CHECK dout0_27 Vdout0_27ck61 = 1.8 time = 620
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=620.05n

* CHECK dout0_28 Vdout0_28ck61 = 1.8 time = 620
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=620.05n

* CHECK dout0_29 Vdout0_29ck61 = 0 time = 620
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=620.05n

* CHECK dout0_30 Vdout0_30ck61 = 0 time = 620
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=620.05n

* CHECK dout0_31 Vdout0_31ck61 = 0 time = 620
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=620.05n

* CHECK dout0_32 Vdout0_32ck61 = 0 time = 620
.meas tran vdout0_32ck61 FIND v(dout0_32) AT=620.05n

* CHECK dout0_0 Vdout0_0ck63 = 0 time = 640
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=640.05n

* CHECK dout0_1 Vdout0_1ck63 = 1.8 time = 640
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=640.05n

* CHECK dout0_2 Vdout0_2ck63 = 1.8 time = 640
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=640.05n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 640
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=640.05n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 640
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=640.05n

* CHECK dout0_5 Vdout0_5ck63 = 0 time = 640
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=640.05n

* CHECK dout0_6 Vdout0_6ck63 = 1.8 time = 640
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=640.05n

* CHECK dout0_7 Vdout0_7ck63 = 0 time = 640
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=640.05n

* CHECK dout0_8 Vdout0_8ck63 = 0 time = 640
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=640.05n

* CHECK dout0_9 Vdout0_9ck63 = 0 time = 640
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=640.05n

* CHECK dout0_10 Vdout0_10ck63 = 0 time = 640
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=640.05n

* CHECK dout0_11 Vdout0_11ck63 = 1.8 time = 640
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=640.05n

* CHECK dout0_12 Vdout0_12ck63 = 1.8 time = 640
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=640.05n

* CHECK dout0_13 Vdout0_13ck63 = 1.8 time = 640
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=640.05n

* CHECK dout0_14 Vdout0_14ck63 = 1.8 time = 640
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=640.05n

* CHECK dout0_15 Vdout0_15ck63 = 1.8 time = 640
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=640.05n

* CHECK dout0_16 Vdout0_16ck63 = 0 time = 640
.meas tran vdout0_16ck63 FIND v(dout0_16) AT=640.05n

* CHECK dout0_17 Vdout0_17ck63 = 1.8 time = 640
.meas tran vdout0_17ck63 FIND v(dout0_17) AT=640.05n

* CHECK dout0_18 Vdout0_18ck63 = 0 time = 640
.meas tran vdout0_18ck63 FIND v(dout0_18) AT=640.05n

* CHECK dout0_19 Vdout0_19ck63 = 1.8 time = 640
.meas tran vdout0_19ck63 FIND v(dout0_19) AT=640.05n

* CHECK dout0_20 Vdout0_20ck63 = 0 time = 640
.meas tran vdout0_20ck63 FIND v(dout0_20) AT=640.05n

* CHECK dout0_21 Vdout0_21ck63 = 0 time = 640
.meas tran vdout0_21ck63 FIND v(dout0_21) AT=640.05n

* CHECK dout0_22 Vdout0_22ck63 = 1.8 time = 640
.meas tran vdout0_22ck63 FIND v(dout0_22) AT=640.05n

* CHECK dout0_23 Vdout0_23ck63 = 0 time = 640
.meas tran vdout0_23ck63 FIND v(dout0_23) AT=640.05n

* CHECK dout0_24 Vdout0_24ck63 = 1.8 time = 640
.meas tran vdout0_24ck63 FIND v(dout0_24) AT=640.05n

* CHECK dout0_25 Vdout0_25ck63 = 1.8 time = 640
.meas tran vdout0_25ck63 FIND v(dout0_25) AT=640.05n

* CHECK dout0_26 Vdout0_26ck63 = 1.8 time = 640
.meas tran vdout0_26ck63 FIND v(dout0_26) AT=640.05n

* CHECK dout0_27 Vdout0_27ck63 = 1.8 time = 640
.meas tran vdout0_27ck63 FIND v(dout0_27) AT=640.05n

* CHECK dout0_28 Vdout0_28ck63 = 0 time = 640
.meas tran vdout0_28ck63 FIND v(dout0_28) AT=640.05n

* CHECK dout0_29 Vdout0_29ck63 = 1.8 time = 640
.meas tran vdout0_29ck63 FIND v(dout0_29) AT=640.05n

* CHECK dout0_30 Vdout0_30ck63 = 1.8 time = 640
.meas tran vdout0_30ck63 FIND v(dout0_30) AT=640.05n

* CHECK dout0_31 Vdout0_31ck63 = 0 time = 640
.meas tran vdout0_31ck63 FIND v(dout0_31) AT=640.05n

* CHECK dout0_32 Vdout0_32ck63 = 0 time = 640
.meas tran vdout0_32ck63 FIND v(dout0_32) AT=640.05n

* CHECK dout0_0 Vdout0_0ck64 = 1.8 time = 650
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=650.05n

* CHECK dout0_1 Vdout0_1ck64 = 0 time = 650
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=650.05n

* CHECK dout0_2 Vdout0_2ck64 = 1.8 time = 650
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=650.05n

* CHECK dout0_3 Vdout0_3ck64 = 1.8 time = 650
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=650.05n

* CHECK dout0_4 Vdout0_4ck64 = 1.8 time = 650
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=650.05n

* CHECK dout0_5 Vdout0_5ck64 = 0 time = 650
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=650.05n

* CHECK dout0_6 Vdout0_6ck64 = 0 time = 650
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=650.05n

* CHECK dout0_7 Vdout0_7ck64 = 0 time = 650
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=650.05n

* CHECK dout0_8 Vdout0_8ck64 = 1.8 time = 650
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=650.05n

* CHECK dout0_9 Vdout0_9ck64 = 0 time = 650
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=650.05n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 650
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=650.05n

* CHECK dout0_11 Vdout0_11ck64 = 1.8 time = 650
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=650.05n

* CHECK dout0_12 Vdout0_12ck64 = 1.8 time = 650
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=650.05n

* CHECK dout0_13 Vdout0_13ck64 = 0 time = 650
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=650.05n

* CHECK dout0_14 Vdout0_14ck64 = 1.8 time = 650
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=650.05n

* CHECK dout0_15 Vdout0_15ck64 = 0 time = 650
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=650.05n

* CHECK dout0_16 Vdout0_16ck64 = 0 time = 650
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=650.05n

* CHECK dout0_17 Vdout0_17ck64 = 0 time = 650
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=650.05n

* CHECK dout0_18 Vdout0_18ck64 = 0 time = 650
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=650.05n

* CHECK dout0_19 Vdout0_19ck64 = 1.8 time = 650
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=650.05n

* CHECK dout0_20 Vdout0_20ck64 = 1.8 time = 650
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=650.05n

* CHECK dout0_21 Vdout0_21ck64 = 0 time = 650
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=650.05n

* CHECK dout0_22 Vdout0_22ck64 = 0 time = 650
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=650.05n

* CHECK dout0_23 Vdout0_23ck64 = 0 time = 650
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=650.05n

* CHECK dout0_24 Vdout0_24ck64 = 1.8 time = 650
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=650.05n

* CHECK dout0_25 Vdout0_25ck64 = 1.8 time = 650
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=650.05n

* CHECK dout0_26 Vdout0_26ck64 = 0 time = 650
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=650.05n

* CHECK dout0_27 Vdout0_27ck64 = 1.8 time = 650
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=650.05n

* CHECK dout0_28 Vdout0_28ck64 = 0 time = 650
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=650.05n

* CHECK dout0_29 Vdout0_29ck64 = 0 time = 650
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=650.05n

* CHECK dout0_30 Vdout0_30ck64 = 1.8 time = 650
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=650.05n

* CHECK dout0_31 Vdout0_31ck64 = 0 time = 650
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=650.05n

* CHECK dout0_32 Vdout0_32ck64 = 0 time = 650
.meas tran vdout0_32ck64 FIND v(dout0_32) AT=650.05n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 670
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=670.05n

* CHECK dout0_1 Vdout0_1ck66 = 1.8 time = 670
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=670.05n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 670
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=670.05n

* CHECK dout0_3 Vdout0_3ck66 = 0 time = 670
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=670.05n

* CHECK dout0_4 Vdout0_4ck66 = 1.8 time = 670
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=670.05n

* CHECK dout0_5 Vdout0_5ck66 = 1.8 time = 670
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=670.05n

* CHECK dout0_6 Vdout0_6ck66 = 1.8 time = 670
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=670.05n

* CHECK dout0_7 Vdout0_7ck66 = 1.8 time = 670
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=670.05n

* CHECK dout0_8 Vdout0_8ck66 = 1.8 time = 670
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=670.05n

* CHECK dout0_9 Vdout0_9ck66 = 0 time = 670
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=670.05n

* CHECK dout0_10 Vdout0_10ck66 = 1.8 time = 670
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=670.05n

* CHECK dout0_11 Vdout0_11ck66 = 0 time = 670
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=670.05n

* CHECK dout0_12 Vdout0_12ck66 = 1.8 time = 670
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=670.05n

* CHECK dout0_13 Vdout0_13ck66 = 1.8 time = 670
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=670.05n

* CHECK dout0_14 Vdout0_14ck66 = 0 time = 670
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=670.05n

* CHECK dout0_15 Vdout0_15ck66 = 1.8 time = 670
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=670.05n

* CHECK dout0_16 Vdout0_16ck66 = 0 time = 670
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=670.05n

* CHECK dout0_17 Vdout0_17ck66 = 1.8 time = 670
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=670.05n

* CHECK dout0_18 Vdout0_18ck66 = 1.8 time = 670
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=670.05n

* CHECK dout0_19 Vdout0_19ck66 = 0 time = 670
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=670.05n

* CHECK dout0_20 Vdout0_20ck66 = 0 time = 670
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=670.05n

* CHECK dout0_21 Vdout0_21ck66 = 1.8 time = 670
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=670.05n

* CHECK dout0_22 Vdout0_22ck66 = 1.8 time = 670
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=670.05n

* CHECK dout0_23 Vdout0_23ck66 = 0 time = 670
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=670.05n

* CHECK dout0_24 Vdout0_24ck66 = 0 time = 670
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=670.05n

* CHECK dout0_25 Vdout0_25ck66 = 1.8 time = 670
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=670.05n

* CHECK dout0_26 Vdout0_26ck66 = 1.8 time = 670
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=670.05n

* CHECK dout0_27 Vdout0_27ck66 = 1.8 time = 670
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=670.05n

* CHECK dout0_28 Vdout0_28ck66 = 1.8 time = 670
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=670.05n

* CHECK dout0_29 Vdout0_29ck66 = 0 time = 670
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=670.05n

* CHECK dout0_30 Vdout0_30ck66 = 0 time = 670
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=670.05n

* CHECK dout0_31 Vdout0_31ck66 = 0 time = 670
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=670.05n

* CHECK dout0_32 Vdout0_32ck66 = 0 time = 670
.meas tran vdout0_32ck66 FIND v(dout0_32) AT=670.05n

* CHECK dout0_0 Vdout0_0ck68 = 0 time = 690
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=690.05n

* CHECK dout0_1 Vdout0_1ck68 = 1.8 time = 690
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=690.05n

* CHECK dout0_2 Vdout0_2ck68 = 0 time = 690
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=690.05n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 690
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=690.05n

* CHECK dout0_4 Vdout0_4ck68 = 1.8 time = 690
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=690.05n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 690
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=690.05n

* CHECK dout0_6 Vdout0_6ck68 = 1.8 time = 690
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=690.05n

* CHECK dout0_7 Vdout0_7ck68 = 1.8 time = 690
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=690.05n

* CHECK dout0_8 Vdout0_8ck68 = 1.8 time = 690
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=690.05n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 690
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=690.05n

* CHECK dout0_10 Vdout0_10ck68 = 1.8 time = 690
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=690.05n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 690
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=690.05n

* CHECK dout0_12 Vdout0_12ck68 = 1.8 time = 690
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=690.05n

* CHECK dout0_13 Vdout0_13ck68 = 1.8 time = 690
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=690.05n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 690
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=690.05n

* CHECK dout0_15 Vdout0_15ck68 = 1.8 time = 690
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=690.05n

* CHECK dout0_16 Vdout0_16ck68 = 0 time = 690
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=690.05n

* CHECK dout0_17 Vdout0_17ck68 = 1.8 time = 690
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=690.05n

* CHECK dout0_18 Vdout0_18ck68 = 1.8 time = 690
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=690.05n

* CHECK dout0_19 Vdout0_19ck68 = 0 time = 690
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=690.05n

* CHECK dout0_20 Vdout0_20ck68 = 0 time = 690
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=690.05n

* CHECK dout0_21 Vdout0_21ck68 = 1.8 time = 690
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=690.05n

* CHECK dout0_22 Vdout0_22ck68 = 1.8 time = 690
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=690.05n

* CHECK dout0_23 Vdout0_23ck68 = 0 time = 690
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=690.05n

* CHECK dout0_24 Vdout0_24ck68 = 0 time = 690
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=690.05n

* CHECK dout0_25 Vdout0_25ck68 = 1.8 time = 690
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=690.05n

* CHECK dout0_26 Vdout0_26ck68 = 1.8 time = 690
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=690.05n

* CHECK dout0_27 Vdout0_27ck68 = 1.8 time = 690
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=690.05n

* CHECK dout0_28 Vdout0_28ck68 = 1.8 time = 690
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=690.05n

* CHECK dout0_29 Vdout0_29ck68 = 0 time = 690
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=690.05n

* CHECK dout0_30 Vdout0_30ck68 = 0 time = 690
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=690.05n

* CHECK dout0_31 Vdout0_31ck68 = 0 time = 690
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=690.05n

* CHECK dout0_32 Vdout0_32ck68 = 0 time = 690
.meas tran vdout0_32ck68 FIND v(dout0_32) AT=690.05n

* CHECK dout0_0 Vdout0_0ck69 = 1.8 time = 700
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=700.05n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 700
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=700.05n

* CHECK dout0_2 Vdout0_2ck69 = 1.8 time = 700
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=700.05n

* CHECK dout0_3 Vdout0_3ck69 = 0 time = 700
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=700.05n

* CHECK dout0_4 Vdout0_4ck69 = 0 time = 700
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=700.05n

* CHECK dout0_5 Vdout0_5ck69 = 1.8 time = 700
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=700.05n

* CHECK dout0_6 Vdout0_6ck69 = 0 time = 700
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=700.05n

* CHECK dout0_7 Vdout0_7ck69 = 1.8 time = 700
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=700.05n

* CHECK dout0_8 Vdout0_8ck69 = 1.8 time = 700
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=700.05n

* CHECK dout0_9 Vdout0_9ck69 = 0 time = 700
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=700.05n

* CHECK dout0_10 Vdout0_10ck69 = 0 time = 700
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=700.05n

* CHECK dout0_11 Vdout0_11ck69 = 0 time = 700
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=700.05n

* CHECK dout0_12 Vdout0_12ck69 = 1.8 time = 700
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=700.05n

* CHECK dout0_13 Vdout0_13ck69 = 1.8 time = 700
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=700.05n

* CHECK dout0_14 Vdout0_14ck69 = 1.8 time = 700
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=700.05n

* CHECK dout0_15 Vdout0_15ck69 = 1.8 time = 700
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=700.05n

* CHECK dout0_16 Vdout0_16ck69 = 1.8 time = 700
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=700.05n

* CHECK dout0_17 Vdout0_17ck69 = 0 time = 700
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=700.05n

* CHECK dout0_18 Vdout0_18ck69 = 0 time = 700
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=700.05n

* CHECK dout0_19 Vdout0_19ck69 = 1.8 time = 700
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=700.05n

* CHECK dout0_20 Vdout0_20ck69 = 1.8 time = 700
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=700.05n

* CHECK dout0_21 Vdout0_21ck69 = 1.8 time = 700
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=700.05n

* CHECK dout0_22 Vdout0_22ck69 = 0 time = 700
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=700.05n

* CHECK dout0_23 Vdout0_23ck69 = 1.8 time = 700
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=700.05n

* CHECK dout0_24 Vdout0_24ck69 = 0 time = 700
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=700.05n

* CHECK dout0_25 Vdout0_25ck69 = 1.8 time = 700
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=700.05n

* CHECK dout0_26 Vdout0_26ck69 = 0 time = 700
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=700.05n

* CHECK dout0_27 Vdout0_27ck69 = 0 time = 700
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=700.05n

* CHECK dout0_28 Vdout0_28ck69 = 0 time = 700
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=700.05n

* CHECK dout0_29 Vdout0_29ck69 = 1.8 time = 700
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=700.05n

* CHECK dout0_30 Vdout0_30ck69 = 0 time = 700
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=700.05n

* CHECK dout0_31 Vdout0_31ck69 = 0 time = 700
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=700.05n

* CHECK dout0_32 Vdout0_32ck69 = 0 time = 700
.meas tran vdout0_32ck69 FIND v(dout0_32) AT=700.05n

* CHECK dout0_0 Vdout0_0ck71 = 0 time = 720
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=720.05n

* CHECK dout0_1 Vdout0_1ck71 = 1.8 time = 720
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=720.05n

* CHECK dout0_2 Vdout0_2ck71 = 0 time = 720
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=720.05n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 720
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=720.05n

* CHECK dout0_4 Vdout0_4ck71 = 1.8 time = 720
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=720.05n

* CHECK dout0_5 Vdout0_5ck71 = 1.8 time = 720
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=720.05n

* CHECK dout0_6 Vdout0_6ck71 = 1.8 time = 720
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=720.05n

* CHECK dout0_7 Vdout0_7ck71 = 1.8 time = 720
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=720.05n

* CHECK dout0_8 Vdout0_8ck71 = 1.8 time = 720
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=720.05n

* CHECK dout0_9 Vdout0_9ck71 = 0 time = 720
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=720.05n

* CHECK dout0_10 Vdout0_10ck71 = 1.8 time = 720
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=720.05n

* CHECK dout0_11 Vdout0_11ck71 = 0 time = 720
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=720.05n

* CHECK dout0_12 Vdout0_12ck71 = 1.8 time = 720
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=720.05n

* CHECK dout0_13 Vdout0_13ck71 = 1.8 time = 720
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=720.05n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 720
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=720.05n

* CHECK dout0_15 Vdout0_15ck71 = 1.8 time = 720
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=720.05n

* CHECK dout0_16 Vdout0_16ck71 = 0 time = 720
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=720.05n

* CHECK dout0_17 Vdout0_17ck71 = 1.8 time = 720
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=720.05n

* CHECK dout0_18 Vdout0_18ck71 = 1.8 time = 720
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=720.05n

* CHECK dout0_19 Vdout0_19ck71 = 0 time = 720
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=720.05n

* CHECK dout0_20 Vdout0_20ck71 = 0 time = 720
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=720.05n

* CHECK dout0_21 Vdout0_21ck71 = 1.8 time = 720
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=720.05n

* CHECK dout0_22 Vdout0_22ck71 = 1.8 time = 720
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=720.05n

* CHECK dout0_23 Vdout0_23ck71 = 0 time = 720
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=720.05n

* CHECK dout0_24 Vdout0_24ck71 = 0 time = 720
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=720.05n

* CHECK dout0_25 Vdout0_25ck71 = 1.8 time = 720
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=720.05n

* CHECK dout0_26 Vdout0_26ck71 = 1.8 time = 720
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=720.05n

* CHECK dout0_27 Vdout0_27ck71 = 1.8 time = 720
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=720.05n

* CHECK dout0_28 Vdout0_28ck71 = 1.8 time = 720
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=720.05n

* CHECK dout0_29 Vdout0_29ck71 = 0 time = 720
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=720.05n

* CHECK dout0_30 Vdout0_30ck71 = 0 time = 720
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=720.05n

* CHECK dout0_31 Vdout0_31ck71 = 0 time = 720
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=720.05n

* CHECK dout0_32 Vdout0_32ck71 = 0 time = 720
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=720.05n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 730
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=730.05n

* CHECK dout0_1 Vdout0_1ck72 = 0 time = 730
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=730.05n

* CHECK dout0_2 Vdout0_2ck72 = 1.8 time = 730
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=730.05n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 730
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=730.05n

* CHECK dout0_4 Vdout0_4ck72 = 0 time = 730
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=730.05n

* CHECK dout0_5 Vdout0_5ck72 = 0 time = 730
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=730.05n

* CHECK dout0_6 Vdout0_6ck72 = 1.8 time = 730
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=730.05n

* CHECK dout0_7 Vdout0_7ck72 = 0 time = 730
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=730.05n

* CHECK dout0_8 Vdout0_8ck72 = 1.8 time = 730
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=730.05n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 730
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=730.05n

* CHECK dout0_10 Vdout0_10ck72 = 1.8 time = 730
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=730.05n

* CHECK dout0_11 Vdout0_11ck72 = 1.8 time = 730
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=730.05n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 730
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=730.05n

* CHECK dout0_13 Vdout0_13ck72 = 0 time = 730
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=730.05n

* CHECK dout0_14 Vdout0_14ck72 = 1.8 time = 730
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=730.05n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 730
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=730.05n

* CHECK dout0_16 Vdout0_16ck72 = 0 time = 730
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=730.05n

* CHECK dout0_17 Vdout0_17ck72 = 1.8 time = 730
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=730.05n

* CHECK dout0_18 Vdout0_18ck72 = 0 time = 730
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=730.05n

* CHECK dout0_19 Vdout0_19ck72 = 1.8 time = 730
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=730.05n

* CHECK dout0_20 Vdout0_20ck72 = 0 time = 730
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=730.05n

* CHECK dout0_21 Vdout0_21ck72 = 0 time = 730
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=730.05n

* CHECK dout0_22 Vdout0_22ck72 = 0 time = 730
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=730.05n

* CHECK dout0_23 Vdout0_23ck72 = 0 time = 730
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=730.05n

* CHECK dout0_24 Vdout0_24ck72 = 0 time = 730
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=730.05n

* CHECK dout0_25 Vdout0_25ck72 = 0 time = 730
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=730.05n

* CHECK dout0_26 Vdout0_26ck72 = 1.8 time = 730
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=730.05n

* CHECK dout0_27 Vdout0_27ck72 = 0 time = 730
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=730.05n

* CHECK dout0_28 Vdout0_28ck72 = 1.8 time = 730
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=730.05n

* CHECK dout0_29 Vdout0_29ck72 = 0 time = 730
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=730.05n

* CHECK dout0_30 Vdout0_30ck72 = 1.8 time = 730
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=730.05n

* CHECK dout0_31 Vdout0_31ck72 = 0 time = 730
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=730.05n

* CHECK dout0_32 Vdout0_32ck72 = 0 time = 730
.meas tran vdout0_32ck72 FIND v(dout0_32) AT=730.05n

* CHECK dout0_0 Vdout0_0ck75 = 0 time = 760
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=760.05n

* CHECK dout0_1 Vdout0_1ck75 = 1.8 time = 760
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=760.05n

* CHECK dout0_2 Vdout0_2ck75 = 1.8 time = 760
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=760.05n

* CHECK dout0_3 Vdout0_3ck75 = 0 time = 760
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=760.05n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 760
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=760.05n

* CHECK dout0_5 Vdout0_5ck75 = 0 time = 760
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=760.05n

* CHECK dout0_6 Vdout0_6ck75 = 1.8 time = 760
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=760.05n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 760
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=760.05n

* CHECK dout0_8 Vdout0_8ck75 = 0 time = 760
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=760.05n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 760
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=760.05n

* CHECK dout0_10 Vdout0_10ck75 = 0 time = 760
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=760.05n

* CHECK dout0_11 Vdout0_11ck75 = 1.8 time = 760
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=760.05n

* CHECK dout0_12 Vdout0_12ck75 = 1.8 time = 760
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=760.05n

* CHECK dout0_13 Vdout0_13ck75 = 1.8 time = 760
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=760.05n

* CHECK dout0_14 Vdout0_14ck75 = 1.8 time = 760
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=760.05n

* CHECK dout0_15 Vdout0_15ck75 = 1.8 time = 760
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=760.05n

* CHECK dout0_16 Vdout0_16ck75 = 0 time = 760
.meas tran vdout0_16ck75 FIND v(dout0_16) AT=760.05n

* CHECK dout0_17 Vdout0_17ck75 = 1.8 time = 760
.meas tran vdout0_17ck75 FIND v(dout0_17) AT=760.05n

* CHECK dout0_18 Vdout0_18ck75 = 0 time = 760
.meas tran vdout0_18ck75 FIND v(dout0_18) AT=760.05n

* CHECK dout0_19 Vdout0_19ck75 = 1.8 time = 760
.meas tran vdout0_19ck75 FIND v(dout0_19) AT=760.05n

* CHECK dout0_20 Vdout0_20ck75 = 0 time = 760
.meas tran vdout0_20ck75 FIND v(dout0_20) AT=760.05n

* CHECK dout0_21 Vdout0_21ck75 = 0 time = 760
.meas tran vdout0_21ck75 FIND v(dout0_21) AT=760.05n

* CHECK dout0_22 Vdout0_22ck75 = 1.8 time = 760
.meas tran vdout0_22ck75 FIND v(dout0_22) AT=760.05n

* CHECK dout0_23 Vdout0_23ck75 = 0 time = 760
.meas tran vdout0_23ck75 FIND v(dout0_23) AT=760.05n

* CHECK dout0_24 Vdout0_24ck75 = 1.8 time = 760
.meas tran vdout0_24ck75 FIND v(dout0_24) AT=760.05n

* CHECK dout0_25 Vdout0_25ck75 = 1.8 time = 760
.meas tran vdout0_25ck75 FIND v(dout0_25) AT=760.05n

* CHECK dout0_26 Vdout0_26ck75 = 1.8 time = 760
.meas tran vdout0_26ck75 FIND v(dout0_26) AT=760.05n

* CHECK dout0_27 Vdout0_27ck75 = 1.8 time = 760
.meas tran vdout0_27ck75 FIND v(dout0_27) AT=760.05n

* CHECK dout0_28 Vdout0_28ck75 = 0 time = 760
.meas tran vdout0_28ck75 FIND v(dout0_28) AT=760.05n

* CHECK dout0_29 Vdout0_29ck75 = 1.8 time = 760
.meas tran vdout0_29ck75 FIND v(dout0_29) AT=760.05n

* CHECK dout0_30 Vdout0_30ck75 = 1.8 time = 760
.meas tran vdout0_30ck75 FIND v(dout0_30) AT=760.05n

* CHECK dout0_31 Vdout0_31ck75 = 0 time = 760
.meas tran vdout0_31ck75 FIND v(dout0_31) AT=760.05n

* CHECK dout0_32 Vdout0_32ck75 = 0 time = 760
.meas tran vdout0_32ck75 FIND v(dout0_32) AT=760.05n

* CHECK dout0_0 Vdout0_0ck78 = 0 time = 790
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=790.05n

* CHECK dout0_1 Vdout0_1ck78 = 1.8 time = 790
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=790.05n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 790
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=790.05n

* CHECK dout0_3 Vdout0_3ck78 = 0 time = 790
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=790.05n

* CHECK dout0_4 Vdout0_4ck78 = 1.8 time = 790
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=790.05n

* CHECK dout0_5 Vdout0_5ck78 = 1.8 time = 790
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=790.05n

* CHECK dout0_6 Vdout0_6ck78 = 1.8 time = 790
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=790.05n

* CHECK dout0_7 Vdout0_7ck78 = 1.8 time = 790
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=790.05n

* CHECK dout0_8 Vdout0_8ck78 = 1.8 time = 790
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=790.05n

* CHECK dout0_9 Vdout0_9ck78 = 0 time = 790
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=790.05n

* CHECK dout0_10 Vdout0_10ck78 = 1.8 time = 790
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=790.05n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 790
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=790.05n

* CHECK dout0_12 Vdout0_12ck78 = 1.8 time = 790
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=790.05n

* CHECK dout0_13 Vdout0_13ck78 = 1.8 time = 790
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=790.05n

* CHECK dout0_14 Vdout0_14ck78 = 0 time = 790
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=790.05n

* CHECK dout0_15 Vdout0_15ck78 = 1.8 time = 790
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=790.05n

* CHECK dout0_16 Vdout0_16ck78 = 0 time = 790
.meas tran vdout0_16ck78 FIND v(dout0_16) AT=790.05n

* CHECK dout0_17 Vdout0_17ck78 = 1.8 time = 790
.meas tran vdout0_17ck78 FIND v(dout0_17) AT=790.05n

* CHECK dout0_18 Vdout0_18ck78 = 1.8 time = 790
.meas tran vdout0_18ck78 FIND v(dout0_18) AT=790.05n

* CHECK dout0_19 Vdout0_19ck78 = 0 time = 790
.meas tran vdout0_19ck78 FIND v(dout0_19) AT=790.05n

* CHECK dout0_20 Vdout0_20ck78 = 0 time = 790
.meas tran vdout0_20ck78 FIND v(dout0_20) AT=790.05n

* CHECK dout0_21 Vdout0_21ck78 = 1.8 time = 790
.meas tran vdout0_21ck78 FIND v(dout0_21) AT=790.05n

* CHECK dout0_22 Vdout0_22ck78 = 1.8 time = 790
.meas tran vdout0_22ck78 FIND v(dout0_22) AT=790.05n

* CHECK dout0_23 Vdout0_23ck78 = 0 time = 790
.meas tran vdout0_23ck78 FIND v(dout0_23) AT=790.05n

* CHECK dout0_24 Vdout0_24ck78 = 0 time = 790
.meas tran vdout0_24ck78 FIND v(dout0_24) AT=790.05n

* CHECK dout0_25 Vdout0_25ck78 = 1.8 time = 790
.meas tran vdout0_25ck78 FIND v(dout0_25) AT=790.05n

* CHECK dout0_26 Vdout0_26ck78 = 1.8 time = 790
.meas tran vdout0_26ck78 FIND v(dout0_26) AT=790.05n

* CHECK dout0_27 Vdout0_27ck78 = 1.8 time = 790
.meas tran vdout0_27ck78 FIND v(dout0_27) AT=790.05n

* CHECK dout0_28 Vdout0_28ck78 = 1.8 time = 790
.meas tran vdout0_28ck78 FIND v(dout0_28) AT=790.05n

* CHECK dout0_29 Vdout0_29ck78 = 0 time = 790
.meas tran vdout0_29ck78 FIND v(dout0_29) AT=790.05n

* CHECK dout0_30 Vdout0_30ck78 = 0 time = 790
.meas tran vdout0_30ck78 FIND v(dout0_30) AT=790.05n

* CHECK dout0_31 Vdout0_31ck78 = 0 time = 790
.meas tran vdout0_31ck78 FIND v(dout0_31) AT=790.05n

* CHECK dout0_32 Vdout0_32ck78 = 0 time = 790
.meas tran vdout0_32ck78 FIND v(dout0_32) AT=790.05n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 800
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=800.05n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 800
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=800.05n

* CHECK dout0_2 Vdout0_2ck79 = 1.8 time = 800
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=800.05n

* CHECK dout0_3 Vdout0_3ck79 = 1.8 time = 800
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=800.05n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 800
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=800.05n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 800
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=800.05n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 800
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=800.05n

* CHECK dout0_7 Vdout0_7ck79 = 1.8 time = 800
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=800.05n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 800
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=800.05n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 800
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=800.05n

* CHECK dout0_10 Vdout0_10ck79 = 1.8 time = 800
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=800.05n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 800
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=800.05n

* CHECK dout0_12 Vdout0_12ck79 = 0 time = 800
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=800.05n

* CHECK dout0_13 Vdout0_13ck79 = 0 time = 800
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=800.05n

* CHECK dout0_14 Vdout0_14ck79 = 1.8 time = 800
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=800.05n

* CHECK dout0_15 Vdout0_15ck79 = 1.8 time = 800
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=800.05n

* CHECK dout0_16 Vdout0_16ck79 = 0 time = 800
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=800.05n

* CHECK dout0_17 Vdout0_17ck79 = 0 time = 800
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=800.05n

* CHECK dout0_18 Vdout0_18ck79 = 0 time = 800
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=800.05n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 800
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=800.05n

* CHECK dout0_20 Vdout0_20ck79 = 1.8 time = 800
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=800.05n

* CHECK dout0_21 Vdout0_21ck79 = 0 time = 800
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=800.05n

* CHECK dout0_22 Vdout0_22ck79 = 1.8 time = 800
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=800.05n

* CHECK dout0_23 Vdout0_23ck79 = 1.8 time = 800
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=800.05n

* CHECK dout0_24 Vdout0_24ck79 = 1.8 time = 800
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=800.05n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 800
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=800.05n

* CHECK dout0_26 Vdout0_26ck79 = 1.8 time = 800
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=800.05n

* CHECK dout0_27 Vdout0_27ck79 = 0 time = 800
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=800.05n

* CHECK dout0_28 Vdout0_28ck79 = 1.8 time = 800
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=800.05n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 800
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=800.05n

* CHECK dout0_30 Vdout0_30ck79 = 1.8 time = 800
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=800.05n

* CHECK dout0_31 Vdout0_31ck79 = 1.8 time = 800
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=800.05n

* CHECK dout0_32 Vdout0_32ck79 = 0 time = 800
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=800.05n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 810
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=810.05n

* CHECK dout0_1 Vdout0_1ck80 = 0 time = 810
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=810.05n

* CHECK dout0_2 Vdout0_2ck80 = 1.8 time = 810
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=810.05n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 810
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=810.05n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 810
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=810.05n

* CHECK dout0_5 Vdout0_5ck80 = 0 time = 810
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=810.05n

* CHECK dout0_6 Vdout0_6ck80 = 1.8 time = 810
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=810.05n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 810
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=810.05n

* CHECK dout0_8 Vdout0_8ck80 = 1.8 time = 810
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=810.05n

* CHECK dout0_9 Vdout0_9ck80 = 0 time = 810
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=810.05n

* CHECK dout0_10 Vdout0_10ck80 = 1.8 time = 810
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=810.05n

* CHECK dout0_11 Vdout0_11ck80 = 1.8 time = 810
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=810.05n

* CHECK dout0_12 Vdout0_12ck80 = 0 time = 810
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=810.05n

* CHECK dout0_13 Vdout0_13ck80 = 0 time = 810
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=810.05n

* CHECK dout0_14 Vdout0_14ck80 = 1.8 time = 810
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=810.05n

* CHECK dout0_15 Vdout0_15ck80 = 0 time = 810
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=810.05n

* CHECK dout0_16 Vdout0_16ck80 = 0 time = 810
.meas tran vdout0_16ck80 FIND v(dout0_16) AT=810.05n

* CHECK dout0_17 Vdout0_17ck80 = 1.8 time = 810
.meas tran vdout0_17ck80 FIND v(dout0_17) AT=810.05n

* CHECK dout0_18 Vdout0_18ck80 = 0 time = 810
.meas tran vdout0_18ck80 FIND v(dout0_18) AT=810.05n

* CHECK dout0_19 Vdout0_19ck80 = 1.8 time = 810
.meas tran vdout0_19ck80 FIND v(dout0_19) AT=810.05n

* CHECK dout0_20 Vdout0_20ck80 = 0 time = 810
.meas tran vdout0_20ck80 FIND v(dout0_20) AT=810.05n

* CHECK dout0_21 Vdout0_21ck80 = 0 time = 810
.meas tran vdout0_21ck80 FIND v(dout0_21) AT=810.05n

* CHECK dout0_22 Vdout0_22ck80 = 0 time = 810
.meas tran vdout0_22ck80 FIND v(dout0_22) AT=810.05n

* CHECK dout0_23 Vdout0_23ck80 = 0 time = 810
.meas tran vdout0_23ck80 FIND v(dout0_23) AT=810.05n

* CHECK dout0_24 Vdout0_24ck80 = 0 time = 810
.meas tran vdout0_24ck80 FIND v(dout0_24) AT=810.05n

* CHECK dout0_25 Vdout0_25ck80 = 0 time = 810
.meas tran vdout0_25ck80 FIND v(dout0_25) AT=810.05n

* CHECK dout0_26 Vdout0_26ck80 = 1.8 time = 810
.meas tran vdout0_26ck80 FIND v(dout0_26) AT=810.05n

* CHECK dout0_27 Vdout0_27ck80 = 0 time = 810
.meas tran vdout0_27ck80 FIND v(dout0_27) AT=810.05n

* CHECK dout0_28 Vdout0_28ck80 = 1.8 time = 810
.meas tran vdout0_28ck80 FIND v(dout0_28) AT=810.05n

* CHECK dout0_29 Vdout0_29ck80 = 0 time = 810
.meas tran vdout0_29ck80 FIND v(dout0_29) AT=810.05n

* CHECK dout0_30 Vdout0_30ck80 = 1.8 time = 810
.meas tran vdout0_30ck80 FIND v(dout0_30) AT=810.05n

* CHECK dout0_31 Vdout0_31ck80 = 0 time = 810
.meas tran vdout0_31ck80 FIND v(dout0_31) AT=810.05n

* CHECK dout0_32 Vdout0_32ck80 = 0 time = 810
.meas tran vdout0_32ck80 FIND v(dout0_32) AT=810.05n

* CHECK dout0_0 Vdout0_0ck81 = 1.8 time = 820
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=820.05n

* CHECK dout0_1 Vdout0_1ck81 = 1.8 time = 820
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=820.05n

* CHECK dout0_2 Vdout0_2ck81 = 1.8 time = 820
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=820.05n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 820
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=820.05n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 820
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=820.05n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 820
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=820.05n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 820
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=820.05n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 820
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=820.05n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 820
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=820.05n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 820
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=820.05n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 820
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=820.05n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 820
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=820.05n

* CHECK dout0_12 Vdout0_12ck81 = 0 time = 820
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=820.05n

* CHECK dout0_13 Vdout0_13ck81 = 1.8 time = 820
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=820.05n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 820
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=820.05n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 820
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=820.05n

* CHECK dout0_16 Vdout0_16ck81 = 1.8 time = 820
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=820.05n

* CHECK dout0_17 Vdout0_17ck81 = 0 time = 820
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=820.05n

* CHECK dout0_18 Vdout0_18ck81 = 1.8 time = 820
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=820.05n

* CHECK dout0_19 Vdout0_19ck81 = 0 time = 820
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=820.05n

* CHECK dout0_20 Vdout0_20ck81 = 1.8 time = 820
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=820.05n

* CHECK dout0_21 Vdout0_21ck81 = 0 time = 820
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=820.05n

* CHECK dout0_22 Vdout0_22ck81 = 1.8 time = 820
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=820.05n

* CHECK dout0_23 Vdout0_23ck81 = 0 time = 820
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=820.05n

* CHECK dout0_24 Vdout0_24ck81 = 1.8 time = 820
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=820.05n

* CHECK dout0_25 Vdout0_25ck81 = 0 time = 820
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=820.05n

* CHECK dout0_26 Vdout0_26ck81 = 1.8 time = 820
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=820.05n

* CHECK dout0_27 Vdout0_27ck81 = 0 time = 820
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=820.05n

* CHECK dout0_28 Vdout0_28ck81 = 0 time = 820
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=820.05n

* CHECK dout0_29 Vdout0_29ck81 = 1.8 time = 820
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=820.05n

* CHECK dout0_30 Vdout0_30ck81 = 1.8 time = 820
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=820.05n

* CHECK dout0_31 Vdout0_31ck81 = 1.8 time = 820
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=820.05n

* CHECK dout0_32 Vdout0_32ck81 = 0 time = 820
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=820.05n

* CHECK dout0_0 Vdout0_0ck83 = 0 time = 840
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=840.05n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 840
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=840.05n

* CHECK dout0_2 Vdout0_2ck83 = 1.8 time = 840
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=840.05n

* CHECK dout0_3 Vdout0_3ck83 = 0 time = 840
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=840.05n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 840
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=840.05n

* CHECK dout0_5 Vdout0_5ck83 = 0 time = 840
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=840.05n

* CHECK dout0_6 Vdout0_6ck83 = 1.8 time = 840
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=840.05n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 840
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=840.05n

* CHECK dout0_8 Vdout0_8ck83 = 1.8 time = 840
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=840.05n

* CHECK dout0_9 Vdout0_9ck83 = 0 time = 840
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=840.05n

* CHECK dout0_10 Vdout0_10ck83 = 1.8 time = 840
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=840.05n

* CHECK dout0_11 Vdout0_11ck83 = 1.8 time = 840
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=840.05n

* CHECK dout0_12 Vdout0_12ck83 = 0 time = 840
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=840.05n

* CHECK dout0_13 Vdout0_13ck83 = 0 time = 840
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=840.05n

* CHECK dout0_14 Vdout0_14ck83 = 1.8 time = 840
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=840.05n

* CHECK dout0_15 Vdout0_15ck83 = 0 time = 840
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=840.05n

* CHECK dout0_16 Vdout0_16ck83 = 0 time = 840
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=840.05n

* CHECK dout0_17 Vdout0_17ck83 = 1.8 time = 840
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=840.05n

* CHECK dout0_18 Vdout0_18ck83 = 0 time = 840
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=840.05n

* CHECK dout0_19 Vdout0_19ck83 = 1.8 time = 840
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=840.05n

* CHECK dout0_20 Vdout0_20ck83 = 0 time = 840
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=840.05n

* CHECK dout0_21 Vdout0_21ck83 = 0 time = 840
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=840.05n

* CHECK dout0_22 Vdout0_22ck83 = 0 time = 840
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=840.05n

* CHECK dout0_23 Vdout0_23ck83 = 0 time = 840
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=840.05n

* CHECK dout0_24 Vdout0_24ck83 = 0 time = 840
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=840.05n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 840
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=840.05n

* CHECK dout0_26 Vdout0_26ck83 = 1.8 time = 840
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=840.05n

* CHECK dout0_27 Vdout0_27ck83 = 0 time = 840
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=840.05n

* CHECK dout0_28 Vdout0_28ck83 = 1.8 time = 840
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=840.05n

* CHECK dout0_29 Vdout0_29ck83 = 0 time = 840
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=840.05n

* CHECK dout0_30 Vdout0_30ck83 = 1.8 time = 840
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=840.05n

* CHECK dout0_31 Vdout0_31ck83 = 0 time = 840
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=840.05n

* CHECK dout0_32 Vdout0_32ck83 = 0 time = 840
.meas tran vdout0_32ck83 FIND v(dout0_32) AT=840.05n

* CHECK dout0_0 Vdout0_0ck84 = 0 time = 850
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=850.05n

* CHECK dout0_1 Vdout0_1ck84 = 0 time = 850
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=850.05n

* CHECK dout0_2 Vdout0_2ck84 = 1.8 time = 850
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=850.05n

* CHECK dout0_3 Vdout0_3ck84 = 1.8 time = 850
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=850.05n

* CHECK dout0_4 Vdout0_4ck84 = 0 time = 850
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=850.05n

* CHECK dout0_5 Vdout0_5ck84 = 0 time = 850
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=850.05n

* CHECK dout0_6 Vdout0_6ck84 = 0 time = 850
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=850.05n

* CHECK dout0_7 Vdout0_7ck84 = 1.8 time = 850
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=850.05n

* CHECK dout0_8 Vdout0_8ck84 = 0 time = 850
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=850.05n

* CHECK dout0_9 Vdout0_9ck84 = 0 time = 850
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=850.05n

* CHECK dout0_10 Vdout0_10ck84 = 1.8 time = 850
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=850.05n

* CHECK dout0_11 Vdout0_11ck84 = 0 time = 850
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=850.05n

* CHECK dout0_12 Vdout0_12ck84 = 0 time = 850
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=850.05n

* CHECK dout0_13 Vdout0_13ck84 = 0 time = 850
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=850.05n

* CHECK dout0_14 Vdout0_14ck84 = 1.8 time = 850
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=850.05n

* CHECK dout0_15 Vdout0_15ck84 = 1.8 time = 850
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=850.05n

* CHECK dout0_16 Vdout0_16ck84 = 0 time = 850
.meas tran vdout0_16ck84 FIND v(dout0_16) AT=850.05n

* CHECK dout0_17 Vdout0_17ck84 = 0 time = 850
.meas tran vdout0_17ck84 FIND v(dout0_17) AT=850.05n

* CHECK dout0_18 Vdout0_18ck84 = 0 time = 850
.meas tran vdout0_18ck84 FIND v(dout0_18) AT=850.05n

* CHECK dout0_19 Vdout0_19ck84 = 0 time = 850
.meas tran vdout0_19ck84 FIND v(dout0_19) AT=850.05n

* CHECK dout0_20 Vdout0_20ck84 = 1.8 time = 850
.meas tran vdout0_20ck84 FIND v(dout0_20) AT=850.05n

* CHECK dout0_21 Vdout0_21ck84 = 0 time = 850
.meas tran vdout0_21ck84 FIND v(dout0_21) AT=850.05n

* CHECK dout0_22 Vdout0_22ck84 = 1.8 time = 850
.meas tran vdout0_22ck84 FIND v(dout0_22) AT=850.05n

* CHECK dout0_23 Vdout0_23ck84 = 1.8 time = 850
.meas tran vdout0_23ck84 FIND v(dout0_23) AT=850.05n

* CHECK dout0_24 Vdout0_24ck84 = 1.8 time = 850
.meas tran vdout0_24ck84 FIND v(dout0_24) AT=850.05n

* CHECK dout0_25 Vdout0_25ck84 = 0 time = 850
.meas tran vdout0_25ck84 FIND v(dout0_25) AT=850.05n

* CHECK dout0_26 Vdout0_26ck84 = 1.8 time = 850
.meas tran vdout0_26ck84 FIND v(dout0_26) AT=850.05n

* CHECK dout0_27 Vdout0_27ck84 = 0 time = 850
.meas tran vdout0_27ck84 FIND v(dout0_27) AT=850.05n

* CHECK dout0_28 Vdout0_28ck84 = 1.8 time = 850
.meas tran vdout0_28ck84 FIND v(dout0_28) AT=850.05n

* CHECK dout0_29 Vdout0_29ck84 = 0 time = 850
.meas tran vdout0_29ck84 FIND v(dout0_29) AT=850.05n

* CHECK dout0_30 Vdout0_30ck84 = 1.8 time = 850
.meas tran vdout0_30ck84 FIND v(dout0_30) AT=850.05n

* CHECK dout0_31 Vdout0_31ck84 = 1.8 time = 850
.meas tran vdout0_31ck84 FIND v(dout0_31) AT=850.05n

* CHECK dout0_32 Vdout0_32ck84 = 0 time = 850
.meas tran vdout0_32ck84 FIND v(dout0_32) AT=850.05n

* CHECK dout0_0 Vdout0_0ck85 = 1.8 time = 860
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=860.05n

* CHECK dout0_1 Vdout0_1ck85 = 1.8 time = 860
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=860.05n

* CHECK dout0_2 Vdout0_2ck85 = 1.8 time = 860
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=860.05n

* CHECK dout0_3 Vdout0_3ck85 = 0 time = 860
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=860.05n

* CHECK dout0_4 Vdout0_4ck85 = 0 time = 860
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=860.05n

* CHECK dout0_5 Vdout0_5ck85 = 0 time = 860
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=860.05n

* CHECK dout0_6 Vdout0_6ck85 = 1.8 time = 860
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=860.05n

* CHECK dout0_7 Vdout0_7ck85 = 0 time = 860
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=860.05n

* CHECK dout0_8 Vdout0_8ck85 = 0 time = 860
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=860.05n

* CHECK dout0_9 Vdout0_9ck85 = 0 time = 860
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=860.05n

* CHECK dout0_10 Vdout0_10ck85 = 0 time = 860
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=860.05n

* CHECK dout0_11 Vdout0_11ck85 = 0 time = 860
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=860.05n

* CHECK dout0_12 Vdout0_12ck85 = 0 time = 860
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=860.05n

* CHECK dout0_13 Vdout0_13ck85 = 1.8 time = 860
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=860.05n

* CHECK dout0_14 Vdout0_14ck85 = 0 time = 860
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=860.05n

* CHECK dout0_15 Vdout0_15ck85 = 0 time = 860
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=860.05n

* CHECK dout0_16 Vdout0_16ck85 = 1.8 time = 860
.meas tran vdout0_16ck85 FIND v(dout0_16) AT=860.05n

* CHECK dout0_17 Vdout0_17ck85 = 0 time = 860
.meas tran vdout0_17ck85 FIND v(dout0_17) AT=860.05n

* CHECK dout0_18 Vdout0_18ck85 = 1.8 time = 860
.meas tran vdout0_18ck85 FIND v(dout0_18) AT=860.05n

* CHECK dout0_19 Vdout0_19ck85 = 0 time = 860
.meas tran vdout0_19ck85 FIND v(dout0_19) AT=860.05n

* CHECK dout0_20 Vdout0_20ck85 = 1.8 time = 860
.meas tran vdout0_20ck85 FIND v(dout0_20) AT=860.05n

* CHECK dout0_21 Vdout0_21ck85 = 0 time = 860
.meas tran vdout0_21ck85 FIND v(dout0_21) AT=860.05n

* CHECK dout0_22 Vdout0_22ck85 = 1.8 time = 860
.meas tran vdout0_22ck85 FIND v(dout0_22) AT=860.05n

* CHECK dout0_23 Vdout0_23ck85 = 0 time = 860
.meas tran vdout0_23ck85 FIND v(dout0_23) AT=860.05n

* CHECK dout0_24 Vdout0_24ck85 = 1.8 time = 860
.meas tran vdout0_24ck85 FIND v(dout0_24) AT=860.05n

* CHECK dout0_25 Vdout0_25ck85 = 0 time = 860
.meas tran vdout0_25ck85 FIND v(dout0_25) AT=860.05n

* CHECK dout0_26 Vdout0_26ck85 = 1.8 time = 860
.meas tran vdout0_26ck85 FIND v(dout0_26) AT=860.05n

* CHECK dout0_27 Vdout0_27ck85 = 0 time = 860
.meas tran vdout0_27ck85 FIND v(dout0_27) AT=860.05n

* CHECK dout0_28 Vdout0_28ck85 = 0 time = 860
.meas tran vdout0_28ck85 FIND v(dout0_28) AT=860.05n

* CHECK dout0_29 Vdout0_29ck85 = 1.8 time = 860
.meas tran vdout0_29ck85 FIND v(dout0_29) AT=860.05n

* CHECK dout0_30 Vdout0_30ck85 = 1.8 time = 860
.meas tran vdout0_30ck85 FIND v(dout0_30) AT=860.05n

* CHECK dout0_31 Vdout0_31ck85 = 1.8 time = 860
.meas tran vdout0_31ck85 FIND v(dout0_31) AT=860.05n

* CHECK dout0_32 Vdout0_32ck85 = 0 time = 860
.meas tran vdout0_32ck85 FIND v(dout0_32) AT=860.05n

* CHECK dout0_0 Vdout0_0ck86 = 1.8 time = 870
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=870.05n

* CHECK dout0_1 Vdout0_1ck86 = 1.8 time = 870
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=870.05n

* CHECK dout0_2 Vdout0_2ck86 = 1.8 time = 870
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=870.05n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 870
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=870.05n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 870
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=870.05n

* CHECK dout0_5 Vdout0_5ck86 = 1.8 time = 870
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=870.05n

* CHECK dout0_6 Vdout0_6ck86 = 1.8 time = 870
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=870.05n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 870
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=870.05n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 870
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=870.05n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 870
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=870.05n

* CHECK dout0_10 Vdout0_10ck86 = 1.8 time = 870
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=870.05n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 870
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=870.05n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 870
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=870.05n

* CHECK dout0_13 Vdout0_13ck86 = 1.8 time = 870
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=870.05n

* CHECK dout0_14 Vdout0_14ck86 = 0 time = 870
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=870.05n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 870
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=870.05n

* CHECK dout0_16 Vdout0_16ck86 = 0 time = 870
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=870.05n

* CHECK dout0_17 Vdout0_17ck86 = 1.8 time = 870
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=870.05n

* CHECK dout0_18 Vdout0_18ck86 = 0 time = 870
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=870.05n

* CHECK dout0_19 Vdout0_19ck86 = 1.8 time = 870
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=870.05n

* CHECK dout0_20 Vdout0_20ck86 = 1.8 time = 870
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=870.05n

* CHECK dout0_21 Vdout0_21ck86 = 0 time = 870
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=870.05n

* CHECK dout0_22 Vdout0_22ck86 = 1.8 time = 870
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=870.05n

* CHECK dout0_23 Vdout0_23ck86 = 1.8 time = 870
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=870.05n

* CHECK dout0_24 Vdout0_24ck86 = 1.8 time = 870
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=870.05n

* CHECK dout0_25 Vdout0_25ck86 = 0 time = 870
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=870.05n

* CHECK dout0_26 Vdout0_26ck86 = 0 time = 870
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=870.05n

* CHECK dout0_27 Vdout0_27ck86 = 1.8 time = 870
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=870.05n

* CHECK dout0_28 Vdout0_28ck86 = 1.8 time = 870
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=870.05n

* CHECK dout0_29 Vdout0_29ck86 = 0 time = 870
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=870.05n

* CHECK dout0_30 Vdout0_30ck86 = 1.8 time = 870
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=870.05n

* CHECK dout0_31 Vdout0_31ck86 = 1.8 time = 870
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=870.05n

* CHECK dout0_32 Vdout0_32ck86 = 0 time = 870
.meas tran vdout0_32ck86 FIND v(dout0_32) AT=870.05n

* CHECK dout0_0 Vdout0_0ck88 = 1.8 time = 890
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=890.05n

* CHECK dout0_1 Vdout0_1ck88 = 1.8 time = 890
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=890.05n

* CHECK dout0_2 Vdout0_2ck88 = 1.8 time = 890
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=890.05n

* CHECK dout0_3 Vdout0_3ck88 = 0 time = 890
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=890.05n

* CHECK dout0_4 Vdout0_4ck88 = 0 time = 890
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=890.05n

* CHECK dout0_5 Vdout0_5ck88 = 1.8 time = 890
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=890.05n

* CHECK dout0_6 Vdout0_6ck88 = 1.8 time = 890
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=890.05n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 890
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=890.05n

* CHECK dout0_8 Vdout0_8ck88 = 0 time = 890
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=890.05n

* CHECK dout0_9 Vdout0_9ck88 = 0 time = 890
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=890.05n

* CHECK dout0_10 Vdout0_10ck88 = 1.8 time = 890
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=890.05n

* CHECK dout0_11 Vdout0_11ck88 = 0 time = 890
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=890.05n

* CHECK dout0_12 Vdout0_12ck88 = 0 time = 890
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=890.05n

* CHECK dout0_13 Vdout0_13ck88 = 1.8 time = 890
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=890.05n

* CHECK dout0_14 Vdout0_14ck88 = 0 time = 890
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=890.05n

* CHECK dout0_15 Vdout0_15ck88 = 0 time = 890
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=890.05n

* CHECK dout0_16 Vdout0_16ck88 = 0 time = 890
.meas tran vdout0_16ck88 FIND v(dout0_16) AT=890.05n

* CHECK dout0_17 Vdout0_17ck88 = 1.8 time = 890
.meas tran vdout0_17ck88 FIND v(dout0_17) AT=890.05n

* CHECK dout0_18 Vdout0_18ck88 = 0 time = 890
.meas tran vdout0_18ck88 FIND v(dout0_18) AT=890.05n

* CHECK dout0_19 Vdout0_19ck88 = 1.8 time = 890
.meas tran vdout0_19ck88 FIND v(dout0_19) AT=890.05n

* CHECK dout0_20 Vdout0_20ck88 = 1.8 time = 890
.meas tran vdout0_20ck88 FIND v(dout0_20) AT=890.05n

* CHECK dout0_21 Vdout0_21ck88 = 0 time = 890
.meas tran vdout0_21ck88 FIND v(dout0_21) AT=890.05n

* CHECK dout0_22 Vdout0_22ck88 = 1.8 time = 890
.meas tran vdout0_22ck88 FIND v(dout0_22) AT=890.05n

* CHECK dout0_23 Vdout0_23ck88 = 1.8 time = 890
.meas tran vdout0_23ck88 FIND v(dout0_23) AT=890.05n

* CHECK dout0_24 Vdout0_24ck88 = 1.8 time = 890
.meas tran vdout0_24ck88 FIND v(dout0_24) AT=890.05n

* CHECK dout0_25 Vdout0_25ck88 = 0 time = 890
.meas tran vdout0_25ck88 FIND v(dout0_25) AT=890.05n

* CHECK dout0_26 Vdout0_26ck88 = 0 time = 890
.meas tran vdout0_26ck88 FIND v(dout0_26) AT=890.05n

* CHECK dout0_27 Vdout0_27ck88 = 1.8 time = 890
.meas tran vdout0_27ck88 FIND v(dout0_27) AT=890.05n

* CHECK dout0_28 Vdout0_28ck88 = 1.8 time = 890
.meas tran vdout0_28ck88 FIND v(dout0_28) AT=890.05n

* CHECK dout0_29 Vdout0_29ck88 = 0 time = 890
.meas tran vdout0_29ck88 FIND v(dout0_29) AT=890.05n

* CHECK dout0_30 Vdout0_30ck88 = 1.8 time = 890
.meas tran vdout0_30ck88 FIND v(dout0_30) AT=890.05n

* CHECK dout0_31 Vdout0_31ck88 = 1.8 time = 890
.meas tran vdout0_31ck88 FIND v(dout0_31) AT=890.05n

* CHECK dout0_32 Vdout0_32ck88 = 0 time = 890
.meas tran vdout0_32ck88 FIND v(dout0_32) AT=890.05n

* CHECK dout0_0 Vdout0_0ck90 = 1.8 time = 910
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=910.05n

* CHECK dout0_1 Vdout0_1ck90 = 1.8 time = 910
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=910.05n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 910
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=910.05n

* CHECK dout0_3 Vdout0_3ck90 = 1.8 time = 910
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=910.05n

* CHECK dout0_4 Vdout0_4ck90 = 1.8 time = 910
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=910.05n

* CHECK dout0_5 Vdout0_5ck90 = 0 time = 910
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=910.05n

* CHECK dout0_6 Vdout0_6ck90 = 0 time = 910
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=910.05n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 910
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=910.05n

* CHECK dout0_8 Vdout0_8ck90 = 1.8 time = 910
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=910.05n

* CHECK dout0_9 Vdout0_9ck90 = 0 time = 910
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=910.05n

* CHECK dout0_10 Vdout0_10ck90 = 1.8 time = 910
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=910.05n

* CHECK dout0_11 Vdout0_11ck90 = 0 time = 910
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=910.05n

* CHECK dout0_12 Vdout0_12ck90 = 1.8 time = 910
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=910.05n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 910
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=910.05n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 910
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=910.05n

* CHECK dout0_15 Vdout0_15ck90 = 1.8 time = 910
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=910.05n

* CHECK dout0_16 Vdout0_16ck90 = 1.8 time = 910
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=910.05n

* CHECK dout0_17 Vdout0_17ck90 = 0 time = 910
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=910.05n

* CHECK dout0_18 Vdout0_18ck90 = 0 time = 910
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=910.05n

* CHECK dout0_19 Vdout0_19ck90 = 0 time = 910
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=910.05n

* CHECK dout0_20 Vdout0_20ck90 = 1.8 time = 910
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=910.05n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 910
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=910.05n

* CHECK dout0_22 Vdout0_22ck90 = 0 time = 910
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=910.05n

* CHECK dout0_23 Vdout0_23ck90 = 0 time = 910
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=910.05n

* CHECK dout0_24 Vdout0_24ck90 = 0 time = 910
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=910.05n

* CHECK dout0_25 Vdout0_25ck90 = 1.8 time = 910
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=910.05n

* CHECK dout0_26 Vdout0_26ck90 = 0 time = 910
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=910.05n

* CHECK dout0_27 Vdout0_27ck90 = 1.8 time = 910
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=910.05n

* CHECK dout0_28 Vdout0_28ck90 = 0 time = 910
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=910.05n

* CHECK dout0_29 Vdout0_29ck90 = 0 time = 910
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=910.05n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 910
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=910.05n

* CHECK dout0_31 Vdout0_31ck90 = 1.8 time = 910
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=910.05n

* CHECK dout0_32 Vdout0_32ck90 = 0 time = 910
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=910.05n

* CHECK dout0_0 Vdout0_0ck91 = 1.8 time = 920
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=920.05n

* CHECK dout0_1 Vdout0_1ck91 = 1.8 time = 920
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=920.05n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 920
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=920.05n

* CHECK dout0_3 Vdout0_3ck91 = 1.8 time = 920
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=920.05n

* CHECK dout0_4 Vdout0_4ck91 = 1.8 time = 920
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=920.05n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 920
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=920.05n

* CHECK dout0_6 Vdout0_6ck91 = 0 time = 920
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=920.05n

* CHECK dout0_7 Vdout0_7ck91 = 0 time = 920
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=920.05n

* CHECK dout0_8 Vdout0_8ck91 = 1.8 time = 920
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=920.05n

* CHECK dout0_9 Vdout0_9ck91 = 0 time = 920
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=920.05n

* CHECK dout0_10 Vdout0_10ck91 = 1.8 time = 920
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=920.05n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 920
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=920.05n

* CHECK dout0_12 Vdout0_12ck91 = 1.8 time = 920
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=920.05n

* CHECK dout0_13 Vdout0_13ck91 = 0 time = 920
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=920.05n

* CHECK dout0_14 Vdout0_14ck91 = 0 time = 920
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=920.05n

* CHECK dout0_15 Vdout0_15ck91 = 1.8 time = 920
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=920.05n

* CHECK dout0_16 Vdout0_16ck91 = 1.8 time = 920
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=920.05n

* CHECK dout0_17 Vdout0_17ck91 = 0 time = 920
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=920.05n

* CHECK dout0_18 Vdout0_18ck91 = 0 time = 920
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=920.05n

* CHECK dout0_19 Vdout0_19ck91 = 0 time = 920
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=920.05n

* CHECK dout0_20 Vdout0_20ck91 = 1.8 time = 920
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=920.05n

* CHECK dout0_21 Vdout0_21ck91 = 0 time = 920
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=920.05n

* CHECK dout0_22 Vdout0_22ck91 = 0 time = 920
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=920.05n

* CHECK dout0_23 Vdout0_23ck91 = 0 time = 920
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=920.05n

* CHECK dout0_24 Vdout0_24ck91 = 0 time = 920
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=920.05n

* CHECK dout0_25 Vdout0_25ck91 = 1.8 time = 920
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=920.05n

* CHECK dout0_26 Vdout0_26ck91 = 0 time = 920
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=920.05n

* CHECK dout0_27 Vdout0_27ck91 = 1.8 time = 920
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=920.05n

* CHECK dout0_28 Vdout0_28ck91 = 0 time = 920
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=920.05n

* CHECK dout0_29 Vdout0_29ck91 = 0 time = 920
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=920.05n

* CHECK dout0_30 Vdout0_30ck91 = 0 time = 920
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=920.05n

* CHECK dout0_31 Vdout0_31ck91 = 1.8 time = 920
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=920.05n

* CHECK dout0_32 Vdout0_32ck91 = 0 time = 920
.meas tran vdout0_32ck91 FIND v(dout0_32) AT=920.05n

* CHECK dout0_0 Vdout0_0ck92 = 1.8 time = 930
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=930.05n

* CHECK dout0_1 Vdout0_1ck92 = 1.8 time = 930
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=930.05n

* CHECK dout0_2 Vdout0_2ck92 = 1.8 time = 930
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=930.05n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 930
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=930.05n

* CHECK dout0_4 Vdout0_4ck92 = 0 time = 930
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=930.05n

* CHECK dout0_5 Vdout0_5ck92 = 1.8 time = 930
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=930.05n

* CHECK dout0_6 Vdout0_6ck92 = 1.8 time = 930
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=930.05n

* CHECK dout0_7 Vdout0_7ck92 = 0 time = 930
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=930.05n

* CHECK dout0_8 Vdout0_8ck92 = 0 time = 930
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=930.05n

* CHECK dout0_9 Vdout0_9ck92 = 0 time = 930
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=930.05n

* CHECK dout0_10 Vdout0_10ck92 = 1.8 time = 930
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=930.05n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 930
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=930.05n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 930
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=930.05n

* CHECK dout0_13 Vdout0_13ck92 = 1.8 time = 930
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=930.05n

* CHECK dout0_14 Vdout0_14ck92 = 0 time = 930
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=930.05n

* CHECK dout0_15 Vdout0_15ck92 = 0 time = 930
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=930.05n

* CHECK dout0_16 Vdout0_16ck92 = 0 time = 930
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=930.05n

* CHECK dout0_17 Vdout0_17ck92 = 1.8 time = 930
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=930.05n

* CHECK dout0_18 Vdout0_18ck92 = 0 time = 930
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=930.05n

* CHECK dout0_19 Vdout0_19ck92 = 1.8 time = 930
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=930.05n

* CHECK dout0_20 Vdout0_20ck92 = 1.8 time = 930
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=930.05n

* CHECK dout0_21 Vdout0_21ck92 = 0 time = 930
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=930.05n

* CHECK dout0_22 Vdout0_22ck92 = 1.8 time = 930
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=930.05n

* CHECK dout0_23 Vdout0_23ck92 = 1.8 time = 930
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=930.05n

* CHECK dout0_24 Vdout0_24ck92 = 1.8 time = 930
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=930.05n

* CHECK dout0_25 Vdout0_25ck92 = 0 time = 930
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=930.05n

* CHECK dout0_26 Vdout0_26ck92 = 0 time = 930
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=930.05n

* CHECK dout0_27 Vdout0_27ck92 = 1.8 time = 930
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=930.05n

* CHECK dout0_28 Vdout0_28ck92 = 1.8 time = 930
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=930.05n

* CHECK dout0_29 Vdout0_29ck92 = 0 time = 930
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=930.05n

* CHECK dout0_30 Vdout0_30ck92 = 1.8 time = 930
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=930.05n

* CHECK dout0_31 Vdout0_31ck92 = 1.8 time = 930
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=930.05n

* CHECK dout0_32 Vdout0_32ck92 = 0 time = 930
.meas tran vdout0_32ck92 FIND v(dout0_32) AT=930.05n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 940
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=940.05n

* CHECK dout0_1 Vdout0_1ck93 = 1.8 time = 940
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=940.05n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 940
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=940.05n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 940
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=940.05n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 940
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=940.05n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 940
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=940.05n

* CHECK dout0_6 Vdout0_6ck93 = 1.8 time = 940
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=940.05n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 940
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=940.05n

* CHECK dout0_8 Vdout0_8ck93 = 0 time = 940
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=940.05n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 940
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=940.05n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 940
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=940.05n

* CHECK dout0_11 Vdout0_11ck93 = 1.8 time = 940
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=940.05n

* CHECK dout0_12 Vdout0_12ck93 = 1.8 time = 940
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=940.05n

* CHECK dout0_13 Vdout0_13ck93 = 1.8 time = 940
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=940.05n

* CHECK dout0_14 Vdout0_14ck93 = 1.8 time = 940
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=940.05n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 940
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=940.05n

* CHECK dout0_16 Vdout0_16ck93 = 0 time = 940
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=940.05n

* CHECK dout0_17 Vdout0_17ck93 = 1.8 time = 940
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=940.05n

* CHECK dout0_18 Vdout0_18ck93 = 0 time = 940
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=940.05n

* CHECK dout0_19 Vdout0_19ck93 = 1.8 time = 940
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=940.05n

* CHECK dout0_20 Vdout0_20ck93 = 0 time = 940
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=940.05n

* CHECK dout0_21 Vdout0_21ck93 = 0 time = 940
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=940.05n

* CHECK dout0_22 Vdout0_22ck93 = 1.8 time = 940
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=940.05n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 940
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=940.05n

* CHECK dout0_24 Vdout0_24ck93 = 1.8 time = 940
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=940.05n

* CHECK dout0_25 Vdout0_25ck93 = 1.8 time = 940
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=940.05n

* CHECK dout0_26 Vdout0_26ck93 = 1.8 time = 940
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=940.05n

* CHECK dout0_27 Vdout0_27ck93 = 1.8 time = 940
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=940.05n

* CHECK dout0_28 Vdout0_28ck93 = 0 time = 940
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=940.05n

* CHECK dout0_29 Vdout0_29ck93 = 1.8 time = 940
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=940.05n

* CHECK dout0_30 Vdout0_30ck93 = 1.8 time = 940
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=940.05n

* CHECK dout0_31 Vdout0_31ck93 = 0 time = 940
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=940.05n

* CHECK dout0_32 Vdout0_32ck93 = 0 time = 940
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=940.05n

* CHECK dout0_0 Vdout0_0ck100 = 0 time = 1010
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=1010.05n

* CHECK dout0_1 Vdout0_1ck100 = 1.8 time = 1010
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=1010.05n

* CHECK dout0_2 Vdout0_2ck100 = 0 time = 1010
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=1010.05n

* CHECK dout0_3 Vdout0_3ck100 = 0 time = 1010
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=1010.05n

* CHECK dout0_4 Vdout0_4ck100 = 1.8 time = 1010
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=1010.05n

* CHECK dout0_5 Vdout0_5ck100 = 1.8 time = 1010
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=1010.05n

* CHECK dout0_6 Vdout0_6ck100 = 1.8 time = 1010
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=1010.05n

* CHECK dout0_7 Vdout0_7ck100 = 1.8 time = 1010
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=1010.05n

* CHECK dout0_8 Vdout0_8ck100 = 1.8 time = 1010
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=1010.05n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 1010
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=1010.05n

* CHECK dout0_10 Vdout0_10ck100 = 1.8 time = 1010
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=1010.05n

* CHECK dout0_11 Vdout0_11ck100 = 1.8 time = 1010
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=1010.05n

* CHECK dout0_12 Vdout0_12ck100 = 0 time = 1010
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=1010.05n

* CHECK dout0_13 Vdout0_13ck100 = 1.8 time = 1010
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=1010.05n

* CHECK dout0_14 Vdout0_14ck100 = 0 time = 1010
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=1010.05n

* CHECK dout0_15 Vdout0_15ck100 = 0 time = 1010
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=1010.05n

* CHECK dout0_16 Vdout0_16ck100 = 0 time = 1010
.meas tran vdout0_16ck100 FIND v(dout0_16) AT=1010.05n

* CHECK dout0_17 Vdout0_17ck100 = 1.8 time = 1010
.meas tran vdout0_17ck100 FIND v(dout0_17) AT=1010.05n

* CHECK dout0_18 Vdout0_18ck100 = 0 time = 1010
.meas tran vdout0_18ck100 FIND v(dout0_18) AT=1010.05n

* CHECK dout0_19 Vdout0_19ck100 = 0 time = 1010
.meas tran vdout0_19ck100 FIND v(dout0_19) AT=1010.05n

* CHECK dout0_20 Vdout0_20ck100 = 1.8 time = 1010
.meas tran vdout0_20ck100 FIND v(dout0_20) AT=1010.05n

* CHECK dout0_21 Vdout0_21ck100 = 0 time = 1010
.meas tran vdout0_21ck100 FIND v(dout0_21) AT=1010.05n

* CHECK dout0_22 Vdout0_22ck100 = 0 time = 1010
.meas tran vdout0_22ck100 FIND v(dout0_22) AT=1010.05n

* CHECK dout0_23 Vdout0_23ck100 = 0 time = 1010
.meas tran vdout0_23ck100 FIND v(dout0_23) AT=1010.05n

* CHECK dout0_24 Vdout0_24ck100 = 1.8 time = 1010
.meas tran vdout0_24ck100 FIND v(dout0_24) AT=1010.05n

* CHECK dout0_25 Vdout0_25ck100 = 0 time = 1010
.meas tran vdout0_25ck100 FIND v(dout0_25) AT=1010.05n

* CHECK dout0_26 Vdout0_26ck100 = 1.8 time = 1010
.meas tran vdout0_26ck100 FIND v(dout0_26) AT=1010.05n

* CHECK dout0_27 Vdout0_27ck100 = 0 time = 1010
.meas tran vdout0_27ck100 FIND v(dout0_27) AT=1010.05n

* CHECK dout0_28 Vdout0_28ck100 = 0 time = 1010
.meas tran vdout0_28ck100 FIND v(dout0_28) AT=1010.05n

* CHECK dout0_29 Vdout0_29ck100 = 1.8 time = 1010
.meas tran vdout0_29ck100 FIND v(dout0_29) AT=1010.05n

* CHECK dout0_30 Vdout0_30ck100 = 0 time = 1010
.meas tran vdout0_30ck100 FIND v(dout0_30) AT=1010.05n

* CHECK dout0_31 Vdout0_31ck100 = 0 time = 1010
.meas tran vdout0_31ck100 FIND v(dout0_31) AT=1010.05n

* CHECK dout0_32 Vdout0_32ck100 = 0 time = 1010
.meas tran vdout0_32ck100 FIND v(dout0_32) AT=1010.05n

* CHECK dout0_0 Vdout0_0ck101 = 0 time = 1020
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=1020.05n

* CHECK dout0_1 Vdout0_1ck101 = 1.8 time = 1020
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=1020.05n

* CHECK dout0_2 Vdout0_2ck101 = 1.8 time = 1020
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=1020.05n

* CHECK dout0_3 Vdout0_3ck101 = 1.8 time = 1020
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=1020.05n

* CHECK dout0_4 Vdout0_4ck101 = 1.8 time = 1020
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=1020.05n

* CHECK dout0_5 Vdout0_5ck101 = 1.8 time = 1020
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=1020.05n

* CHECK dout0_6 Vdout0_6ck101 = 1.8 time = 1020
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=1020.05n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 1020
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=1020.05n

* CHECK dout0_8 Vdout0_8ck101 = 0 time = 1020
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=1020.05n

* CHECK dout0_9 Vdout0_9ck101 = 1.8 time = 1020
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=1020.05n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 1020
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=1020.05n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 1020
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=1020.05n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 1020
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=1020.05n

* CHECK dout0_13 Vdout0_13ck101 = 1.8 time = 1020
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=1020.05n

* CHECK dout0_14 Vdout0_14ck101 = 0 time = 1020
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=1020.05n

* CHECK dout0_15 Vdout0_15ck101 = 1.8 time = 1020
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=1020.05n

* CHECK dout0_16 Vdout0_16ck101 = 1.8 time = 1020
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=1020.05n

* CHECK dout0_17 Vdout0_17ck101 = 0 time = 1020
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=1020.05n

* CHECK dout0_18 Vdout0_18ck101 = 0 time = 1020
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=1020.05n

* CHECK dout0_19 Vdout0_19ck101 = 0 time = 1020
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=1020.05n

* CHECK dout0_20 Vdout0_20ck101 = 1.8 time = 1020
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=1020.05n

* CHECK dout0_21 Vdout0_21ck101 = 0 time = 1020
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=1020.05n

* CHECK dout0_22 Vdout0_22ck101 = 0 time = 1020
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=1020.05n

* CHECK dout0_23 Vdout0_23ck101 = 1.8 time = 1020
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=1020.05n

* CHECK dout0_24 Vdout0_24ck101 = 1.8 time = 1020
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=1020.05n

* CHECK dout0_25 Vdout0_25ck101 = 0 time = 1020
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=1020.05n

* CHECK dout0_26 Vdout0_26ck101 = 1.8 time = 1020
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=1020.05n

* CHECK dout0_27 Vdout0_27ck101 = 0 time = 1020
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=1020.05n

* CHECK dout0_28 Vdout0_28ck101 = 0 time = 1020
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=1020.05n

* CHECK dout0_29 Vdout0_29ck101 = 1.8 time = 1020
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=1020.05n

* CHECK dout0_30 Vdout0_30ck101 = 0 time = 1020
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=1020.05n

* CHECK dout0_31 Vdout0_31ck101 = 1.8 time = 1020
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=1020.05n

* CHECK dout0_32 Vdout0_32ck101 = 0 time = 1020
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=1020.05n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 1030
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=1030.05n

* CHECK dout0_1 Vdout0_1ck102 = 1.8 time = 1030
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=1030.05n

* CHECK dout0_2 Vdout0_2ck102 = 0 time = 1030
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=1030.05n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 1030
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=1030.05n

* CHECK dout0_4 Vdout0_4ck102 = 1.8 time = 1030
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=1030.05n

* CHECK dout0_5 Vdout0_5ck102 = 1.8 time = 1030
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=1030.05n

* CHECK dout0_6 Vdout0_6ck102 = 1.8 time = 1030
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=1030.05n

* CHECK dout0_7 Vdout0_7ck102 = 1.8 time = 1030
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=1030.05n

* CHECK dout0_8 Vdout0_8ck102 = 1.8 time = 1030
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=1030.05n

* CHECK dout0_9 Vdout0_9ck102 = 0 time = 1030
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=1030.05n

* CHECK dout0_10 Vdout0_10ck102 = 1.8 time = 1030
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=1030.05n

* CHECK dout0_11 Vdout0_11ck102 = 1.8 time = 1030
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=1030.05n

* CHECK dout0_12 Vdout0_12ck102 = 0 time = 1030
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=1030.05n

* CHECK dout0_13 Vdout0_13ck102 = 1.8 time = 1030
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=1030.05n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 1030
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=1030.05n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 1030
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=1030.05n

* CHECK dout0_16 Vdout0_16ck102 = 0 time = 1030
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=1030.05n

* CHECK dout0_17 Vdout0_17ck102 = 1.8 time = 1030
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=1030.05n

* CHECK dout0_18 Vdout0_18ck102 = 0 time = 1030
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=1030.05n

* CHECK dout0_19 Vdout0_19ck102 = 0 time = 1030
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=1030.05n

* CHECK dout0_20 Vdout0_20ck102 = 1.8 time = 1030
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=1030.05n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 1030
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=1030.05n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 1030
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=1030.05n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 1030
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=1030.05n

* CHECK dout0_24 Vdout0_24ck102 = 1.8 time = 1030
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=1030.05n

* CHECK dout0_25 Vdout0_25ck102 = 0 time = 1030
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=1030.05n

* CHECK dout0_26 Vdout0_26ck102 = 1.8 time = 1030
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=1030.05n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 1030
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=1030.05n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 1030
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=1030.05n

* CHECK dout0_29 Vdout0_29ck102 = 1.8 time = 1030
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=1030.05n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 1030
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=1030.05n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 1030
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=1030.05n

* CHECK dout0_32 Vdout0_32ck102 = 0 time = 1030
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=1030.05n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 1040
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=1040.05n

* CHECK dout0_1 Vdout0_1ck103 = 1.8 time = 1040
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=1040.05n

* CHECK dout0_2 Vdout0_2ck103 = 1.8 time = 1040
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=1040.05n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 1040
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=1040.05n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 1040
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=1040.05n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 1040
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=1040.05n

* CHECK dout0_6 Vdout0_6ck103 = 1.8 time = 1040
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=1040.05n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 1040
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=1040.05n

* CHECK dout0_8 Vdout0_8ck103 = 0 time = 1040
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=1040.05n

* CHECK dout0_9 Vdout0_9ck103 = 0 time = 1040
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=1040.05n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 1040
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=1040.05n

* CHECK dout0_11 Vdout0_11ck103 = 1.8 time = 1040
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=1040.05n

* CHECK dout0_12 Vdout0_12ck103 = 1.8 time = 1040
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=1040.05n

* CHECK dout0_13 Vdout0_13ck103 = 1.8 time = 1040
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=1040.05n

* CHECK dout0_14 Vdout0_14ck103 = 1.8 time = 1040
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=1040.05n

* CHECK dout0_15 Vdout0_15ck103 = 1.8 time = 1040
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=1040.05n

* CHECK dout0_16 Vdout0_16ck103 = 0 time = 1040
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=1040.05n

* CHECK dout0_17 Vdout0_17ck103 = 1.8 time = 1040
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=1040.05n

* CHECK dout0_18 Vdout0_18ck103 = 0 time = 1040
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=1040.05n

* CHECK dout0_19 Vdout0_19ck103 = 1.8 time = 1040
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=1040.05n

* CHECK dout0_20 Vdout0_20ck103 = 0 time = 1040
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=1040.05n

* CHECK dout0_21 Vdout0_21ck103 = 0 time = 1040
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=1040.05n

* CHECK dout0_22 Vdout0_22ck103 = 1.8 time = 1040
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=1040.05n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 1040
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=1040.05n

* CHECK dout0_24 Vdout0_24ck103 = 1.8 time = 1040
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=1040.05n

* CHECK dout0_25 Vdout0_25ck103 = 1.8 time = 1040
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=1040.05n

* CHECK dout0_26 Vdout0_26ck103 = 1.8 time = 1040
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=1040.05n

* CHECK dout0_27 Vdout0_27ck103 = 1.8 time = 1040
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=1040.05n

* CHECK dout0_28 Vdout0_28ck103 = 0 time = 1040
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=1040.05n

* CHECK dout0_29 Vdout0_29ck103 = 1.8 time = 1040
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=1040.05n

* CHECK dout0_30 Vdout0_30ck103 = 1.8 time = 1040
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=1040.05n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 1040
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=1040.05n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 1040
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=1040.05n

* CHECK dout0_0 Vdout0_0ck105 = 1.8 time = 1060
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=1060.05n

* CHECK dout0_1 Vdout0_1ck105 = 1.8 time = 1060
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=1060.05n

* CHECK dout0_2 Vdout0_2ck105 = 1.8 time = 1060
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=1060.05n

* CHECK dout0_3 Vdout0_3ck105 = 0 time = 1060
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=1060.05n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 1060
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=1060.05n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 1060
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=1060.05n

* CHECK dout0_6 Vdout0_6ck105 = 1.8 time = 1060
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=1060.05n

* CHECK dout0_7 Vdout0_7ck105 = 0 time = 1060
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=1060.05n

* CHECK dout0_8 Vdout0_8ck105 = 1.8 time = 1060
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=1060.05n

* CHECK dout0_9 Vdout0_9ck105 = 1.8 time = 1060
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=1060.05n

* CHECK dout0_10 Vdout0_10ck105 = 1.8 time = 1060
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=1060.05n

* CHECK dout0_11 Vdout0_11ck105 = 1.8 time = 1060
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=1060.05n

* CHECK dout0_12 Vdout0_12ck105 = 1.8 time = 1060
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=1060.05n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 1060
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=1060.05n

* CHECK dout0_14 Vdout0_14ck105 = 1.8 time = 1060
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=1060.05n

* CHECK dout0_15 Vdout0_15ck105 = 0 time = 1060
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=1060.05n

* CHECK dout0_16 Vdout0_16ck105 = 1.8 time = 1060
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=1060.05n

* CHECK dout0_17 Vdout0_17ck105 = 1.8 time = 1060
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=1060.05n

* CHECK dout0_18 Vdout0_18ck105 = 1.8 time = 1060
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=1060.05n

* CHECK dout0_19 Vdout0_19ck105 = 1.8 time = 1060
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=1060.05n

* CHECK dout0_20 Vdout0_20ck105 = 1.8 time = 1060
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=1060.05n

* CHECK dout0_21 Vdout0_21ck105 = 1.8 time = 1060
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=1060.05n

* CHECK dout0_22 Vdout0_22ck105 = 0 time = 1060
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=1060.05n

* CHECK dout0_23 Vdout0_23ck105 = 1.8 time = 1060
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=1060.05n

* CHECK dout0_24 Vdout0_24ck105 = 1.8 time = 1060
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=1060.05n

* CHECK dout0_25 Vdout0_25ck105 = 0 time = 1060
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=1060.05n

* CHECK dout0_26 Vdout0_26ck105 = 1.8 time = 1060
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=1060.05n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 1060
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=1060.05n

* CHECK dout0_28 Vdout0_28ck105 = 0 time = 1060
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=1060.05n

* CHECK dout0_29 Vdout0_29ck105 = 1.8 time = 1060
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=1060.05n

* CHECK dout0_30 Vdout0_30ck105 = 1.8 time = 1060
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=1060.05n

* CHECK dout0_31 Vdout0_31ck105 = 1.8 time = 1060
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=1060.05n

* CHECK dout0_32 Vdout0_32ck105 = 0 time = 1060
.meas tran vdout0_32ck105 FIND v(dout0_32) AT=1060.05n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 1080
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=1080.05n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 1080
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=1080.05n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 1080
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=1080.05n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 1080
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=1080.05n

* CHECK dout0_4 Vdout0_4ck107 = 0 time = 1080
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=1080.05n

* CHECK dout0_5 Vdout0_5ck107 = 1.8 time = 1080
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=1080.05n

* CHECK dout0_6 Vdout0_6ck107 = 0 time = 1080
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=1080.05n

* CHECK dout0_7 Vdout0_7ck107 = 1.8 time = 1080
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=1080.05n

* CHECK dout0_8 Vdout0_8ck107 = 1.8 time = 1080
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=1080.05n

* CHECK dout0_9 Vdout0_9ck107 = 0 time = 1080
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=1080.05n

* CHECK dout0_10 Vdout0_10ck107 = 1.8 time = 1080
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=1080.05n

* CHECK dout0_11 Vdout0_11ck107 = 1.8 time = 1080
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=1080.05n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 1080
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=1080.05n

* CHECK dout0_13 Vdout0_13ck107 = 1.8 time = 1080
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=1080.05n

* CHECK dout0_14 Vdout0_14ck107 = 1.8 time = 1080
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=1080.05n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 1080
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=1080.05n

* CHECK dout0_16 Vdout0_16ck107 = 1.8 time = 1080
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=1080.05n

* CHECK dout0_17 Vdout0_17ck107 = 1.8 time = 1080
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=1080.05n

* CHECK dout0_18 Vdout0_18ck107 = 0 time = 1080
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=1080.05n

* CHECK dout0_19 Vdout0_19ck107 = 1.8 time = 1080
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=1080.05n

* CHECK dout0_20 Vdout0_20ck107 = 1.8 time = 1080
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=1080.05n

* CHECK dout0_21 Vdout0_21ck107 = 0 time = 1080
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=1080.05n

* CHECK dout0_22 Vdout0_22ck107 = 1.8 time = 1080
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=1080.05n

* CHECK dout0_23 Vdout0_23ck107 = 0 time = 1080
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=1080.05n

* CHECK dout0_24 Vdout0_24ck107 = 1.8 time = 1080
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=1080.05n

* CHECK dout0_25 Vdout0_25ck107 = 1.8 time = 1080
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=1080.05n

* CHECK dout0_26 Vdout0_26ck107 = 0 time = 1080
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=1080.05n

* CHECK dout0_27 Vdout0_27ck107 = 1.8 time = 1080
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=1080.05n

* CHECK dout0_28 Vdout0_28ck107 = 0 time = 1080
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=1080.05n

* CHECK dout0_29 Vdout0_29ck107 = 1.8 time = 1080
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=1080.05n

* CHECK dout0_30 Vdout0_30ck107 = 1.8 time = 1080
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=1080.05n

* CHECK dout0_31 Vdout0_31ck107 = 1.8 time = 1080
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=1080.05n

* CHECK dout0_32 Vdout0_32ck107 = 0 time = 1080
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=1080.05n

* CHECK dout0_0 Vdout0_0ck108 = 1.8 time = 1090
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=1090.05n

* CHECK dout0_1 Vdout0_1ck108 = 0 time = 1090
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=1090.05n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 1090
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=1090.05n

* CHECK dout0_3 Vdout0_3ck108 = 0 time = 1090
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=1090.05n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 1090
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=1090.05n

* CHECK dout0_5 Vdout0_5ck108 = 1.8 time = 1090
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=1090.05n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 1090
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=1090.05n

* CHECK dout0_7 Vdout0_7ck108 = 1.8 time = 1090
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=1090.05n

* CHECK dout0_8 Vdout0_8ck108 = 1.8 time = 1090
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=1090.05n

* CHECK dout0_9 Vdout0_9ck108 = 0 time = 1090
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=1090.05n

* CHECK dout0_10 Vdout0_10ck108 = 1.8 time = 1090
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=1090.05n

* CHECK dout0_11 Vdout0_11ck108 = 1.8 time = 1090
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=1090.05n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 1090
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=1090.05n

* CHECK dout0_13 Vdout0_13ck108 = 1.8 time = 1090
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=1090.05n

* CHECK dout0_14 Vdout0_14ck108 = 1.8 time = 1090
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=1090.05n

* CHECK dout0_15 Vdout0_15ck108 = 0 time = 1090
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=1090.05n

* CHECK dout0_16 Vdout0_16ck108 = 1.8 time = 1090
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=1090.05n

* CHECK dout0_17 Vdout0_17ck108 = 1.8 time = 1090
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=1090.05n

* CHECK dout0_18 Vdout0_18ck108 = 0 time = 1090
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=1090.05n

* CHECK dout0_19 Vdout0_19ck108 = 1.8 time = 1090
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=1090.05n

* CHECK dout0_20 Vdout0_20ck108 = 1.8 time = 1090
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=1090.05n

* CHECK dout0_21 Vdout0_21ck108 = 0 time = 1090
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=1090.05n

* CHECK dout0_22 Vdout0_22ck108 = 1.8 time = 1090
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=1090.05n

* CHECK dout0_23 Vdout0_23ck108 = 0 time = 1090
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=1090.05n

* CHECK dout0_24 Vdout0_24ck108 = 1.8 time = 1090
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=1090.05n

* CHECK dout0_25 Vdout0_25ck108 = 1.8 time = 1090
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=1090.05n

* CHECK dout0_26 Vdout0_26ck108 = 0 time = 1090
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=1090.05n

* CHECK dout0_27 Vdout0_27ck108 = 1.8 time = 1090
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=1090.05n

* CHECK dout0_28 Vdout0_28ck108 = 0 time = 1090
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=1090.05n

* CHECK dout0_29 Vdout0_29ck108 = 1.8 time = 1090
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=1090.05n

* CHECK dout0_30 Vdout0_30ck108 = 1.8 time = 1090
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=1090.05n

* CHECK dout0_31 Vdout0_31ck108 = 1.8 time = 1090
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=1090.05n

* CHECK dout0_32 Vdout0_32ck108 = 0 time = 1090
.meas tran vdout0_32ck108 FIND v(dout0_32) AT=1090.05n

* CHECK dout0_0 Vdout0_0ck115 = 0 time = 1160
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=1160.05n

* CHECK dout0_1 Vdout0_1ck115 = 1.8 time = 1160
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=1160.05n

* CHECK dout0_2 Vdout0_2ck115 = 1.8 time = 1160
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=1160.05n

* CHECK dout0_3 Vdout0_3ck115 = 1.8 time = 1160
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=1160.05n

* CHECK dout0_4 Vdout0_4ck115 = 1.8 time = 1160
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=1160.05n

* CHECK dout0_5 Vdout0_5ck115 = 1.8 time = 1160
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=1160.05n

* CHECK dout0_6 Vdout0_6ck115 = 1.8 time = 1160
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=1160.05n

* CHECK dout0_7 Vdout0_7ck115 = 1.8 time = 1160
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=1160.05n

* CHECK dout0_8 Vdout0_8ck115 = 0 time = 1160
.meas tran vdout0_8ck115 FIND v(dout0_8) AT=1160.05n

* CHECK dout0_9 Vdout0_9ck115 = 1.8 time = 1160
.meas tran vdout0_9ck115 FIND v(dout0_9) AT=1160.05n

* CHECK dout0_10 Vdout0_10ck115 = 0 time = 1160
.meas tran vdout0_10ck115 FIND v(dout0_10) AT=1160.05n

* CHECK dout0_11 Vdout0_11ck115 = 0 time = 1160
.meas tran vdout0_11ck115 FIND v(dout0_11) AT=1160.05n

* CHECK dout0_12 Vdout0_12ck115 = 0 time = 1160
.meas tran vdout0_12ck115 FIND v(dout0_12) AT=1160.05n

* CHECK dout0_13 Vdout0_13ck115 = 1.8 time = 1160
.meas tran vdout0_13ck115 FIND v(dout0_13) AT=1160.05n

* CHECK dout0_14 Vdout0_14ck115 = 0 time = 1160
.meas tran vdout0_14ck115 FIND v(dout0_14) AT=1160.05n

* CHECK dout0_15 Vdout0_15ck115 = 1.8 time = 1160
.meas tran vdout0_15ck115 FIND v(dout0_15) AT=1160.05n

* CHECK dout0_16 Vdout0_16ck115 = 1.8 time = 1160
.meas tran vdout0_16ck115 FIND v(dout0_16) AT=1160.05n

* CHECK dout0_17 Vdout0_17ck115 = 0 time = 1160
.meas tran vdout0_17ck115 FIND v(dout0_17) AT=1160.05n

* CHECK dout0_18 Vdout0_18ck115 = 0 time = 1160
.meas tran vdout0_18ck115 FIND v(dout0_18) AT=1160.05n

* CHECK dout0_19 Vdout0_19ck115 = 0 time = 1160
.meas tran vdout0_19ck115 FIND v(dout0_19) AT=1160.05n

* CHECK dout0_20 Vdout0_20ck115 = 1.8 time = 1160
.meas tran vdout0_20ck115 FIND v(dout0_20) AT=1160.05n

* CHECK dout0_21 Vdout0_21ck115 = 0 time = 1160
.meas tran vdout0_21ck115 FIND v(dout0_21) AT=1160.05n

* CHECK dout0_22 Vdout0_22ck115 = 0 time = 1160
.meas tran vdout0_22ck115 FIND v(dout0_22) AT=1160.05n

* CHECK dout0_23 Vdout0_23ck115 = 1.8 time = 1160
.meas tran vdout0_23ck115 FIND v(dout0_23) AT=1160.05n

* CHECK dout0_24 Vdout0_24ck115 = 1.8 time = 1160
.meas tran vdout0_24ck115 FIND v(dout0_24) AT=1160.05n

* CHECK dout0_25 Vdout0_25ck115 = 0 time = 1160
.meas tran vdout0_25ck115 FIND v(dout0_25) AT=1160.05n

* CHECK dout0_26 Vdout0_26ck115 = 1.8 time = 1160
.meas tran vdout0_26ck115 FIND v(dout0_26) AT=1160.05n

* CHECK dout0_27 Vdout0_27ck115 = 0 time = 1160
.meas tran vdout0_27ck115 FIND v(dout0_27) AT=1160.05n

* CHECK dout0_28 Vdout0_28ck115 = 0 time = 1160
.meas tran vdout0_28ck115 FIND v(dout0_28) AT=1160.05n

* CHECK dout0_29 Vdout0_29ck115 = 1.8 time = 1160
.meas tran vdout0_29ck115 FIND v(dout0_29) AT=1160.05n

* CHECK dout0_30 Vdout0_30ck115 = 0 time = 1160
.meas tran vdout0_30ck115 FIND v(dout0_30) AT=1160.05n

* CHECK dout0_31 Vdout0_31ck115 = 1.8 time = 1160
.meas tran vdout0_31ck115 FIND v(dout0_31) AT=1160.05n

* CHECK dout0_32 Vdout0_32ck115 = 0 time = 1160
.meas tran vdout0_32ck115 FIND v(dout0_32) AT=1160.05n

* CHECK dout0_0 Vdout0_0ck118 = 1.8 time = 1190
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=1190.05n

* CHECK dout0_1 Vdout0_1ck118 = 1.8 time = 1190
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=1190.05n

* CHECK dout0_2 Vdout0_2ck118 = 1.8 time = 1190
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=1190.05n

* CHECK dout0_3 Vdout0_3ck118 = 0 time = 1190
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=1190.05n

* CHECK dout0_4 Vdout0_4ck118 = 0 time = 1190
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=1190.05n

* CHECK dout0_5 Vdout0_5ck118 = 0 time = 1190
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=1190.05n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 1190
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=1190.05n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 1190
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=1190.05n

* CHECK dout0_8 Vdout0_8ck118 = 1.8 time = 1190
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=1190.05n

* CHECK dout0_9 Vdout0_9ck118 = 1.8 time = 1190
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=1190.05n

* CHECK dout0_10 Vdout0_10ck118 = 1.8 time = 1190
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=1190.05n

* CHECK dout0_11 Vdout0_11ck118 = 1.8 time = 1190
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=1190.05n

* CHECK dout0_12 Vdout0_12ck118 = 1.8 time = 1190
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=1190.05n

* CHECK dout0_13 Vdout0_13ck118 = 1.8 time = 1190
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=1190.05n

* CHECK dout0_14 Vdout0_14ck118 = 1.8 time = 1190
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=1190.05n

* CHECK dout0_15 Vdout0_15ck118 = 0 time = 1190
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=1190.05n

* CHECK dout0_16 Vdout0_16ck118 = 1.8 time = 1190
.meas tran vdout0_16ck118 FIND v(dout0_16) AT=1190.05n

* CHECK dout0_17 Vdout0_17ck118 = 1.8 time = 1190
.meas tran vdout0_17ck118 FIND v(dout0_17) AT=1190.05n

* CHECK dout0_18 Vdout0_18ck118 = 1.8 time = 1190
.meas tran vdout0_18ck118 FIND v(dout0_18) AT=1190.05n

* CHECK dout0_19 Vdout0_19ck118 = 1.8 time = 1190
.meas tran vdout0_19ck118 FIND v(dout0_19) AT=1190.05n

* CHECK dout0_20 Vdout0_20ck118 = 1.8 time = 1190
.meas tran vdout0_20ck118 FIND v(dout0_20) AT=1190.05n

* CHECK dout0_21 Vdout0_21ck118 = 1.8 time = 1190
.meas tran vdout0_21ck118 FIND v(dout0_21) AT=1190.05n

* CHECK dout0_22 Vdout0_22ck118 = 0 time = 1190
.meas tran vdout0_22ck118 FIND v(dout0_22) AT=1190.05n

* CHECK dout0_23 Vdout0_23ck118 = 1.8 time = 1190
.meas tran vdout0_23ck118 FIND v(dout0_23) AT=1190.05n

* CHECK dout0_24 Vdout0_24ck118 = 1.8 time = 1190
.meas tran vdout0_24ck118 FIND v(dout0_24) AT=1190.05n

* CHECK dout0_25 Vdout0_25ck118 = 0 time = 1190
.meas tran vdout0_25ck118 FIND v(dout0_25) AT=1190.05n

* CHECK dout0_26 Vdout0_26ck118 = 1.8 time = 1190
.meas tran vdout0_26ck118 FIND v(dout0_26) AT=1190.05n

* CHECK dout0_27 Vdout0_27ck118 = 0 time = 1190
.meas tran vdout0_27ck118 FIND v(dout0_27) AT=1190.05n

* CHECK dout0_28 Vdout0_28ck118 = 0 time = 1190
.meas tran vdout0_28ck118 FIND v(dout0_28) AT=1190.05n

* CHECK dout0_29 Vdout0_29ck118 = 1.8 time = 1190
.meas tran vdout0_29ck118 FIND v(dout0_29) AT=1190.05n

* CHECK dout0_30 Vdout0_30ck118 = 1.8 time = 1190
.meas tran vdout0_30ck118 FIND v(dout0_30) AT=1190.05n

* CHECK dout0_31 Vdout0_31ck118 = 1.8 time = 1190
.meas tran vdout0_31ck118 FIND v(dout0_31) AT=1190.05n

* CHECK dout0_32 Vdout0_32ck118 = 0 time = 1190
.meas tran vdout0_32ck118 FIND v(dout0_32) AT=1190.05n

* CHECK dout0_0 Vdout0_0ck119 = 1.8 time = 1200
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=1200.05n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 1200
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=1200.05n

* CHECK dout0_2 Vdout0_2ck119 = 1.8 time = 1200
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=1200.05n

* CHECK dout0_3 Vdout0_3ck119 = 1.8 time = 1200
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=1200.05n

* CHECK dout0_4 Vdout0_4ck119 = 1.8 time = 1200
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=1200.05n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 1200
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=1200.05n

* CHECK dout0_6 Vdout0_6ck119 = 1.8 time = 1200
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=1200.05n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 1200
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=1200.05n

* CHECK dout0_8 Vdout0_8ck119 = 1.8 time = 1200
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=1200.05n

* CHECK dout0_9 Vdout0_9ck119 = 0 time = 1200
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=1200.05n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 1200
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=1200.05n

* CHECK dout0_11 Vdout0_11ck119 = 1.8 time = 1200
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=1200.05n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 1200
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=1200.05n

* CHECK dout0_13 Vdout0_13ck119 = 0 time = 1200
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=1200.05n

* CHECK dout0_14 Vdout0_14ck119 = 0 time = 1200
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=1200.05n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 1200
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=1200.05n

* CHECK dout0_16 Vdout0_16ck119 = 1.8 time = 1200
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=1200.05n

* CHECK dout0_17 Vdout0_17ck119 = 0 time = 1200
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=1200.05n

* CHECK dout0_18 Vdout0_18ck119 = 0 time = 1200
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=1200.05n

* CHECK dout0_19 Vdout0_19ck119 = 0 time = 1200
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=1200.05n

* CHECK dout0_20 Vdout0_20ck119 = 0 time = 1200
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=1200.05n

* CHECK dout0_21 Vdout0_21ck119 = 1.8 time = 1200
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=1200.05n

* CHECK dout0_22 Vdout0_22ck119 = 0 time = 1200
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=1200.05n

* CHECK dout0_23 Vdout0_23ck119 = 1.8 time = 1200
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=1200.05n

* CHECK dout0_24 Vdout0_24ck119 = 1.8 time = 1200
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=1200.05n

* CHECK dout0_25 Vdout0_25ck119 = 0 time = 1200
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=1200.05n

* CHECK dout0_26 Vdout0_26ck119 = 0 time = 1200
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=1200.05n

* CHECK dout0_27 Vdout0_27ck119 = 0 time = 1200
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=1200.05n

* CHECK dout0_28 Vdout0_28ck119 = 1.8 time = 1200
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=1200.05n

* CHECK dout0_29 Vdout0_29ck119 = 0 time = 1200
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=1200.05n

* CHECK dout0_30 Vdout0_30ck119 = 1.8 time = 1200
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=1200.05n

* CHECK dout0_31 Vdout0_31ck119 = 1.8 time = 1200
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=1200.05n

* CHECK dout0_32 Vdout0_32ck119 = 0 time = 1200
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=1200.05n

* CHECK dout0_0 Vdout0_0ck121 = 1.8 time = 1220
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=1220.05n

* CHECK dout0_1 Vdout0_1ck121 = 1.8 time = 1220
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=1220.05n

* CHECK dout0_2 Vdout0_2ck121 = 0 time = 1220
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=1220.05n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 1220
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=1220.05n

* CHECK dout0_4 Vdout0_4ck121 = 1.8 time = 1220
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=1220.05n

* CHECK dout0_5 Vdout0_5ck121 = 1.8 time = 1220
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=1220.05n

* CHECK dout0_6 Vdout0_6ck121 = 1.8 time = 1220
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=1220.05n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 1220
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=1220.05n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 1220
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=1220.05n

* CHECK dout0_9 Vdout0_9ck121 = 1.8 time = 1220
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=1220.05n

* CHECK dout0_10 Vdout0_10ck121 = 1.8 time = 1220
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=1220.05n

* CHECK dout0_11 Vdout0_11ck121 = 1.8 time = 1220
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=1220.05n

* CHECK dout0_12 Vdout0_12ck121 = 1.8 time = 1220
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=1220.05n

* CHECK dout0_13 Vdout0_13ck121 = 1.8 time = 1220
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=1220.05n

* CHECK dout0_14 Vdout0_14ck121 = 1.8 time = 1220
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=1220.05n

* CHECK dout0_15 Vdout0_15ck121 = 1.8 time = 1220
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=1220.05n

* CHECK dout0_16 Vdout0_16ck121 = 1.8 time = 1220
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=1220.05n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 1220
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=1220.05n

* CHECK dout0_18 Vdout0_18ck121 = 0 time = 1220
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=1220.05n

* CHECK dout0_19 Vdout0_19ck121 = 0 time = 1220
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=1220.05n

* CHECK dout0_20 Vdout0_20ck121 = 1.8 time = 1220
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=1220.05n

* CHECK dout0_21 Vdout0_21ck121 = 0 time = 1220
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=1220.05n

* CHECK dout0_22 Vdout0_22ck121 = 0 time = 1220
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=1220.05n

* CHECK dout0_23 Vdout0_23ck121 = 0 time = 1220
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=1220.05n

* CHECK dout0_24 Vdout0_24ck121 = 0 time = 1220
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=1220.05n

* CHECK dout0_25 Vdout0_25ck121 = 0 time = 1220
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=1220.05n

* CHECK dout0_26 Vdout0_26ck121 = 1.8 time = 1220
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=1220.05n

* CHECK dout0_27 Vdout0_27ck121 = 1.8 time = 1220
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=1220.05n

* CHECK dout0_28 Vdout0_28ck121 = 1.8 time = 1220
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=1220.05n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 1220
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=1220.05n

* CHECK dout0_30 Vdout0_30ck121 = 0 time = 1220
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=1220.05n

* CHECK dout0_31 Vdout0_31ck121 = 1.8 time = 1220
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=1220.05n

* CHECK dout0_32 Vdout0_32ck121 = 0 time = 1220
.meas tran vdout0_32ck121 FIND v(dout0_32) AT=1220.05n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 1230
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=1230.05n

* CHECK dout0_1 Vdout0_1ck122 = 0 time = 1230
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=1230.05n

* CHECK dout0_2 Vdout0_2ck122 = 1.8 time = 1230
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=1230.05n

* CHECK dout0_3 Vdout0_3ck122 = 1.8 time = 1230
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=1230.05n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 1230
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=1230.05n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 1230
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=1230.05n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 1230
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=1230.05n

* CHECK dout0_7 Vdout0_7ck122 = 1.8 time = 1230
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=1230.05n

* CHECK dout0_8 Vdout0_8ck122 = 1.8 time = 1230
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=1230.05n

* CHECK dout0_9 Vdout0_9ck122 = 0 time = 1230
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=1230.05n

* CHECK dout0_10 Vdout0_10ck122 = 1.8 time = 1230
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=1230.05n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 1230
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=1230.05n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 1230
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=1230.05n

* CHECK dout0_13 Vdout0_13ck122 = 1.8 time = 1230
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=1230.05n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 1230
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=1230.05n

* CHECK dout0_15 Vdout0_15ck122 = 0 time = 1230
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=1230.05n

* CHECK dout0_16 Vdout0_16ck122 = 1.8 time = 1230
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=1230.05n

* CHECK dout0_17 Vdout0_17ck122 = 1.8 time = 1230
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=1230.05n

* CHECK dout0_18 Vdout0_18ck122 = 0 time = 1230
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=1230.05n

* CHECK dout0_19 Vdout0_19ck122 = 1.8 time = 1230
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=1230.05n

* CHECK dout0_20 Vdout0_20ck122 = 0 time = 1230
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=1230.05n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 1230
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=1230.05n

* CHECK dout0_22 Vdout0_22ck122 = 0 time = 1230
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=1230.05n

* CHECK dout0_23 Vdout0_23ck122 = 0 time = 1230
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=1230.05n

* CHECK dout0_24 Vdout0_24ck122 = 1.8 time = 1230
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=1230.05n

* CHECK dout0_25 Vdout0_25ck122 = 1.8 time = 1230
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=1230.05n

* CHECK dout0_26 Vdout0_26ck122 = 1.8 time = 1230
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=1230.05n

* CHECK dout0_27 Vdout0_27ck122 = 0 time = 1230
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=1230.05n

* CHECK dout0_28 Vdout0_28ck122 = 0 time = 1230
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=1230.05n

* CHECK dout0_29 Vdout0_29ck122 = 0 time = 1230
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=1230.05n

* CHECK dout0_30 Vdout0_30ck122 = 1.8 time = 1230
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=1230.05n

* CHECK dout0_31 Vdout0_31ck122 = 0 time = 1230
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=1230.05n

* CHECK dout0_32 Vdout0_32ck122 = 0 time = 1230
.meas tran vdout0_32ck122 FIND v(dout0_32) AT=1230.05n

* CHECK dout0_0 Vdout0_0ck123 = 1.8 time = 1240
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=1240.05n

* CHECK dout0_1 Vdout0_1ck123 = 1.8 time = 1240
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=1240.05n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 1240
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=1240.05n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 1240
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=1240.05n

* CHECK dout0_4 Vdout0_4ck123 = 1.8 time = 1240
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=1240.05n

* CHECK dout0_5 Vdout0_5ck123 = 1.8 time = 1240
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=1240.05n

* CHECK dout0_6 Vdout0_6ck123 = 1.8 time = 1240
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=1240.05n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 1240
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=1240.05n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 1240
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=1240.05n

* CHECK dout0_9 Vdout0_9ck123 = 1.8 time = 1240
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=1240.05n

* CHECK dout0_10 Vdout0_10ck123 = 1.8 time = 1240
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=1240.05n

* CHECK dout0_11 Vdout0_11ck123 = 1.8 time = 1240
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=1240.05n

* CHECK dout0_12 Vdout0_12ck123 = 1.8 time = 1240
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=1240.05n

* CHECK dout0_13 Vdout0_13ck123 = 1.8 time = 1240
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=1240.05n

* CHECK dout0_14 Vdout0_14ck123 = 1.8 time = 1240
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=1240.05n

* CHECK dout0_15 Vdout0_15ck123 = 1.8 time = 1240
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=1240.05n

* CHECK dout0_16 Vdout0_16ck123 = 1.8 time = 1240
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=1240.05n

* CHECK dout0_17 Vdout0_17ck123 = 0 time = 1240
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=1240.05n

* CHECK dout0_18 Vdout0_18ck123 = 0 time = 1240
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=1240.05n

* CHECK dout0_19 Vdout0_19ck123 = 0 time = 1240
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=1240.05n

* CHECK dout0_20 Vdout0_20ck123 = 1.8 time = 1240
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=1240.05n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 1240
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=1240.05n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 1240
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=1240.05n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 1240
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=1240.05n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 1240
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=1240.05n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 1240
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=1240.05n

* CHECK dout0_26 Vdout0_26ck123 = 1.8 time = 1240
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=1240.05n

* CHECK dout0_27 Vdout0_27ck123 = 1.8 time = 1240
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=1240.05n

* CHECK dout0_28 Vdout0_28ck123 = 1.8 time = 1240
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=1240.05n

* CHECK dout0_29 Vdout0_29ck123 = 0 time = 1240
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=1240.05n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 1240
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=1240.05n

* CHECK dout0_31 Vdout0_31ck123 = 1.8 time = 1240
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=1240.05n

* CHECK dout0_32 Vdout0_32ck123 = 0 time = 1240
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=1240.05n

* CHECK dout0_0 Vdout0_0ck132 = 1.8 time = 1330
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=1330.05n

* CHECK dout0_1 Vdout0_1ck132 = 0 time = 1330
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=1330.05n

* CHECK dout0_2 Vdout0_2ck132 = 0 time = 1330
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=1330.05n

* CHECK dout0_3 Vdout0_3ck132 = 0 time = 1330
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=1330.05n

* CHECK dout0_4 Vdout0_4ck132 = 0 time = 1330
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=1330.05n

* CHECK dout0_5 Vdout0_5ck132 = 1.8 time = 1330
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=1330.05n

* CHECK dout0_6 Vdout0_6ck132 = 0 time = 1330
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=1330.05n

* CHECK dout0_7 Vdout0_7ck132 = 1.8 time = 1330
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=1330.05n

* CHECK dout0_8 Vdout0_8ck132 = 1.8 time = 1330
.meas tran vdout0_8ck132 FIND v(dout0_8) AT=1330.05n

* CHECK dout0_9 Vdout0_9ck132 = 0 time = 1330
.meas tran vdout0_9ck132 FIND v(dout0_9) AT=1330.05n

* CHECK dout0_10 Vdout0_10ck132 = 1.8 time = 1330
.meas tran vdout0_10ck132 FIND v(dout0_10) AT=1330.05n

* CHECK dout0_11 Vdout0_11ck132 = 1.8 time = 1330
.meas tran vdout0_11ck132 FIND v(dout0_11) AT=1330.05n

* CHECK dout0_12 Vdout0_12ck132 = 0 time = 1330
.meas tran vdout0_12ck132 FIND v(dout0_12) AT=1330.05n

* CHECK dout0_13 Vdout0_13ck132 = 1.8 time = 1330
.meas tran vdout0_13ck132 FIND v(dout0_13) AT=1330.05n

* CHECK dout0_14 Vdout0_14ck132 = 1.8 time = 1330
.meas tran vdout0_14ck132 FIND v(dout0_14) AT=1330.05n

* CHECK dout0_15 Vdout0_15ck132 = 0 time = 1330
.meas tran vdout0_15ck132 FIND v(dout0_15) AT=1330.05n

* CHECK dout0_16 Vdout0_16ck132 = 1.8 time = 1330
.meas tran vdout0_16ck132 FIND v(dout0_16) AT=1330.05n

* CHECK dout0_17 Vdout0_17ck132 = 1.8 time = 1330
.meas tran vdout0_17ck132 FIND v(dout0_17) AT=1330.05n

* CHECK dout0_18 Vdout0_18ck132 = 0 time = 1330
.meas tran vdout0_18ck132 FIND v(dout0_18) AT=1330.05n

* CHECK dout0_19 Vdout0_19ck132 = 1.8 time = 1330
.meas tran vdout0_19ck132 FIND v(dout0_19) AT=1330.05n

* CHECK dout0_20 Vdout0_20ck132 = 1.8 time = 1330
.meas tran vdout0_20ck132 FIND v(dout0_20) AT=1330.05n

* CHECK dout0_21 Vdout0_21ck132 = 0 time = 1330
.meas tran vdout0_21ck132 FIND v(dout0_21) AT=1330.05n

* CHECK dout0_22 Vdout0_22ck132 = 1.8 time = 1330
.meas tran vdout0_22ck132 FIND v(dout0_22) AT=1330.05n

* CHECK dout0_23 Vdout0_23ck132 = 0 time = 1330
.meas tran vdout0_23ck132 FIND v(dout0_23) AT=1330.05n

* CHECK dout0_24 Vdout0_24ck132 = 1.8 time = 1330
.meas tran vdout0_24ck132 FIND v(dout0_24) AT=1330.05n

* CHECK dout0_25 Vdout0_25ck132 = 1.8 time = 1330
.meas tran vdout0_25ck132 FIND v(dout0_25) AT=1330.05n

* CHECK dout0_26 Vdout0_26ck132 = 0 time = 1330
.meas tran vdout0_26ck132 FIND v(dout0_26) AT=1330.05n

* CHECK dout0_27 Vdout0_27ck132 = 1.8 time = 1330
.meas tran vdout0_27ck132 FIND v(dout0_27) AT=1330.05n

* CHECK dout0_28 Vdout0_28ck132 = 0 time = 1330
.meas tran vdout0_28ck132 FIND v(dout0_28) AT=1330.05n

* CHECK dout0_29 Vdout0_29ck132 = 1.8 time = 1330
.meas tran vdout0_29ck132 FIND v(dout0_29) AT=1330.05n

* CHECK dout0_30 Vdout0_30ck132 = 1.8 time = 1330
.meas tran vdout0_30ck132 FIND v(dout0_30) AT=1330.05n

* CHECK dout0_31 Vdout0_31ck132 = 1.8 time = 1330
.meas tran vdout0_31ck132 FIND v(dout0_31) AT=1330.05n

* CHECK dout0_32 Vdout0_32ck132 = 0 time = 1330
.meas tran vdout0_32ck132 FIND v(dout0_32) AT=1330.05n

* CHECK dout0_0 Vdout0_0ck135 = 1.8 time = 1360
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=1360.05n

* CHECK dout0_1 Vdout0_1ck135 = 1.8 time = 1360
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=1360.05n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 1360
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=1360.05n

* CHECK dout0_3 Vdout0_3ck135 = 0 time = 1360
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=1360.05n

* CHECK dout0_4 Vdout0_4ck135 = 1.8 time = 1360
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=1360.05n

* CHECK dout0_5 Vdout0_5ck135 = 1.8 time = 1360
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=1360.05n

* CHECK dout0_6 Vdout0_6ck135 = 1.8 time = 1360
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=1360.05n

* CHECK dout0_7 Vdout0_7ck135 = 0 time = 1360
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=1360.05n

* CHECK dout0_8 Vdout0_8ck135 = 0 time = 1360
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=1360.05n

* CHECK dout0_9 Vdout0_9ck135 = 1.8 time = 1360
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=1360.05n

* CHECK dout0_10 Vdout0_10ck135 = 1.8 time = 1360
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=1360.05n

* CHECK dout0_11 Vdout0_11ck135 = 1.8 time = 1360
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=1360.05n

* CHECK dout0_12 Vdout0_12ck135 = 1.8 time = 1360
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=1360.05n

* CHECK dout0_13 Vdout0_13ck135 = 1.8 time = 1360
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=1360.05n

* CHECK dout0_14 Vdout0_14ck135 = 1.8 time = 1360
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=1360.05n

* CHECK dout0_15 Vdout0_15ck135 = 1.8 time = 1360
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=1360.05n

* CHECK dout0_16 Vdout0_16ck135 = 1.8 time = 1360
.meas tran vdout0_16ck135 FIND v(dout0_16) AT=1360.05n

* CHECK dout0_17 Vdout0_17ck135 = 0 time = 1360
.meas tran vdout0_17ck135 FIND v(dout0_17) AT=1360.05n

* CHECK dout0_18 Vdout0_18ck135 = 0 time = 1360
.meas tran vdout0_18ck135 FIND v(dout0_18) AT=1360.05n

* CHECK dout0_19 Vdout0_19ck135 = 0 time = 1360
.meas tran vdout0_19ck135 FIND v(dout0_19) AT=1360.05n

* CHECK dout0_20 Vdout0_20ck135 = 1.8 time = 1360
.meas tran vdout0_20ck135 FIND v(dout0_20) AT=1360.05n

* CHECK dout0_21 Vdout0_21ck135 = 0 time = 1360
.meas tran vdout0_21ck135 FIND v(dout0_21) AT=1360.05n

* CHECK dout0_22 Vdout0_22ck135 = 0 time = 1360
.meas tran vdout0_22ck135 FIND v(dout0_22) AT=1360.05n

* CHECK dout0_23 Vdout0_23ck135 = 0 time = 1360
.meas tran vdout0_23ck135 FIND v(dout0_23) AT=1360.05n

* CHECK dout0_24 Vdout0_24ck135 = 0 time = 1360
.meas tran vdout0_24ck135 FIND v(dout0_24) AT=1360.05n

* CHECK dout0_25 Vdout0_25ck135 = 0 time = 1360
.meas tran vdout0_25ck135 FIND v(dout0_25) AT=1360.05n

* CHECK dout0_26 Vdout0_26ck135 = 1.8 time = 1360
.meas tran vdout0_26ck135 FIND v(dout0_26) AT=1360.05n

* CHECK dout0_27 Vdout0_27ck135 = 1.8 time = 1360
.meas tran vdout0_27ck135 FIND v(dout0_27) AT=1360.05n

* CHECK dout0_28 Vdout0_28ck135 = 1.8 time = 1360
.meas tran vdout0_28ck135 FIND v(dout0_28) AT=1360.05n

* CHECK dout0_29 Vdout0_29ck135 = 0 time = 1360
.meas tran vdout0_29ck135 FIND v(dout0_29) AT=1360.05n

* CHECK dout0_30 Vdout0_30ck135 = 0 time = 1360
.meas tran vdout0_30ck135 FIND v(dout0_30) AT=1360.05n

* CHECK dout0_31 Vdout0_31ck135 = 1.8 time = 1360
.meas tran vdout0_31ck135 FIND v(dout0_31) AT=1360.05n

* CHECK dout0_32 Vdout0_32ck135 = 0 time = 1360
.meas tran vdout0_32ck135 FIND v(dout0_32) AT=1360.05n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 1370
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=1370.05n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 1370
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=1370.05n

* CHECK dout0_2 Vdout0_2ck136 = 0 time = 1370
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=1370.05n

* CHECK dout0_3 Vdout0_3ck136 = 1.8 time = 1370
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=1370.05n

* CHECK dout0_4 Vdout0_4ck136 = 1.8 time = 1370
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=1370.05n

* CHECK dout0_5 Vdout0_5ck136 = 1.8 time = 1370
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=1370.05n

* CHECK dout0_6 Vdout0_6ck136 = 1.8 time = 1370
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=1370.05n

* CHECK dout0_7 Vdout0_7ck136 = 1.8 time = 1370
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=1370.05n

* CHECK dout0_8 Vdout0_8ck136 = 1.8 time = 1370
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=1370.05n

* CHECK dout0_9 Vdout0_9ck136 = 0 time = 1370
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=1370.05n

* CHECK dout0_10 Vdout0_10ck136 = 0 time = 1370
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=1370.05n

* CHECK dout0_11 Vdout0_11ck136 = 1.8 time = 1370
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=1370.05n

* CHECK dout0_12 Vdout0_12ck136 = 1.8 time = 1370
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=1370.05n

* CHECK dout0_13 Vdout0_13ck136 = 1.8 time = 1370
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=1370.05n

* CHECK dout0_14 Vdout0_14ck136 = 0 time = 1370
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=1370.05n

* CHECK dout0_15 Vdout0_15ck136 = 1.8 time = 1370
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=1370.05n

* CHECK dout0_16 Vdout0_16ck136 = 1.8 time = 1370
.meas tran vdout0_16ck136 FIND v(dout0_16) AT=1370.05n

* CHECK dout0_17 Vdout0_17ck136 = 1.8 time = 1370
.meas tran vdout0_17ck136 FIND v(dout0_17) AT=1370.05n

* CHECK dout0_18 Vdout0_18ck136 = 0 time = 1370
.meas tran vdout0_18ck136 FIND v(dout0_18) AT=1370.05n

* CHECK dout0_19 Vdout0_19ck136 = 1.8 time = 1370
.meas tran vdout0_19ck136 FIND v(dout0_19) AT=1370.05n

* CHECK dout0_20 Vdout0_20ck136 = 1.8 time = 1370
.meas tran vdout0_20ck136 FIND v(dout0_20) AT=1370.05n

* CHECK dout0_21 Vdout0_21ck136 = 0 time = 1370
.meas tran vdout0_21ck136 FIND v(dout0_21) AT=1370.05n

* CHECK dout0_22 Vdout0_22ck136 = 0 time = 1370
.meas tran vdout0_22ck136 FIND v(dout0_22) AT=1370.05n

* CHECK dout0_23 Vdout0_23ck136 = 1.8 time = 1370
.meas tran vdout0_23ck136 FIND v(dout0_23) AT=1370.05n

* CHECK dout0_24 Vdout0_24ck136 = 0 time = 1370
.meas tran vdout0_24ck136 FIND v(dout0_24) AT=1370.05n

* CHECK dout0_25 Vdout0_25ck136 = 1.8 time = 1370
.meas tran vdout0_25ck136 FIND v(dout0_25) AT=1370.05n

* CHECK dout0_26 Vdout0_26ck136 = 0 time = 1370
.meas tran vdout0_26ck136 FIND v(dout0_26) AT=1370.05n

* CHECK dout0_27 Vdout0_27ck136 = 0 time = 1370
.meas tran vdout0_27ck136 FIND v(dout0_27) AT=1370.05n

* CHECK dout0_28 Vdout0_28ck136 = 0 time = 1370
.meas tran vdout0_28ck136 FIND v(dout0_28) AT=1370.05n

* CHECK dout0_29 Vdout0_29ck136 = 1.8 time = 1370
.meas tran vdout0_29ck136 FIND v(dout0_29) AT=1370.05n

* CHECK dout0_30 Vdout0_30ck136 = 1.8 time = 1370
.meas tran vdout0_30ck136 FIND v(dout0_30) AT=1370.05n

* CHECK dout0_31 Vdout0_31ck136 = 1.8 time = 1370
.meas tran vdout0_31ck136 FIND v(dout0_31) AT=1370.05n

* CHECK dout0_32 Vdout0_32ck136 = 0 time = 1370
.meas tran vdout0_32ck136 FIND v(dout0_32) AT=1370.05n

* CHECK dout0_0 Vdout0_0ck140 = 1.8 time = 1410
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=1410.05n

* CHECK dout0_1 Vdout0_1ck140 = 0 time = 1410
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=1410.05n

* CHECK dout0_2 Vdout0_2ck140 = 1.8 time = 1410
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=1410.05n

* CHECK dout0_3 Vdout0_3ck140 = 1.8 time = 1410
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=1410.05n

* CHECK dout0_4 Vdout0_4ck140 = 1.8 time = 1410
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=1410.05n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 1410
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=1410.05n

* CHECK dout0_6 Vdout0_6ck140 = 1.8 time = 1410
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=1410.05n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 1410
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=1410.05n

* CHECK dout0_8 Vdout0_8ck140 = 1.8 time = 1410
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=1410.05n

* CHECK dout0_9 Vdout0_9ck140 = 0 time = 1410
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=1410.05n

* CHECK dout0_10 Vdout0_10ck140 = 0 time = 1410
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=1410.05n

* CHECK dout0_11 Vdout0_11ck140 = 1.8 time = 1410
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=1410.05n

* CHECK dout0_12 Vdout0_12ck140 = 0 time = 1410
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=1410.05n

* CHECK dout0_13 Vdout0_13ck140 = 0 time = 1410
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=1410.05n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 1410
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=1410.05n

* CHECK dout0_15 Vdout0_15ck140 = 0 time = 1410
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=1410.05n

* CHECK dout0_16 Vdout0_16ck140 = 1.8 time = 1410
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=1410.05n

* CHECK dout0_17 Vdout0_17ck140 = 0 time = 1410
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=1410.05n

* CHECK dout0_18 Vdout0_18ck140 = 0 time = 1410
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=1410.05n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 1410
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=1410.05n

* CHECK dout0_20 Vdout0_20ck140 = 0 time = 1410
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=1410.05n

* CHECK dout0_21 Vdout0_21ck140 = 1.8 time = 1410
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=1410.05n

* CHECK dout0_22 Vdout0_22ck140 = 0 time = 1410
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=1410.05n

* CHECK dout0_23 Vdout0_23ck140 = 1.8 time = 1410
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=1410.05n

* CHECK dout0_24 Vdout0_24ck140 = 1.8 time = 1410
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=1410.05n

* CHECK dout0_25 Vdout0_25ck140 = 0 time = 1410
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=1410.05n

* CHECK dout0_26 Vdout0_26ck140 = 0 time = 1410
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=1410.05n

* CHECK dout0_27 Vdout0_27ck140 = 0 time = 1410
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=1410.05n

* CHECK dout0_28 Vdout0_28ck140 = 1.8 time = 1410
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=1410.05n

* CHECK dout0_29 Vdout0_29ck140 = 0 time = 1410
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=1410.05n

* CHECK dout0_30 Vdout0_30ck140 = 1.8 time = 1410
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=1410.05n

* CHECK dout0_31 Vdout0_31ck140 = 1.8 time = 1410
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=1410.05n

* CHECK dout0_32 Vdout0_32ck140 = 0 time = 1410
.meas tran vdout0_32ck140 FIND v(dout0_32) AT=1410.05n

* CHECK dout0_0 Vdout0_0ck142 = 1.8 time = 1430
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=1430.05n

* CHECK dout0_1 Vdout0_1ck142 = 1.8 time = 1430
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=1430.05n

* CHECK dout0_2 Vdout0_2ck142 = 1.8 time = 1430
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=1430.05n

* CHECK dout0_3 Vdout0_3ck142 = 0 time = 1430
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=1430.05n

* CHECK dout0_4 Vdout0_4ck142 = 0 time = 1430
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=1430.05n

* CHECK dout0_5 Vdout0_5ck142 = 0 time = 1430
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=1430.05n

* CHECK dout0_6 Vdout0_6ck142 = 1.8 time = 1430
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=1430.05n

* CHECK dout0_7 Vdout0_7ck142 = 0 time = 1430
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=1430.05n

* CHECK dout0_8 Vdout0_8ck142 = 1.8 time = 1430
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=1430.05n

* CHECK dout0_9 Vdout0_9ck142 = 1.8 time = 1430
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=1430.05n

* CHECK dout0_10 Vdout0_10ck142 = 1.8 time = 1430
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=1430.05n

* CHECK dout0_11 Vdout0_11ck142 = 1.8 time = 1430
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=1430.05n

* CHECK dout0_12 Vdout0_12ck142 = 1.8 time = 1430
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=1430.05n

* CHECK dout0_13 Vdout0_13ck142 = 1.8 time = 1430
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=1430.05n

* CHECK dout0_14 Vdout0_14ck142 = 1.8 time = 1430
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=1430.05n

* CHECK dout0_15 Vdout0_15ck142 = 0 time = 1430
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=1430.05n

* CHECK dout0_16 Vdout0_16ck142 = 1.8 time = 1430
.meas tran vdout0_16ck142 FIND v(dout0_16) AT=1430.05n

* CHECK dout0_17 Vdout0_17ck142 = 1.8 time = 1430
.meas tran vdout0_17ck142 FIND v(dout0_17) AT=1430.05n

* CHECK dout0_18 Vdout0_18ck142 = 1.8 time = 1430
.meas tran vdout0_18ck142 FIND v(dout0_18) AT=1430.05n

* CHECK dout0_19 Vdout0_19ck142 = 1.8 time = 1430
.meas tran vdout0_19ck142 FIND v(dout0_19) AT=1430.05n

* CHECK dout0_20 Vdout0_20ck142 = 1.8 time = 1430
.meas tran vdout0_20ck142 FIND v(dout0_20) AT=1430.05n

* CHECK dout0_21 Vdout0_21ck142 = 1.8 time = 1430
.meas tran vdout0_21ck142 FIND v(dout0_21) AT=1430.05n

* CHECK dout0_22 Vdout0_22ck142 = 0 time = 1430
.meas tran vdout0_22ck142 FIND v(dout0_22) AT=1430.05n

* CHECK dout0_23 Vdout0_23ck142 = 1.8 time = 1430
.meas tran vdout0_23ck142 FIND v(dout0_23) AT=1430.05n

* CHECK dout0_24 Vdout0_24ck142 = 1.8 time = 1430
.meas tran vdout0_24ck142 FIND v(dout0_24) AT=1430.05n

* CHECK dout0_25 Vdout0_25ck142 = 0 time = 1430
.meas tran vdout0_25ck142 FIND v(dout0_25) AT=1430.05n

* CHECK dout0_26 Vdout0_26ck142 = 1.8 time = 1430
.meas tran vdout0_26ck142 FIND v(dout0_26) AT=1430.05n

* CHECK dout0_27 Vdout0_27ck142 = 0 time = 1430
.meas tran vdout0_27ck142 FIND v(dout0_27) AT=1430.05n

* CHECK dout0_28 Vdout0_28ck142 = 0 time = 1430
.meas tran vdout0_28ck142 FIND v(dout0_28) AT=1430.05n

* CHECK dout0_29 Vdout0_29ck142 = 1.8 time = 1430
.meas tran vdout0_29ck142 FIND v(dout0_29) AT=1430.05n

* CHECK dout0_30 Vdout0_30ck142 = 1.8 time = 1430
.meas tran vdout0_30ck142 FIND v(dout0_30) AT=1430.05n

* CHECK dout0_31 Vdout0_31ck142 = 1.8 time = 1430
.meas tran vdout0_31ck142 FIND v(dout0_31) AT=1430.05n

* CHECK dout0_32 Vdout0_32ck142 = 0 time = 1430
.meas tran vdout0_32ck142 FIND v(dout0_32) AT=1430.05n

* CHECK dout0_0 Vdout0_0ck146 = 1.8 time = 1470
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=1470.05n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 1470
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=1470.05n

* CHECK dout0_2 Vdout0_2ck146 = 0 time = 1470
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=1470.05n

* CHECK dout0_3 Vdout0_3ck146 = 1.8 time = 1470
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=1470.05n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 1470
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=1470.05n

* CHECK dout0_5 Vdout0_5ck146 = 0 time = 1470
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=1470.05n

* CHECK dout0_6 Vdout0_6ck146 = 1.8 time = 1470
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=1470.05n

* CHECK dout0_7 Vdout0_7ck146 = 0 time = 1470
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=1470.05n

* CHECK dout0_8 Vdout0_8ck146 = 1.8 time = 1470
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=1470.05n

* CHECK dout0_9 Vdout0_9ck146 = 0 time = 1470
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=1470.05n

* CHECK dout0_10 Vdout0_10ck146 = 1.8 time = 1470
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=1470.05n

* CHECK dout0_11 Vdout0_11ck146 = 1.8 time = 1470
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=1470.05n

* CHECK dout0_12 Vdout0_12ck146 = 0 time = 1470
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=1470.05n

* CHECK dout0_13 Vdout0_13ck146 = 1.8 time = 1470
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=1470.05n

* CHECK dout0_14 Vdout0_14ck146 = 1.8 time = 1470
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=1470.05n

* CHECK dout0_15 Vdout0_15ck146 = 0 time = 1470
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=1470.05n

* CHECK dout0_16 Vdout0_16ck146 = 1.8 time = 1470
.meas tran vdout0_16ck146 FIND v(dout0_16) AT=1470.05n

* CHECK dout0_17 Vdout0_17ck146 = 1.8 time = 1470
.meas tran vdout0_17ck146 FIND v(dout0_17) AT=1470.05n

* CHECK dout0_18 Vdout0_18ck146 = 0 time = 1470
.meas tran vdout0_18ck146 FIND v(dout0_18) AT=1470.05n

* CHECK dout0_19 Vdout0_19ck146 = 1.8 time = 1470
.meas tran vdout0_19ck146 FIND v(dout0_19) AT=1470.05n

* CHECK dout0_20 Vdout0_20ck146 = 1.8 time = 1470
.meas tran vdout0_20ck146 FIND v(dout0_20) AT=1470.05n

* CHECK dout0_21 Vdout0_21ck146 = 0 time = 1470
.meas tran vdout0_21ck146 FIND v(dout0_21) AT=1470.05n

* CHECK dout0_22 Vdout0_22ck146 = 1.8 time = 1470
.meas tran vdout0_22ck146 FIND v(dout0_22) AT=1470.05n

* CHECK dout0_23 Vdout0_23ck146 = 0 time = 1470
.meas tran vdout0_23ck146 FIND v(dout0_23) AT=1470.05n

* CHECK dout0_24 Vdout0_24ck146 = 0 time = 1470
.meas tran vdout0_24ck146 FIND v(dout0_24) AT=1470.05n

* CHECK dout0_25 Vdout0_25ck146 = 1.8 time = 1470
.meas tran vdout0_25ck146 FIND v(dout0_25) AT=1470.05n

* CHECK dout0_26 Vdout0_26ck146 = 1.8 time = 1470
.meas tran vdout0_26ck146 FIND v(dout0_26) AT=1470.05n

* CHECK dout0_27 Vdout0_27ck146 = 1.8 time = 1470
.meas tran vdout0_27ck146 FIND v(dout0_27) AT=1470.05n

* CHECK dout0_28 Vdout0_28ck146 = 1.8 time = 1470
.meas tran vdout0_28ck146 FIND v(dout0_28) AT=1470.05n

* CHECK dout0_29 Vdout0_29ck146 = 0 time = 1470
.meas tran vdout0_29ck146 FIND v(dout0_29) AT=1470.05n

* CHECK dout0_30 Vdout0_30ck146 = 1.8 time = 1470
.meas tran vdout0_30ck146 FIND v(dout0_30) AT=1470.05n

* CHECK dout0_31 Vdout0_31ck146 = 0 time = 1470
.meas tran vdout0_31ck146 FIND v(dout0_31) AT=1470.05n

* CHECK dout0_32 Vdout0_32ck146 = 0 time = 1470
.meas tran vdout0_32ck146 FIND v(dout0_32) AT=1470.05n

* CHECK dout0_0 Vdout0_0ck149 = 0 time = 1500
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=1500.05n

* CHECK dout0_1 Vdout0_1ck149 = 1.8 time = 1500
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=1500.05n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 1500
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=1500.05n

* CHECK dout0_3 Vdout0_3ck149 = 1.8 time = 1500
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=1500.05n

* CHECK dout0_4 Vdout0_4ck149 = 0 time = 1500
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=1500.05n

* CHECK dout0_5 Vdout0_5ck149 = 1.8 time = 1500
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=1500.05n

* CHECK dout0_6 Vdout0_6ck149 = 1.8 time = 1500
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=1500.05n

* CHECK dout0_7 Vdout0_7ck149 = 1.8 time = 1500
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=1500.05n

* CHECK dout0_8 Vdout0_8ck149 = 0 time = 1500
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=1500.05n

* CHECK dout0_9 Vdout0_9ck149 = 0 time = 1500
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=1500.05n

* CHECK dout0_10 Vdout0_10ck149 = 1.8 time = 1500
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=1500.05n

* CHECK dout0_11 Vdout0_11ck149 = 1.8 time = 1500
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=1500.05n

* CHECK dout0_12 Vdout0_12ck149 = 1.8 time = 1500
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=1500.05n

* CHECK dout0_13 Vdout0_13ck149 = 0 time = 1500
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=1500.05n

* CHECK dout0_14 Vdout0_14ck149 = 1.8 time = 1500
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=1500.05n

* CHECK dout0_15 Vdout0_15ck149 = 0 time = 1500
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=1500.05n

* CHECK dout0_16 Vdout0_16ck149 = 1.8 time = 1500
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=1500.05n

* CHECK dout0_17 Vdout0_17ck149 = 1.8 time = 1500
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=1500.05n

* CHECK dout0_18 Vdout0_18ck149 = 0 time = 1500
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=1500.05n

* CHECK dout0_19 Vdout0_19ck149 = 0 time = 1500
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=1500.05n

* CHECK dout0_20 Vdout0_20ck149 = 1.8 time = 1500
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=1500.05n

* CHECK dout0_21 Vdout0_21ck149 = 1.8 time = 1500
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=1500.05n

* CHECK dout0_22 Vdout0_22ck149 = 0 time = 1500
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=1500.05n

* CHECK dout0_23 Vdout0_23ck149 = 1.8 time = 1500
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=1500.05n

* CHECK dout0_24 Vdout0_24ck149 = 1.8 time = 1500
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=1500.05n

* CHECK dout0_25 Vdout0_25ck149 = 0 time = 1500
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=1500.05n

* CHECK dout0_26 Vdout0_26ck149 = 0 time = 1500
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=1500.05n

* CHECK dout0_27 Vdout0_27ck149 = 0 time = 1500
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=1500.05n

* CHECK dout0_28 Vdout0_28ck149 = 1.8 time = 1500
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=1500.05n

* CHECK dout0_29 Vdout0_29ck149 = 0 time = 1500
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=1500.05n

* CHECK dout0_30 Vdout0_30ck149 = 1.8 time = 1500
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=1500.05n

* CHECK dout0_31 Vdout0_31ck149 = 0 time = 1500
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=1500.05n

* CHECK dout0_32 Vdout0_32ck149 = 0 time = 1500
.meas tran vdout0_32ck149 FIND v(dout0_32) AT=1500.05n

* CHECK dout0_0 Vdout0_0ck153 = 1.8 time = 1540
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=1540.05n

* CHECK dout0_1 Vdout0_1ck153 = 1.8 time = 1540
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=1540.05n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 1540
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=1540.05n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 1540
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=1540.05n

* CHECK dout0_4 Vdout0_4ck153 = 1.8 time = 1540
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=1540.05n

* CHECK dout0_5 Vdout0_5ck153 = 1.8 time = 1540
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=1540.05n

* CHECK dout0_6 Vdout0_6ck153 = 1.8 time = 1540
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=1540.05n

* CHECK dout0_7 Vdout0_7ck153 = 0 time = 1540
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=1540.05n

* CHECK dout0_8 Vdout0_8ck153 = 0 time = 1540
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=1540.05n

* CHECK dout0_9 Vdout0_9ck153 = 1.8 time = 1540
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=1540.05n

* CHECK dout0_10 Vdout0_10ck153 = 1.8 time = 1540
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=1540.05n

* CHECK dout0_11 Vdout0_11ck153 = 1.8 time = 1540
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=1540.05n

* CHECK dout0_12 Vdout0_12ck153 = 1.8 time = 1540
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=1540.05n

* CHECK dout0_13 Vdout0_13ck153 = 1.8 time = 1540
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=1540.05n

* CHECK dout0_14 Vdout0_14ck153 = 1.8 time = 1540
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=1540.05n

* CHECK dout0_15 Vdout0_15ck153 = 1.8 time = 1540
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=1540.05n

* CHECK dout0_16 Vdout0_16ck153 = 1.8 time = 1540
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=1540.05n

* CHECK dout0_17 Vdout0_17ck153 = 0 time = 1540
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=1540.05n

* CHECK dout0_18 Vdout0_18ck153 = 0 time = 1540
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=1540.05n

* CHECK dout0_19 Vdout0_19ck153 = 0 time = 1540
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=1540.05n

* CHECK dout0_20 Vdout0_20ck153 = 1.8 time = 1540
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=1540.05n

* CHECK dout0_21 Vdout0_21ck153 = 0 time = 1540
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=1540.05n

* CHECK dout0_22 Vdout0_22ck153 = 0 time = 1540
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=1540.05n

* CHECK dout0_23 Vdout0_23ck153 = 0 time = 1540
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=1540.05n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 1540
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=1540.05n

* CHECK dout0_25 Vdout0_25ck153 = 0 time = 1540
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=1540.05n

* CHECK dout0_26 Vdout0_26ck153 = 1.8 time = 1540
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=1540.05n

* CHECK dout0_27 Vdout0_27ck153 = 1.8 time = 1540
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=1540.05n

* CHECK dout0_28 Vdout0_28ck153 = 1.8 time = 1540
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=1540.05n

* CHECK dout0_29 Vdout0_29ck153 = 0 time = 1540
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=1540.05n

* CHECK dout0_30 Vdout0_30ck153 = 0 time = 1540
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=1540.05n

* CHECK dout0_31 Vdout0_31ck153 = 1.8 time = 1540
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=1540.05n

* CHECK dout0_32 Vdout0_32ck153 = 0 time = 1540
.meas tran vdout0_32ck153 FIND v(dout0_32) AT=1540.05n

* CHECK dout0_0 Vdout0_0ck155 = 0 time = 1560
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=1560.05n

* CHECK dout0_1 Vdout0_1ck155 = 1.8 time = 1560
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=1560.05n

* CHECK dout0_2 Vdout0_2ck155 = 0 time = 1560
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=1560.05n

* CHECK dout0_3 Vdout0_3ck155 = 1.8 time = 1560
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=1560.05n

* CHECK dout0_4 Vdout0_4ck155 = 0 time = 1560
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=1560.05n

* CHECK dout0_5 Vdout0_5ck155 = 1.8 time = 1560
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=1560.05n

* CHECK dout0_6 Vdout0_6ck155 = 1.8 time = 1560
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=1560.05n

* CHECK dout0_7 Vdout0_7ck155 = 1.8 time = 1560
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=1560.05n

* CHECK dout0_8 Vdout0_8ck155 = 0 time = 1560
.meas tran vdout0_8ck155 FIND v(dout0_8) AT=1560.05n

* CHECK dout0_9 Vdout0_9ck155 = 0 time = 1560
.meas tran vdout0_9ck155 FIND v(dout0_9) AT=1560.05n

* CHECK dout0_10 Vdout0_10ck155 = 1.8 time = 1560
.meas tran vdout0_10ck155 FIND v(dout0_10) AT=1560.05n

* CHECK dout0_11 Vdout0_11ck155 = 1.8 time = 1560
.meas tran vdout0_11ck155 FIND v(dout0_11) AT=1560.05n

* CHECK dout0_12 Vdout0_12ck155 = 1.8 time = 1560
.meas tran vdout0_12ck155 FIND v(dout0_12) AT=1560.05n

* CHECK dout0_13 Vdout0_13ck155 = 0 time = 1560
.meas tran vdout0_13ck155 FIND v(dout0_13) AT=1560.05n

* CHECK dout0_14 Vdout0_14ck155 = 1.8 time = 1560
.meas tran vdout0_14ck155 FIND v(dout0_14) AT=1560.05n

* CHECK dout0_15 Vdout0_15ck155 = 0 time = 1560
.meas tran vdout0_15ck155 FIND v(dout0_15) AT=1560.05n

* CHECK dout0_16 Vdout0_16ck155 = 1.8 time = 1560
.meas tran vdout0_16ck155 FIND v(dout0_16) AT=1560.05n

* CHECK dout0_17 Vdout0_17ck155 = 1.8 time = 1560
.meas tran vdout0_17ck155 FIND v(dout0_17) AT=1560.05n

* CHECK dout0_18 Vdout0_18ck155 = 0 time = 1560
.meas tran vdout0_18ck155 FIND v(dout0_18) AT=1560.05n

* CHECK dout0_19 Vdout0_19ck155 = 0 time = 1560
.meas tran vdout0_19ck155 FIND v(dout0_19) AT=1560.05n

* CHECK dout0_20 Vdout0_20ck155 = 1.8 time = 1560
.meas tran vdout0_20ck155 FIND v(dout0_20) AT=1560.05n

* CHECK dout0_21 Vdout0_21ck155 = 1.8 time = 1560
.meas tran vdout0_21ck155 FIND v(dout0_21) AT=1560.05n

* CHECK dout0_22 Vdout0_22ck155 = 0 time = 1560
.meas tran vdout0_22ck155 FIND v(dout0_22) AT=1560.05n

* CHECK dout0_23 Vdout0_23ck155 = 1.8 time = 1560
.meas tran vdout0_23ck155 FIND v(dout0_23) AT=1560.05n

* CHECK dout0_24 Vdout0_24ck155 = 1.8 time = 1560
.meas tran vdout0_24ck155 FIND v(dout0_24) AT=1560.05n

* CHECK dout0_25 Vdout0_25ck155 = 0 time = 1560
.meas tran vdout0_25ck155 FIND v(dout0_25) AT=1560.05n

* CHECK dout0_26 Vdout0_26ck155 = 0 time = 1560
.meas tran vdout0_26ck155 FIND v(dout0_26) AT=1560.05n

* CHECK dout0_27 Vdout0_27ck155 = 0 time = 1560
.meas tran vdout0_27ck155 FIND v(dout0_27) AT=1560.05n

* CHECK dout0_28 Vdout0_28ck155 = 1.8 time = 1560
.meas tran vdout0_28ck155 FIND v(dout0_28) AT=1560.05n

* CHECK dout0_29 Vdout0_29ck155 = 0 time = 1560
.meas tran vdout0_29ck155 FIND v(dout0_29) AT=1560.05n

* CHECK dout0_30 Vdout0_30ck155 = 1.8 time = 1560
.meas tran vdout0_30ck155 FIND v(dout0_30) AT=1560.05n

* CHECK dout0_31 Vdout0_31ck155 = 0 time = 1560
.meas tran vdout0_31ck155 FIND v(dout0_31) AT=1560.05n

* CHECK dout0_32 Vdout0_32ck155 = 0 time = 1560
.meas tran vdout0_32ck155 FIND v(dout0_32) AT=1560.05n

* CHECK dout0_0 Vdout0_0ck158 = 1.8 time = 1590
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=1590.05n

* CHECK dout0_1 Vdout0_1ck158 = 1.8 time = 1590
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=1590.05n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 1590
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=1590.05n

* CHECK dout0_3 Vdout0_3ck158 = 0 time = 1590
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=1590.05n

* CHECK dout0_4 Vdout0_4ck158 = 1.8 time = 1590
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=1590.05n

* CHECK dout0_5 Vdout0_5ck158 = 1.8 time = 1590
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=1590.05n

* CHECK dout0_6 Vdout0_6ck158 = 1.8 time = 1590
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=1590.05n

* CHECK dout0_7 Vdout0_7ck158 = 0 time = 1590
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=1590.05n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 1590
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=1590.05n

* CHECK dout0_9 Vdout0_9ck158 = 1.8 time = 1590
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=1590.05n

* CHECK dout0_10 Vdout0_10ck158 = 1.8 time = 1590
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=1590.05n

* CHECK dout0_11 Vdout0_11ck158 = 1.8 time = 1590
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=1590.05n

* CHECK dout0_12 Vdout0_12ck158 = 1.8 time = 1590
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=1590.05n

* CHECK dout0_13 Vdout0_13ck158 = 1.8 time = 1590
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=1590.05n

* CHECK dout0_14 Vdout0_14ck158 = 1.8 time = 1590
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=1590.05n

* CHECK dout0_15 Vdout0_15ck158 = 1.8 time = 1590
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=1590.05n

* CHECK dout0_16 Vdout0_16ck158 = 1.8 time = 1590
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=1590.05n

* CHECK dout0_17 Vdout0_17ck158 = 0 time = 1590
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=1590.05n

* CHECK dout0_18 Vdout0_18ck158 = 0 time = 1590
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=1590.05n

* CHECK dout0_19 Vdout0_19ck158 = 0 time = 1590
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=1590.05n

* CHECK dout0_20 Vdout0_20ck158 = 1.8 time = 1590
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=1590.05n

* CHECK dout0_21 Vdout0_21ck158 = 0 time = 1590
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=1590.05n

* CHECK dout0_22 Vdout0_22ck158 = 0 time = 1590
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=1590.05n

* CHECK dout0_23 Vdout0_23ck158 = 0 time = 1590
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=1590.05n

* CHECK dout0_24 Vdout0_24ck158 = 0 time = 1590
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=1590.05n

* CHECK dout0_25 Vdout0_25ck158 = 0 time = 1590
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=1590.05n

* CHECK dout0_26 Vdout0_26ck158 = 1.8 time = 1590
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=1590.05n

* CHECK dout0_27 Vdout0_27ck158 = 1.8 time = 1590
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=1590.05n

* CHECK dout0_28 Vdout0_28ck158 = 1.8 time = 1590
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=1590.05n

* CHECK dout0_29 Vdout0_29ck158 = 0 time = 1590
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=1590.05n

* CHECK dout0_30 Vdout0_30ck158 = 0 time = 1590
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=1590.05n

* CHECK dout0_31 Vdout0_31ck158 = 1.8 time = 1590
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=1590.05n

* CHECK dout0_32 Vdout0_32ck158 = 0 time = 1590
.meas tran vdout0_32ck158 FIND v(dout0_32) AT=1590.05n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 1610
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=1610.05n

* CHECK dout0_1 Vdout0_1ck160 = 0 time = 1610
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=1610.05n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 1610
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=1610.05n

* CHECK dout0_3 Vdout0_3ck160 = 1.8 time = 1610
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=1610.05n

* CHECK dout0_4 Vdout0_4ck160 = 1.8 time = 1610
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=1610.05n

* CHECK dout0_5 Vdout0_5ck160 = 1.8 time = 1610
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=1610.05n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 1610
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=1610.05n

* CHECK dout0_7 Vdout0_7ck160 = 1.8 time = 1610
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=1610.05n

* CHECK dout0_8 Vdout0_8ck160 = 1.8 time = 1610
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=1610.05n

* CHECK dout0_9 Vdout0_9ck160 = 0 time = 1610
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=1610.05n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 1610
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=1610.05n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 1610
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=1610.05n

* CHECK dout0_12 Vdout0_12ck160 = 1.8 time = 1610
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=1610.05n

* CHECK dout0_13 Vdout0_13ck160 = 1.8 time = 1610
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=1610.05n

* CHECK dout0_14 Vdout0_14ck160 = 1.8 time = 1610
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=1610.05n

* CHECK dout0_15 Vdout0_15ck160 = 1.8 time = 1610
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=1610.05n

* CHECK dout0_16 Vdout0_16ck160 = 1.8 time = 1610
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=1610.05n

* CHECK dout0_17 Vdout0_17ck160 = 0 time = 1610
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=1610.05n

* CHECK dout0_18 Vdout0_18ck160 = 1.8 time = 1610
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=1610.05n

* CHECK dout0_19 Vdout0_19ck160 = 1.8 time = 1610
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=1610.05n

* CHECK dout0_20 Vdout0_20ck160 = 1.8 time = 1610
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=1610.05n

* CHECK dout0_21 Vdout0_21ck160 = 1.8 time = 1610
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=1610.05n

* CHECK dout0_22 Vdout0_22ck160 = 1.8 time = 1610
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=1610.05n

* CHECK dout0_23 Vdout0_23ck160 = 0 time = 1610
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=1610.05n

* CHECK dout0_24 Vdout0_24ck160 = 1.8 time = 1610
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=1610.05n

* CHECK dout0_25 Vdout0_25ck160 = 1.8 time = 1610
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=1610.05n

* CHECK dout0_26 Vdout0_26ck160 = 1.8 time = 1610
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=1610.05n

* CHECK dout0_27 Vdout0_27ck160 = 0 time = 1610
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=1610.05n

* CHECK dout0_28 Vdout0_28ck160 = 0 time = 1610
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=1610.05n

* CHECK dout0_29 Vdout0_29ck160 = 0 time = 1610
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=1610.05n

* CHECK dout0_30 Vdout0_30ck160 = 1.8 time = 1610
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=1610.05n

* CHECK dout0_31 Vdout0_31ck160 = 1.8 time = 1610
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=1610.05n

* CHECK dout0_32 Vdout0_32ck160 = 0 time = 1610
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=1610.05n

* CHECK dout0_0 Vdout0_0ck161 = 1.8 time = 1620
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=1620.05n

* CHECK dout0_1 Vdout0_1ck161 = 0 time = 1620
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=1620.05n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 1620
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=1620.05n

* CHECK dout0_3 Vdout0_3ck161 = 1.8 time = 1620
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=1620.05n

* CHECK dout0_4 Vdout0_4ck161 = 0 time = 1620
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=1620.05n

* CHECK dout0_5 Vdout0_5ck161 = 0 time = 1620
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=1620.05n

* CHECK dout0_6 Vdout0_6ck161 = 0 time = 1620
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=1620.05n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 1620
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=1620.05n

* CHECK dout0_8 Vdout0_8ck161 = 1.8 time = 1620
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=1620.05n

* CHECK dout0_9 Vdout0_9ck161 = 0 time = 1620
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=1620.05n

* CHECK dout0_10 Vdout0_10ck161 = 1.8 time = 1620
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=1620.05n

* CHECK dout0_11 Vdout0_11ck161 = 1.8 time = 1620
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=1620.05n

* CHECK dout0_12 Vdout0_12ck161 = 1.8 time = 1620
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=1620.05n

* CHECK dout0_13 Vdout0_13ck161 = 0 time = 1620
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=1620.05n

* CHECK dout0_14 Vdout0_14ck161 = 1.8 time = 1620
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=1620.05n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 1620
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=1620.05n

* CHECK dout0_16 Vdout0_16ck161 = 1.8 time = 1620
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=1620.05n

* CHECK dout0_17 Vdout0_17ck161 = 0 time = 1620
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=1620.05n

* CHECK dout0_18 Vdout0_18ck161 = 1.8 time = 1620
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=1620.05n

* CHECK dout0_19 Vdout0_19ck161 = 0 time = 1620
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=1620.05n

* CHECK dout0_20 Vdout0_20ck161 = 1.8 time = 1620
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=1620.05n

* CHECK dout0_21 Vdout0_21ck161 = 1.8 time = 1620
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=1620.05n

* CHECK dout0_22 Vdout0_22ck161 = 0 time = 1620
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=1620.05n

* CHECK dout0_23 Vdout0_23ck161 = 1.8 time = 1620
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=1620.05n

* CHECK dout0_24 Vdout0_24ck161 = 0 time = 1620
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=1620.05n

* CHECK dout0_25 Vdout0_25ck161 = 0 time = 1620
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=1620.05n

* CHECK dout0_26 Vdout0_26ck161 = 0 time = 1620
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=1620.05n

* CHECK dout0_27 Vdout0_27ck161 = 1.8 time = 1620
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=1620.05n

* CHECK dout0_28 Vdout0_28ck161 = 1.8 time = 1620
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=1620.05n

* CHECK dout0_29 Vdout0_29ck161 = 0 time = 1620
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=1620.05n

* CHECK dout0_30 Vdout0_30ck161 = 1.8 time = 1620
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=1620.05n

* CHECK dout0_31 Vdout0_31ck161 = 1.8 time = 1620
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=1620.05n

* CHECK dout0_32 Vdout0_32ck161 = 0 time = 1620
.meas tran vdout0_32ck161 FIND v(dout0_32) AT=1620.05n

* CHECK dout0_0 Vdout0_0ck164 = 1.8 time = 1650
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=1650.05n

* CHECK dout0_1 Vdout0_1ck164 = 0 time = 1650
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=1650.05n

* CHECK dout0_2 Vdout0_2ck164 = 0 time = 1650
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=1650.05n

* CHECK dout0_3 Vdout0_3ck164 = 1.8 time = 1650
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=1650.05n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 1650
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=1650.05n

* CHECK dout0_5 Vdout0_5ck164 = 0 time = 1650
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=1650.05n

* CHECK dout0_6 Vdout0_6ck164 = 0 time = 1650
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=1650.05n

* CHECK dout0_7 Vdout0_7ck164 = 0 time = 1650
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=1650.05n

* CHECK dout0_8 Vdout0_8ck164 = 1.8 time = 1650
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=1650.05n

* CHECK dout0_9 Vdout0_9ck164 = 0 time = 1650
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=1650.05n

* CHECK dout0_10 Vdout0_10ck164 = 1.8 time = 1650
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=1650.05n

* CHECK dout0_11 Vdout0_11ck164 = 1.8 time = 1650
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=1650.05n

* CHECK dout0_12 Vdout0_12ck164 = 1.8 time = 1650
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=1650.05n

* CHECK dout0_13 Vdout0_13ck164 = 0 time = 1650
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=1650.05n

* CHECK dout0_14 Vdout0_14ck164 = 1.8 time = 1650
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=1650.05n

* CHECK dout0_15 Vdout0_15ck164 = 0 time = 1650
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=1650.05n

* CHECK dout0_16 Vdout0_16ck164 = 1.8 time = 1650
.meas tran vdout0_16ck164 FIND v(dout0_16) AT=1650.05n

* CHECK dout0_17 Vdout0_17ck164 = 0 time = 1650
.meas tran vdout0_17ck164 FIND v(dout0_17) AT=1650.05n

* CHECK dout0_18 Vdout0_18ck164 = 1.8 time = 1650
.meas tran vdout0_18ck164 FIND v(dout0_18) AT=1650.05n

* CHECK dout0_19 Vdout0_19ck164 = 0 time = 1650
.meas tran vdout0_19ck164 FIND v(dout0_19) AT=1650.05n

* CHECK dout0_20 Vdout0_20ck164 = 1.8 time = 1650
.meas tran vdout0_20ck164 FIND v(dout0_20) AT=1650.05n

* CHECK dout0_21 Vdout0_21ck164 = 1.8 time = 1650
.meas tran vdout0_21ck164 FIND v(dout0_21) AT=1650.05n

* CHECK dout0_22 Vdout0_22ck164 = 0 time = 1650
.meas tran vdout0_22ck164 FIND v(dout0_22) AT=1650.05n

* CHECK dout0_23 Vdout0_23ck164 = 1.8 time = 1650
.meas tran vdout0_23ck164 FIND v(dout0_23) AT=1650.05n

* CHECK dout0_24 Vdout0_24ck164 = 0 time = 1650
.meas tran vdout0_24ck164 FIND v(dout0_24) AT=1650.05n

* CHECK dout0_25 Vdout0_25ck164 = 0 time = 1650
.meas tran vdout0_25ck164 FIND v(dout0_25) AT=1650.05n

* CHECK dout0_26 Vdout0_26ck164 = 0 time = 1650
.meas tran vdout0_26ck164 FIND v(dout0_26) AT=1650.05n

* CHECK dout0_27 Vdout0_27ck164 = 1.8 time = 1650
.meas tran vdout0_27ck164 FIND v(dout0_27) AT=1650.05n

* CHECK dout0_28 Vdout0_28ck164 = 1.8 time = 1650
.meas tran vdout0_28ck164 FIND v(dout0_28) AT=1650.05n

* CHECK dout0_29 Vdout0_29ck164 = 0 time = 1650
.meas tran vdout0_29ck164 FIND v(dout0_29) AT=1650.05n

* CHECK dout0_30 Vdout0_30ck164 = 1.8 time = 1650
.meas tran vdout0_30ck164 FIND v(dout0_30) AT=1650.05n

* CHECK dout0_31 Vdout0_31ck164 = 1.8 time = 1650
.meas tran vdout0_31ck164 FIND v(dout0_31) AT=1650.05n

* CHECK dout0_32 Vdout0_32ck164 = 0 time = 1650
.meas tran vdout0_32ck164 FIND v(dout0_32) AT=1650.05n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 1660
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=1660.05n

* CHECK dout0_1 Vdout0_1ck165 = 1.8 time = 1660
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=1660.05n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 1660
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=1660.05n

* CHECK dout0_3 Vdout0_3ck165 = 1.8 time = 1660
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=1660.05n

* CHECK dout0_4 Vdout0_4ck165 = 0 time = 1660
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=1660.05n

* CHECK dout0_5 Vdout0_5ck165 = 1.8 time = 1660
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=1660.05n

* CHECK dout0_6 Vdout0_6ck165 = 1.8 time = 1660
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=1660.05n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 1660
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=1660.05n

* CHECK dout0_8 Vdout0_8ck165 = 0 time = 1660
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=1660.05n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 1660
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=1660.05n

* CHECK dout0_10 Vdout0_10ck165 = 1.8 time = 1660
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=1660.05n

* CHECK dout0_11 Vdout0_11ck165 = 1.8 time = 1660
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=1660.05n

* CHECK dout0_12 Vdout0_12ck165 = 1.8 time = 1660
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=1660.05n

* CHECK dout0_13 Vdout0_13ck165 = 0 time = 1660
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=1660.05n

* CHECK dout0_14 Vdout0_14ck165 = 1.8 time = 1660
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=1660.05n

* CHECK dout0_15 Vdout0_15ck165 = 0 time = 1660
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=1660.05n

* CHECK dout0_16 Vdout0_16ck165 = 1.8 time = 1660
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=1660.05n

* CHECK dout0_17 Vdout0_17ck165 = 1.8 time = 1660
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=1660.05n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 1660
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=1660.05n

* CHECK dout0_19 Vdout0_19ck165 = 0 time = 1660
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=1660.05n

* CHECK dout0_20 Vdout0_20ck165 = 1.8 time = 1660
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=1660.05n

* CHECK dout0_21 Vdout0_21ck165 = 1.8 time = 1660
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=1660.05n

* CHECK dout0_22 Vdout0_22ck165 = 0 time = 1660
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=1660.05n

* CHECK dout0_23 Vdout0_23ck165 = 1.8 time = 1660
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=1660.05n

* CHECK dout0_24 Vdout0_24ck165 = 1.8 time = 1660
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=1660.05n

* CHECK dout0_25 Vdout0_25ck165 = 0 time = 1660
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=1660.05n

* CHECK dout0_26 Vdout0_26ck165 = 0 time = 1660
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=1660.05n

* CHECK dout0_27 Vdout0_27ck165 = 0 time = 1660
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=1660.05n

* CHECK dout0_28 Vdout0_28ck165 = 1.8 time = 1660
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=1660.05n

* CHECK dout0_29 Vdout0_29ck165 = 0 time = 1660
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=1660.05n

* CHECK dout0_30 Vdout0_30ck165 = 1.8 time = 1660
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=1660.05n

* CHECK dout0_31 Vdout0_31ck165 = 0 time = 1660
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=1660.05n

* CHECK dout0_32 Vdout0_32ck165 = 0 time = 1660
.meas tran vdout0_32ck165 FIND v(dout0_32) AT=1660.05n

* CHECK dout0_0 Vdout0_0ck168 = 1.8 time = 1690
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=1690.05n

* CHECK dout0_1 Vdout0_1ck168 = 1.8 time = 1690
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=1690.05n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 1690
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=1690.05n

* CHECK dout0_3 Vdout0_3ck168 = 1.8 time = 1690
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=1690.05n

* CHECK dout0_4 Vdout0_4ck168 = 1.8 time = 1690
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=1690.05n

* CHECK dout0_5 Vdout0_5ck168 = 0 time = 1690
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=1690.05n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 1690
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=1690.05n

* CHECK dout0_7 Vdout0_7ck168 = 1.8 time = 1690
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=1690.05n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 1690
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=1690.05n

* CHECK dout0_9 Vdout0_9ck168 = 1.8 time = 1690
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=1690.05n

* CHECK dout0_10 Vdout0_10ck168 = 1.8 time = 1690
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=1690.05n

* CHECK dout0_11 Vdout0_11ck168 = 0 time = 1690
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=1690.05n

* CHECK dout0_12 Vdout0_12ck168 = 1.8 time = 1690
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=1690.05n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 1690
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=1690.05n

* CHECK dout0_14 Vdout0_14ck168 = 1.8 time = 1690
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=1690.05n

* CHECK dout0_15 Vdout0_15ck168 = 1.8 time = 1690
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=1690.05n

* CHECK dout0_16 Vdout0_16ck168 = 1.8 time = 1690
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=1690.05n

* CHECK dout0_17 Vdout0_17ck168 = 1.8 time = 1690
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=1690.05n

* CHECK dout0_18 Vdout0_18ck168 = 0 time = 1690
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=1690.05n

* CHECK dout0_19 Vdout0_19ck168 = 1.8 time = 1690
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=1690.05n

* CHECK dout0_20 Vdout0_20ck168 = 0 time = 1690
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=1690.05n

* CHECK dout0_21 Vdout0_21ck168 = 0 time = 1690
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=1690.05n

* CHECK dout0_22 Vdout0_22ck168 = 0 time = 1690
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=1690.05n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 1690
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=1690.05n

* CHECK dout0_24 Vdout0_24ck168 = 1.8 time = 1690
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=1690.05n

* CHECK dout0_25 Vdout0_25ck168 = 1.8 time = 1690
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=1690.05n

* CHECK dout0_26 Vdout0_26ck168 = 0 time = 1690
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=1690.05n

* CHECK dout0_27 Vdout0_27ck168 = 0 time = 1690
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=1690.05n

* CHECK dout0_28 Vdout0_28ck168 = 1.8 time = 1690
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=1690.05n

* CHECK dout0_29 Vdout0_29ck168 = 1.8 time = 1690
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=1690.05n

* CHECK dout0_30 Vdout0_30ck168 = 1.8 time = 1690
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=1690.05n

* CHECK dout0_31 Vdout0_31ck168 = 1.8 time = 1690
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=1690.05n

* CHECK dout0_32 Vdout0_32ck168 = 0 time = 1690
.meas tran vdout0_32ck168 FIND v(dout0_32) AT=1690.05n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 1700
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=1700.05n

* CHECK dout0_1 Vdout0_1ck169 = 0 time = 1700
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=1700.05n

* CHECK dout0_2 Vdout0_2ck169 = 0 time = 1700
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=1700.05n

* CHECK dout0_3 Vdout0_3ck169 = 1.8 time = 1700
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=1700.05n

* CHECK dout0_4 Vdout0_4ck169 = 1.8 time = 1700
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=1700.05n

* CHECK dout0_5 Vdout0_5ck169 = 1.8 time = 1700
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=1700.05n

* CHECK dout0_6 Vdout0_6ck169 = 1.8 time = 1700
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=1700.05n

* CHECK dout0_7 Vdout0_7ck169 = 1.8 time = 1700
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=1700.05n

* CHECK dout0_8 Vdout0_8ck169 = 1.8 time = 1700
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=1700.05n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 1700
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=1700.05n

* CHECK dout0_10 Vdout0_10ck169 = 0 time = 1700
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=1700.05n

* CHECK dout0_11 Vdout0_11ck169 = 1.8 time = 1700
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=1700.05n

* CHECK dout0_12 Vdout0_12ck169 = 1.8 time = 1700
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=1700.05n

* CHECK dout0_13 Vdout0_13ck169 = 1.8 time = 1700
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=1700.05n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 1700
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=1700.05n

* CHECK dout0_15 Vdout0_15ck169 = 1.8 time = 1700
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=1700.05n

* CHECK dout0_16 Vdout0_16ck169 = 1.8 time = 1700
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=1700.05n

* CHECK dout0_17 Vdout0_17ck169 = 1.8 time = 1700
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=1700.05n

* CHECK dout0_18 Vdout0_18ck169 = 0 time = 1700
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=1700.05n

* CHECK dout0_19 Vdout0_19ck169 = 1.8 time = 1700
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=1700.05n

* CHECK dout0_20 Vdout0_20ck169 = 1.8 time = 1700
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=1700.05n

* CHECK dout0_21 Vdout0_21ck169 = 0 time = 1700
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=1700.05n

* CHECK dout0_22 Vdout0_22ck169 = 0 time = 1700
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=1700.05n

* CHECK dout0_23 Vdout0_23ck169 = 1.8 time = 1700
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=1700.05n

* CHECK dout0_24 Vdout0_24ck169 = 0 time = 1700
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=1700.05n

* CHECK dout0_25 Vdout0_25ck169 = 1.8 time = 1700
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=1700.05n

* CHECK dout0_26 Vdout0_26ck169 = 0 time = 1700
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=1700.05n

* CHECK dout0_27 Vdout0_27ck169 = 0 time = 1700
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=1700.05n

* CHECK dout0_28 Vdout0_28ck169 = 0 time = 1700
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=1700.05n

* CHECK dout0_29 Vdout0_29ck169 = 1.8 time = 1700
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=1700.05n

* CHECK dout0_30 Vdout0_30ck169 = 1.8 time = 1700
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=1700.05n

* CHECK dout0_31 Vdout0_31ck169 = 1.8 time = 1700
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=1700.05n

* CHECK dout0_32 Vdout0_32ck169 = 0 time = 1700
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=1700.05n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 1730
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=1730.05n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 1730
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=1730.05n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 1730
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=1730.05n

* CHECK dout0_3 Vdout0_3ck172 = 1.8 time = 1730
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=1730.05n

* CHECK dout0_4 Vdout0_4ck172 = 1.8 time = 1730
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=1730.05n

* CHECK dout0_5 Vdout0_5ck172 = 1.8 time = 1730
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=1730.05n

* CHECK dout0_6 Vdout0_6ck172 = 0 time = 1730
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=1730.05n

* CHECK dout0_7 Vdout0_7ck172 = 1.8 time = 1730
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=1730.05n

* CHECK dout0_8 Vdout0_8ck172 = 1.8 time = 1730
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=1730.05n

* CHECK dout0_9 Vdout0_9ck172 = 0 time = 1730
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=1730.05n

* CHECK dout0_10 Vdout0_10ck172 = 1.8 time = 1730
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=1730.05n

* CHECK dout0_11 Vdout0_11ck172 = 0 time = 1730
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=1730.05n

* CHECK dout0_12 Vdout0_12ck172 = 1.8 time = 1730
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=1730.05n

* CHECK dout0_13 Vdout0_13ck172 = 1.8 time = 1730
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=1730.05n

* CHECK dout0_14 Vdout0_14ck172 = 1.8 time = 1730
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=1730.05n

* CHECK dout0_15 Vdout0_15ck172 = 1.8 time = 1730
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=1730.05n

* CHECK dout0_16 Vdout0_16ck172 = 1.8 time = 1730
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=1730.05n

* CHECK dout0_17 Vdout0_17ck172 = 0 time = 1730
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=1730.05n

* CHECK dout0_18 Vdout0_18ck172 = 1.8 time = 1730
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=1730.05n

* CHECK dout0_19 Vdout0_19ck172 = 1.8 time = 1730
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=1730.05n

* CHECK dout0_20 Vdout0_20ck172 = 1.8 time = 1730
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=1730.05n

* CHECK dout0_21 Vdout0_21ck172 = 1.8 time = 1730
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=1730.05n

* CHECK dout0_22 Vdout0_22ck172 = 1.8 time = 1730
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=1730.05n

* CHECK dout0_23 Vdout0_23ck172 = 0 time = 1730
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=1730.05n

* CHECK dout0_24 Vdout0_24ck172 = 1.8 time = 1730
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=1730.05n

* CHECK dout0_25 Vdout0_25ck172 = 1.8 time = 1730
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=1730.05n

* CHECK dout0_26 Vdout0_26ck172 = 1.8 time = 1730
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=1730.05n

* CHECK dout0_27 Vdout0_27ck172 = 0 time = 1730
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=1730.05n

* CHECK dout0_28 Vdout0_28ck172 = 0 time = 1730
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=1730.05n

* CHECK dout0_29 Vdout0_29ck172 = 0 time = 1730
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=1730.05n

* CHECK dout0_30 Vdout0_30ck172 = 1.8 time = 1730
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=1730.05n

* CHECK dout0_31 Vdout0_31ck172 = 1.8 time = 1730
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=1730.05n

* CHECK dout0_32 Vdout0_32ck172 = 0 time = 1730
.meas tran vdout0_32ck172 FIND v(dout0_32) AT=1730.05n

* CHECK dout0_0 Vdout0_0ck173 = 1.8 time = 1740
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=1740.05n

* CHECK dout0_1 Vdout0_1ck173 = 0 time = 1740
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=1740.05n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 1740
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=1740.05n

* CHECK dout0_3 Vdout0_3ck173 = 1.8 time = 1740
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=1740.05n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 1740
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=1740.05n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 1740
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=1740.05n

* CHECK dout0_6 Vdout0_6ck173 = 1.8 time = 1740
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=1740.05n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 1740
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=1740.05n

* CHECK dout0_8 Vdout0_8ck173 = 1.8 time = 1740
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=1740.05n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 1740
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=1740.05n

* CHECK dout0_10 Vdout0_10ck173 = 1.8 time = 1740
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=1740.05n

* CHECK dout0_11 Vdout0_11ck173 = 1.8 time = 1740
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=1740.05n

* CHECK dout0_12 Vdout0_12ck173 = 0 time = 1740
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=1740.05n

* CHECK dout0_13 Vdout0_13ck173 = 1.8 time = 1740
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=1740.05n

* CHECK dout0_14 Vdout0_14ck173 = 1.8 time = 1740
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=1740.05n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 1740
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=1740.05n

* CHECK dout0_16 Vdout0_16ck173 = 1.8 time = 1740
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=1740.05n

* CHECK dout0_17 Vdout0_17ck173 = 1.8 time = 1740
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=1740.05n

* CHECK dout0_18 Vdout0_18ck173 = 0 time = 1740
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=1740.05n

* CHECK dout0_19 Vdout0_19ck173 = 1.8 time = 1740
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=1740.05n

* CHECK dout0_20 Vdout0_20ck173 = 1.8 time = 1740
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=1740.05n

* CHECK dout0_21 Vdout0_21ck173 = 0 time = 1740
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=1740.05n

* CHECK dout0_22 Vdout0_22ck173 = 1.8 time = 1740
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=1740.05n

* CHECK dout0_23 Vdout0_23ck173 = 0 time = 1740
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=1740.05n

* CHECK dout0_24 Vdout0_24ck173 = 0 time = 1740
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=1740.05n

* CHECK dout0_25 Vdout0_25ck173 = 1.8 time = 1740
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=1740.05n

* CHECK dout0_26 Vdout0_26ck173 = 1.8 time = 1740
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=1740.05n

* CHECK dout0_27 Vdout0_27ck173 = 1.8 time = 1740
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=1740.05n

* CHECK dout0_28 Vdout0_28ck173 = 1.8 time = 1740
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=1740.05n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 1740
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=1740.05n

* CHECK dout0_30 Vdout0_30ck173 = 1.8 time = 1740
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=1740.05n

* CHECK dout0_31 Vdout0_31ck173 = 0 time = 1740
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=1740.05n

* CHECK dout0_32 Vdout0_32ck173 = 0 time = 1740
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=1740.05n

* CHECK dout0_0 Vdout0_0ck175 = 1.8 time = 1760
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=1760.05n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 1760
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=1760.05n

* CHECK dout0_2 Vdout0_2ck175 = 0 time = 1760
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=1760.05n

* CHECK dout0_3 Vdout0_3ck175 = 0 time = 1760
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=1760.05n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 1760
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=1760.05n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 1760
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=1760.05n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 1760
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=1760.05n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 1760
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=1760.05n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 1760
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=1760.05n

* CHECK dout0_9 Vdout0_9ck175 = 0 time = 1760
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=1760.05n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 1760
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=1760.05n

* CHECK dout0_11 Vdout0_11ck175 = 0 time = 1760
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=1760.05n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 1760
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=1760.05n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 1760
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=1760.05n

* CHECK dout0_14 Vdout0_14ck175 = 1.8 time = 1760
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=1760.05n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 1760
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=1760.05n

* CHECK dout0_16 Vdout0_16ck175 = 0 time = 1760
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=1760.05n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 1760
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=1760.05n

* CHECK dout0_18 Vdout0_18ck175 = 1.8 time = 1760
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=1760.05n

* CHECK dout0_19 Vdout0_19ck175 = 0 time = 1760
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=1760.05n

* CHECK dout0_20 Vdout0_20ck175 = 1.8 time = 1760
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=1760.05n

* CHECK dout0_21 Vdout0_21ck175 = 1.8 time = 1760
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=1760.05n

* CHECK dout0_22 Vdout0_22ck175 = 0 time = 1760
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=1760.05n

* CHECK dout0_23 Vdout0_23ck175 = 0 time = 1760
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=1760.05n

* CHECK dout0_24 Vdout0_24ck175 = 0 time = 1760
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=1760.05n

* CHECK dout0_25 Vdout0_25ck175 = 1.8 time = 1760
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=1760.05n

* CHECK dout0_26 Vdout0_26ck175 = 0 time = 1760
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=1760.05n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 1760
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=1760.05n

* CHECK dout0_28 Vdout0_28ck175 = 1.8 time = 1760
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=1760.05n

* CHECK dout0_29 Vdout0_29ck175 = 0 time = 1760
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=1760.05n

* CHECK dout0_30 Vdout0_30ck175 = 0 time = 1760
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=1760.05n

* CHECK dout0_31 Vdout0_31ck175 = 1.8 time = 1760
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=1760.05n

* CHECK dout0_32 Vdout0_32ck175 = 0 time = 1760
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=1760.05n

* CHECK dout0_0 Vdout0_0ck178 = 1.8 time = 1790
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=1790.05n

* CHECK dout0_1 Vdout0_1ck178 = 1.8 time = 1790
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=1790.05n

* CHECK dout0_2 Vdout0_2ck178 = 1.8 time = 1790
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=1790.05n

* CHECK dout0_3 Vdout0_3ck178 = 1.8 time = 1790
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=1790.05n

* CHECK dout0_4 Vdout0_4ck178 = 1.8 time = 1790
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=1790.05n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 1790
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=1790.05n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 1790
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=1790.05n

* CHECK dout0_7 Vdout0_7ck178 = 1.8 time = 1790
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=1790.05n

* CHECK dout0_8 Vdout0_8ck178 = 1.8 time = 1790
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=1790.05n

* CHECK dout0_9 Vdout0_9ck178 = 0 time = 1790
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=1790.05n

* CHECK dout0_10 Vdout0_10ck178 = 1.8 time = 1790
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=1790.05n

* CHECK dout0_11 Vdout0_11ck178 = 1.8 time = 1790
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=1790.05n

* CHECK dout0_12 Vdout0_12ck178 = 1.8 time = 1790
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=1790.05n

* CHECK dout0_13 Vdout0_13ck178 = 0 time = 1790
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=1790.05n

* CHECK dout0_14 Vdout0_14ck178 = 1.8 time = 1790
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=1790.05n

* CHECK dout0_15 Vdout0_15ck178 = 1.8 time = 1790
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=1790.05n

* CHECK dout0_16 Vdout0_16ck178 = 1.8 time = 1790
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=1790.05n

* CHECK dout0_17 Vdout0_17ck178 = 0 time = 1790
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=1790.05n

* CHECK dout0_18 Vdout0_18ck178 = 0 time = 1790
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=1790.05n

* CHECK dout0_19 Vdout0_19ck178 = 0 time = 1790
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=1790.05n

* CHECK dout0_20 Vdout0_20ck178 = 1.8 time = 1790
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=1790.05n

* CHECK dout0_21 Vdout0_21ck178 = 0 time = 1790
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=1790.05n

* CHECK dout0_22 Vdout0_22ck178 = 1.8 time = 1790
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=1790.05n

* CHECK dout0_23 Vdout0_23ck178 = 0 time = 1790
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=1790.05n

* CHECK dout0_24 Vdout0_24ck178 = 0 time = 1790
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=1790.05n

* CHECK dout0_25 Vdout0_25ck178 = 1.8 time = 1790
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=1790.05n

* CHECK dout0_26 Vdout0_26ck178 = 1.8 time = 1790
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=1790.05n

* CHECK dout0_27 Vdout0_27ck178 = 0 time = 1790
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=1790.05n

* CHECK dout0_28 Vdout0_28ck178 = 0 time = 1790
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=1790.05n

* CHECK dout0_29 Vdout0_29ck178 = 1.8 time = 1790
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=1790.05n

* CHECK dout0_30 Vdout0_30ck178 = 1.8 time = 1790
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=1790.05n

* CHECK dout0_31 Vdout0_31ck178 = 1.8 time = 1790
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=1790.05n

* CHECK dout0_32 Vdout0_32ck178 = 0 time = 1790
.meas tran vdout0_32ck178 FIND v(dout0_32) AT=1790.05n

* CHECK dout0_0 Vdout0_0ck188 = 1.8 time = 1890
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=1890.05n

* CHECK dout0_1 Vdout0_1ck188 = 1.8 time = 1890
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=1890.05n

* CHECK dout0_2 Vdout0_2ck188 = 1.8 time = 1890
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=1890.05n

* CHECK dout0_3 Vdout0_3ck188 = 1.8 time = 1890
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=1890.05n

* CHECK dout0_4 Vdout0_4ck188 = 0 time = 1890
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=1890.05n

* CHECK dout0_5 Vdout0_5ck188 = 1.8 time = 1890
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=1890.05n

* CHECK dout0_6 Vdout0_6ck188 = 1.8 time = 1890
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=1890.05n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 1890
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=1890.05n

* CHECK dout0_8 Vdout0_8ck188 = 1.8 time = 1890
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=1890.05n

* CHECK dout0_9 Vdout0_9ck188 = 0 time = 1890
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=1890.05n

* CHECK dout0_10 Vdout0_10ck188 = 1.8 time = 1890
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=1890.05n

* CHECK dout0_11 Vdout0_11ck188 = 0 time = 1890
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=1890.05n

* CHECK dout0_12 Vdout0_12ck188 = 1.8 time = 1890
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=1890.05n

* CHECK dout0_13 Vdout0_13ck188 = 1.8 time = 1890
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=1890.05n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 1890
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=1890.05n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 1890
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=1890.05n

* CHECK dout0_16 Vdout0_16ck188 = 0 time = 1890
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=1890.05n

* CHECK dout0_17 Vdout0_17ck188 = 0 time = 1890
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=1890.05n

* CHECK dout0_18 Vdout0_18ck188 = 0 time = 1890
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=1890.05n

* CHECK dout0_19 Vdout0_19ck188 = 1.8 time = 1890
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=1890.05n

* CHECK dout0_20 Vdout0_20ck188 = 1.8 time = 1890
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=1890.05n

* CHECK dout0_21 Vdout0_21ck188 = 0 time = 1890
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=1890.05n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 1890
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=1890.05n

* CHECK dout0_23 Vdout0_23ck188 = 1.8 time = 1890
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=1890.05n

* CHECK dout0_24 Vdout0_24ck188 = 0 time = 1890
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=1890.05n

* CHECK dout0_25 Vdout0_25ck188 = 1.8 time = 1890
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=1890.05n

* CHECK dout0_26 Vdout0_26ck188 = 1.8 time = 1890
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=1890.05n

* CHECK dout0_27 Vdout0_27ck188 = 0 time = 1890
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=1890.05n

* CHECK dout0_28 Vdout0_28ck188 = 1.8 time = 1890
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=1890.05n

* CHECK dout0_29 Vdout0_29ck188 = 0 time = 1890
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=1890.05n

* CHECK dout0_30 Vdout0_30ck188 = 1.8 time = 1890
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=1890.05n

* CHECK dout0_31 Vdout0_31ck188 = 1.8 time = 1890
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=1890.05n

* CHECK dout0_32 Vdout0_32ck188 = 0 time = 1890
.meas tran vdout0_32ck188 FIND v(dout0_32) AT=1890.05n

* CHECK dout0_0 Vdout0_0ck191 = 1.8 time = 1920
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=1920.05n

* CHECK dout0_1 Vdout0_1ck191 = 1.8 time = 1920
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=1920.05n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 1920
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=1920.05n

* CHECK dout0_3 Vdout0_3ck191 = 1.8 time = 1920
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=1920.05n

* CHECK dout0_4 Vdout0_4ck191 = 1.8 time = 1920
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=1920.05n

* CHECK dout0_5 Vdout0_5ck191 = 0 time = 1920
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=1920.05n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 1920
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=1920.05n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 1920
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=1920.05n

* CHECK dout0_8 Vdout0_8ck191 = 0 time = 1920
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=1920.05n

* CHECK dout0_9 Vdout0_9ck191 = 1.8 time = 1920
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=1920.05n

* CHECK dout0_10 Vdout0_10ck191 = 1.8 time = 1920
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=1920.05n

* CHECK dout0_11 Vdout0_11ck191 = 0 time = 1920
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=1920.05n

* CHECK dout0_12 Vdout0_12ck191 = 1.8 time = 1920
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=1920.05n

* CHECK dout0_13 Vdout0_13ck191 = 0 time = 1920
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=1920.05n

* CHECK dout0_14 Vdout0_14ck191 = 1.8 time = 1920
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=1920.05n

* CHECK dout0_15 Vdout0_15ck191 = 1.8 time = 1920
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=1920.05n

* CHECK dout0_16 Vdout0_16ck191 = 1.8 time = 1920
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=1920.05n

* CHECK dout0_17 Vdout0_17ck191 = 1.8 time = 1920
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=1920.05n

* CHECK dout0_18 Vdout0_18ck191 = 0 time = 1920
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=1920.05n

* CHECK dout0_19 Vdout0_19ck191 = 1.8 time = 1920
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=1920.05n

* CHECK dout0_20 Vdout0_20ck191 = 0 time = 1920
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=1920.05n

* CHECK dout0_21 Vdout0_21ck191 = 0 time = 1920
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=1920.05n

* CHECK dout0_22 Vdout0_22ck191 = 0 time = 1920
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=1920.05n

* CHECK dout0_23 Vdout0_23ck191 = 0 time = 1920
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=1920.05n

* CHECK dout0_24 Vdout0_24ck191 = 1.8 time = 1920
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=1920.05n

* CHECK dout0_25 Vdout0_25ck191 = 1.8 time = 1920
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=1920.05n

* CHECK dout0_26 Vdout0_26ck191 = 0 time = 1920
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=1920.05n

* CHECK dout0_27 Vdout0_27ck191 = 0 time = 1920
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=1920.05n

* CHECK dout0_28 Vdout0_28ck191 = 1.8 time = 1920
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=1920.05n

* CHECK dout0_29 Vdout0_29ck191 = 1.8 time = 1920
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=1920.05n

* CHECK dout0_30 Vdout0_30ck191 = 1.8 time = 1920
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=1920.05n

* CHECK dout0_31 Vdout0_31ck191 = 1.8 time = 1920
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=1920.05n

* CHECK dout0_32 Vdout0_32ck191 = 0 time = 1920
.meas tran vdout0_32ck191 FIND v(dout0_32) AT=1920.05n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 1930
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=1930.05n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 1930
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=1930.05n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 1930
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=1930.05n

* CHECK dout0_3 Vdout0_3ck192 = 1.8 time = 1930
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=1930.05n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 1930
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=1930.05n

* CHECK dout0_5 Vdout0_5ck192 = 1.8 time = 1930
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=1930.05n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 1930
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=1930.05n

* CHECK dout0_7 Vdout0_7ck192 = 1.8 time = 1930
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=1930.05n

* CHECK dout0_8 Vdout0_8ck192 = 1.8 time = 1930
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=1930.05n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 1930
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=1930.05n

* CHECK dout0_10 Vdout0_10ck192 = 1.8 time = 1930
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=1930.05n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 1930
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=1930.05n

* CHECK dout0_12 Vdout0_12ck192 = 1.8 time = 1930
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=1930.05n

* CHECK dout0_13 Vdout0_13ck192 = 1.8 time = 1930
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=1930.05n

* CHECK dout0_14 Vdout0_14ck192 = 1.8 time = 1930
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=1930.05n

* CHECK dout0_15 Vdout0_15ck192 = 1.8 time = 1930
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=1930.05n

* CHECK dout0_16 Vdout0_16ck192 = 1.8 time = 1930
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=1930.05n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 1930
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=1930.05n

* CHECK dout0_18 Vdout0_18ck192 = 1.8 time = 1930
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=1930.05n

* CHECK dout0_19 Vdout0_19ck192 = 1.8 time = 1930
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=1930.05n

* CHECK dout0_20 Vdout0_20ck192 = 1.8 time = 1930
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=1930.05n

* CHECK dout0_21 Vdout0_21ck192 = 1.8 time = 1930
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=1930.05n

* CHECK dout0_22 Vdout0_22ck192 = 1.8 time = 1930
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=1930.05n

* CHECK dout0_23 Vdout0_23ck192 = 0 time = 1930
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=1930.05n

* CHECK dout0_24 Vdout0_24ck192 = 1.8 time = 1930
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=1930.05n

* CHECK dout0_25 Vdout0_25ck192 = 1.8 time = 1930
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=1930.05n

* CHECK dout0_26 Vdout0_26ck192 = 1.8 time = 1930
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=1930.05n

* CHECK dout0_27 Vdout0_27ck192 = 0 time = 1930
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=1930.05n

* CHECK dout0_28 Vdout0_28ck192 = 0 time = 1930
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=1930.05n

* CHECK dout0_29 Vdout0_29ck192 = 0 time = 1930
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=1930.05n

* CHECK dout0_30 Vdout0_30ck192 = 1.8 time = 1930
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=1930.05n

* CHECK dout0_31 Vdout0_31ck192 = 1.8 time = 1930
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=1930.05n

* CHECK dout0_32 Vdout0_32ck192 = 0 time = 1930
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=1930.05n

* CHECK dout0_0 Vdout0_0ck198 = 1.8 time = 1990
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=1990.05n

* CHECK dout0_1 Vdout0_1ck198 = 0 time = 1990
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=1990.05n

* CHECK dout0_2 Vdout0_2ck198 = 1.8 time = 1990
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=1990.05n

* CHECK dout0_3 Vdout0_3ck198 = 1.8 time = 1990
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=1990.05n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 1990
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=1990.05n

* CHECK dout0_5 Vdout0_5ck198 = 0 time = 1990
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=1990.05n

* CHECK dout0_6 Vdout0_6ck198 = 0 time = 1990
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=1990.05n

* CHECK dout0_7 Vdout0_7ck198 = 0 time = 1990
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=1990.05n

* CHECK dout0_8 Vdout0_8ck198 = 1.8 time = 1990
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=1990.05n

* CHECK dout0_9 Vdout0_9ck198 = 1.8 time = 1990
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=1990.05n

* CHECK dout0_10 Vdout0_10ck198 = 0 time = 1990
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=1990.05n

* CHECK dout0_11 Vdout0_11ck198 = 1.8 time = 1990
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=1990.05n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 1990
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=1990.05n

* CHECK dout0_13 Vdout0_13ck198 = 1.8 time = 1990
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=1990.05n

* CHECK dout0_14 Vdout0_14ck198 = 0 time = 1990
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=1990.05n

* CHECK dout0_15 Vdout0_15ck198 = 1.8 time = 1990
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=1990.05n

* CHECK dout0_16 Vdout0_16ck198 = 0 time = 1990
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=1990.05n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 1990
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=1990.05n

* CHECK dout0_18 Vdout0_18ck198 = 0 time = 1990
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=1990.05n

* CHECK dout0_19 Vdout0_19ck198 = 0 time = 1990
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=1990.05n

* CHECK dout0_20 Vdout0_20ck198 = 0 time = 1990
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=1990.05n

* CHECK dout0_21 Vdout0_21ck198 = 0 time = 1990
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=1990.05n

* CHECK dout0_22 Vdout0_22ck198 = 0 time = 1990
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=1990.05n

* CHECK dout0_23 Vdout0_23ck198 = 1.8 time = 1990
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=1990.05n

* CHECK dout0_24 Vdout0_24ck198 = 0 time = 1990
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=1990.05n

* CHECK dout0_25 Vdout0_25ck198 = 1.8 time = 1990
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=1990.05n

* CHECK dout0_26 Vdout0_26ck198 = 1.8 time = 1990
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=1990.05n

* CHECK dout0_27 Vdout0_27ck198 = 0 time = 1990
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=1990.05n

* CHECK dout0_28 Vdout0_28ck198 = 1.8 time = 1990
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=1990.05n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 1990
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=1990.05n

* CHECK dout0_30 Vdout0_30ck198 = 1.8 time = 1990
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=1990.05n

* CHECK dout0_31 Vdout0_31ck198 = 0 time = 1990
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=1990.05n

* CHECK dout0_32 Vdout0_32ck198 = 0 time = 1990
.meas tran vdout0_32ck198 FIND v(dout0_32) AT=1990.05n

* CHECK dout0_0 Vdout0_0ck204 = 1.8 time = 2050
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=2050.05n

* CHECK dout0_1 Vdout0_1ck204 = 0 time = 2050
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=2050.05n

* CHECK dout0_2 Vdout0_2ck204 = 1.8 time = 2050
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=2050.05n

* CHECK dout0_3 Vdout0_3ck204 = 0 time = 2050
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=2050.05n

* CHECK dout0_4 Vdout0_4ck204 = 1.8 time = 2050
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=2050.05n

* CHECK dout0_5 Vdout0_5ck204 = 0 time = 2050
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=2050.05n

* CHECK dout0_6 Vdout0_6ck204 = 0 time = 2050
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=2050.05n

* CHECK dout0_7 Vdout0_7ck204 = 0 time = 2050
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=2050.05n

* CHECK dout0_8 Vdout0_8ck204 = 1.8 time = 2050
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=2050.05n

* CHECK dout0_9 Vdout0_9ck204 = 1.8 time = 2050
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=2050.05n

* CHECK dout0_10 Vdout0_10ck204 = 0 time = 2050
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=2050.05n

* CHECK dout0_11 Vdout0_11ck204 = 1.8 time = 2050
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=2050.05n

* CHECK dout0_12 Vdout0_12ck204 = 0 time = 2050
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=2050.05n

* CHECK dout0_13 Vdout0_13ck204 = 0 time = 2050
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=2050.05n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 2050
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=2050.05n

* CHECK dout0_15 Vdout0_15ck204 = 1.8 time = 2050
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=2050.05n

* CHECK dout0_16 Vdout0_16ck204 = 0 time = 2050
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=2050.05n

* CHECK dout0_17 Vdout0_17ck204 = 1.8 time = 2050
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=2050.05n

* CHECK dout0_18 Vdout0_18ck204 = 1.8 time = 2050
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=2050.05n

* CHECK dout0_19 Vdout0_19ck204 = 1.8 time = 2050
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=2050.05n

* CHECK dout0_20 Vdout0_20ck204 = 1.8 time = 2050
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=2050.05n

* CHECK dout0_21 Vdout0_21ck204 = 0 time = 2050
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=2050.05n

* CHECK dout0_22 Vdout0_22ck204 = 1.8 time = 2050
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=2050.05n

* CHECK dout0_23 Vdout0_23ck204 = 0 time = 2050
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=2050.05n

* CHECK dout0_24 Vdout0_24ck204 = 0 time = 2050
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=2050.05n

* CHECK dout0_25 Vdout0_25ck204 = 1.8 time = 2050
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=2050.05n

* CHECK dout0_26 Vdout0_26ck204 = 0 time = 2050
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=2050.05n

* CHECK dout0_27 Vdout0_27ck204 = 1.8 time = 2050
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=2050.05n

* CHECK dout0_28 Vdout0_28ck204 = 1.8 time = 2050
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=2050.05n

* CHECK dout0_29 Vdout0_29ck204 = 0 time = 2050
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=2050.05n

* CHECK dout0_30 Vdout0_30ck204 = 1.8 time = 2050
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=2050.05n

* CHECK dout0_31 Vdout0_31ck204 = 1.8 time = 2050
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=2050.05n

* CHECK dout0_32 Vdout0_32ck204 = 0 time = 2050
.meas tran vdout0_32ck204 FIND v(dout0_32) AT=2050.05n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
