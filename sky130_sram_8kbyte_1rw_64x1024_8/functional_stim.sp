* Functional test stimulus file for 10ns period

* TT process corner
.lib "/home/software/PDKs/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "sky130_sram_8kbyte_1rw_64x1024_8.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsky130_sram_8kbyte_1rw_64x1024_8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 a0_9 a0_10 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 WMASK0_4 WMASK0_5 WMASK0_6 WMASK0_7 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 dout0_64 vdd gnd sky130_sram_8kbyte_1rw_64x1024_8

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f
CD033 dout0_33  0 27.56f
CD034 dout0_34  0 27.56f
CD035 dout0_35  0 27.56f
CD036 dout0_36  0 27.56f
CD037 dout0_37  0 27.56f
CD038 dout0_38  0 27.56f
CD039 dout0_39  0 27.56f
CD040 dout0_40  0 27.56f
CD041 dout0_41  0 27.56f
CD042 dout0_42  0 27.56f
CD043 dout0_43  0 27.56f
CD044 dout0_44  0 27.56f
CD045 dout0_45  0 27.56f
CD046 dout0_46  0 27.56f
CD047 dout0_47  0 27.56f
CD048 dout0_48  0 27.56f
CD049 dout0_49  0 27.56f
CD050 dout0_50  0 27.56f
CD051 dout0_51  0 27.56f
CD052 dout0_52  0 27.56f
CD053 dout0_53  0 27.56f
CD054 dout0_54  0 27.56f
CD055 dout0_55  0 27.56f
CD056 dout0_56  0 27.56f
CD057 dout0_57  0 27.56f
CD058 dout0_58  0 27.56f
CD059 dout0_59  0 27.56f
CD060 dout0_60  0 27.56f
CD061 dout0_61  0 27.56f
CD062 dout0_62  0 27.56f
CD063 dout0_63  0 27.56f
CD064 dout0_64  0 27.56f

* Important signals for debug
* bl:	xsky130_sram_8kbyte_1rw_64x1024_8.xbank0.bl_0_0
* br:	xsky130_sram_8kbyte_1rw_64x1024_8.xbank0.br_0_0
* s_en:	xsky130_sram_8kbyte_1rw_64x1024_8.s_en
* q:	xsky130_sram_8kbyte_1rw_64x1024_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q
* qbar:	xsky130_sram_8kbyte_1rw_64x1024_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+1011000001000000010011001101011100010011000111001110100000110010  to  address 00000000000 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+1110010011111110100111011010100000000000111110010000010000110001  to  address 10000000010 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+0011100100100100001001100010111010001110100011010011000010100100  to  address 01111111111 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+1011000001000000010011001101011100010011000111001110100000110010 from address 00000000000 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 0+0011100100100100001001100010111010001110100011010011000010100100 from address 01111111111 (from port 0) during cycle 5 (50ns - 60ns)
*	Writing 0+0101111011110100110010011001101010101100101101100000001011001011  to  address 00000000011 (from port 0) during cycle 6 (60ns - 70ns)
*	Writing 0+1001100100100111100011010100110001010111011111101010001111111100  to  address 00000000011 (from port 0) during cycle 7 (70ns - 80ns)
*	Writing 0+1000010011111000101101010100010101101100100000001110011100001101  to  address 00000000010 (from port 0) during cycle 8 (80ns - 90ns)
*	Reading 0+1001100100100111100011010100110001010111011111101010001111111100 from address 00000000011 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 0+0011100100100100001001100010111010001110100011010011000010100100 from address 01111111111 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 0+1011000001000000010011001101011100010011000111001110100000110010 from address 00000000000 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 0+0001100011110000100110010000010111011011101101100101111000100101  to  address 10000000001 (from port 0) during cycle 13 (130ns - 140ns)
*	Writing (partial) 0+0111000101000110111010111011000010110000011001110000001011111001  to  address 00000000010 with mask bit 00010100 (from port 0) during cycle 14 (140ns - 150ns)
*	Reading 0+1001100100100111100011010100110001010111011111101010001111111100 from address 00000000011 (from port 0) during cycle 15 (150ns - 160ns)
*	Writing 0+1101101011101101001110101000100101100011011100011110101100110011  to  address 10000000000 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 0+1001100100100111100011010100110001010111011111101010001111111100 from address 00000000011 (from port 0) during cycle 17 (170ns - 180ns)
*	Reading 0+0011100100100100001001100010111010001110100011010011000010100100 from address 01111111111 (from port 0) during cycle 19 (190ns - 200ns)
*	Reading 0+0011100100100100001001100010111010001110100011010011000010100100 from address 01111111111 (from port 0) during cycle 20 (200ns - 210ns)
*	Writing (partial) 0+0010001111100100100110011110001110111110000011100011010101001010  to  address 00000000000 with mask bit 00101100 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 0+0011100100100100001001100010111010001110100011010011000010100100 from address 01111111111 (from port 0) during cycle 22 (220ns - 230ns)
*	Reading 0+1001100100100111100011010100110001010111011111101010001111111100 from address 00000000011 (from port 0) during cycle 23 (230ns - 240ns)
*	Reading 0+1110010011111110100111011010100000000000111110010000010000110001 from address 10000000010 (from port 0) during cycle 24 (240ns - 250ns)
*	Writing 0+0010111101110101000101110011110010110000001100101011110100011100  to  address 00000000010 (from port 0) during cycle 25 (250ns - 260ns)
*	Reading 0+0011100100100100001001100010111010001110100011010011000010100100 from address 01111111111 (from port 0) during cycle 26 (260ns - 270ns)
*	Reading 0+0010111101110101000101110011110010110000001100101011110100011100 from address 00000000010 (from port 0) during cycle 27 (270ns - 280ns)
*	Writing (partial) 0+0000001010000010010101111011111101001110001111000100011000010101  to  address 00000000010 with mask bit 11000101 (from port 0) during cycle 28 (280ns - 290ns)
*	Writing 0+0100100001011110011001000000010101010011101010001101000110101011  to  address 00000000010 (from port 0) during cycle 29 (290ns - 300ns)
*	Writing (partial) 0+1011001000111111001110101010011100010001000110011101110010000100  to  address 00000000010 with mask bit 01110011 (from port 0) during cycle 30 (300ns - 310ns)
*	Writing 0+0000010010111111110000101101011101111101111010110010111110000000  to  address 00000000011 (from port 0) during cycle 31 (310ns - 320ns)
*	Writing (partial) 0+1011101110100010101110100111110000101100110010100111011000000110  to  address 01111111111 with mask bit 10110010 (from port 0) during cycle 32 (320ns - 330ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 33 (330ns - 340ns)
*	Reading 0+0000010010111111110000101101011101111101111010110010111110000000 from address 00000000011 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 0+1110010011111110100111011010100000000000111110010000010000110001 from address 10000000010 (from port 0) during cycle 35 (350ns - 360ns)
*	Writing (partial) 0+0010101010000100011001100100111000100101010111001000000110001101  to  address 00000000011 with mask bit 00010101 (from port 0) during cycle 36 (360ns - 370ns)
*	Writing (partial) 0+1000000001111010010100101101111110001110101100001000011101000100  to  address 01111111111 with mask bit 01110011 (from port 0) during cycle 37 (370ns - 380ns)
*	Reading 0+1011000001000000100110011101011110111110000011101110100000110010 from address 00000000000 (from port 0) during cycle 40 (400ns - 410ns)
*	Writing 0+0100001011100001110111001100010111110000010001110001111110011011  to  address 00000000001 (from port 0) during cycle 41 (410ns - 420ns)
*	Writing 0+1111110000001101110101011001000100010100110011101010011111111010  to  address 00000000011 (from port 0) during cycle 43 (430ns - 440ns)
*	Writing (partial) 0+0111101101110001101010000110011001101000110001100100011110101100  to  address 00000000001 with mask bit 11000111 (from port 0) during cycle 44 (440ns - 450ns)
*	Writing (partial) 0+0010011001101100000110011100100011000000111101001001100010101100  to  address 10000000001 with mask bit 00100010 (from port 0) during cycle 45 (450ns - 460ns)
*	Reading 0+1111110000001101110101011001000100010100110011101010011111111010 from address 00000000011 (from port 0) during cycle 46 (460ns - 470ns)
*	Reading 0+1111110000001101110101011001000100010100110011101010011111111010 from address 00000000011 (from port 0) during cycle 47 (470ns - 480ns)
*	Writing 0+1101111101100010010111100100011001010000111011000011110100110111  to  address 00000000000 (from port 0) during cycle 48 (480ns - 490ns)
*	Writing (partial) 0+0101101111011100100111001110010001000100011100000110000101100011  to  address 00000000011 with mask bit 11100101 (from port 0) during cycle 49 (490ns - 500ns)
*	Writing (partial) 0+0101011100001101111001010001101100000101101100101000011101000101  to  address 00000000011 with mask bit 11011110 (from port 0) during cycle 50 (500ns - 510ns)
*	Reading 0+1101111101100010010111100100011001010000111011000011110100110111 from address 00000000000 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 0+0100100000111111001110101010011101010011101010001101110010000100 from address 00000000010 (from port 0) during cycle 52 (520ns - 530ns)
*	Reading 0+1011101101111010010100101101111110001110100011011000011101000100 from address 01111111111 (from port 0) during cycle 53 (530ns - 540ns)
*	Writing 0+1000101000100011101100001111111110001100000111010000001110110110  to  address 10000000001 (from port 0) during cycle 54 (540ns - 550ns)
*	Writing (partial) 0+1011011111111111011000011111000001000111100110011000001101110000  to  address 10000000010 with mask bit 01111101 (from port 0) during cycle 56 (560ns - 570ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 59 (590ns - 600ns)
*	Reading 0+1110010011111111011000011111000001000111100110010000010001110000 from address 10000000010 (from port 0) during cycle 60 (600ns - 610ns)
*	Reading 0+0111101101110001110111001100010111110000110001100100011110101100 from address 00000000001 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 0+0101011100001101100111000001101100000101101100101000011101100011 from address 00000000011 (from port 0) during cycle 63 (630ns - 640ns)
*	Reading 0+1000101000100011101100001111111110001100000111010000001110110110 from address 10000000001 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 65 (650ns - 660ns)
*	Writing (partial) 0+0000111011101100101111101101001011111111101000000000111000011110  to  address 00000000011 with mask bit 11111100 (from port 0) during cycle 66 (660ns - 670ns)
*	Reading 0+1110010011111111011000011111000001000111100110010000010001110000 from address 10000000010 (from port 0) during cycle 68 (680ns - 690ns)
*	Writing (partial) 0+0001011001100111000100110010001001111001100010101001110000101111  to  address 00000000011 with mask bit 11001110 (from port 0) during cycle 69 (690ns - 700ns)
*	Reading 0+1011101101111010010100101101111110001110100011011000011101000100 from address 01111111111 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 0+0100100000111111001110101010011101010011101010001101110010000100 from address 00000000010 (from port 0) during cycle 73 (730ns - 740ns)
*	Writing 0+0101100010110101100110010010101111011000111000101110001100001101  to  address 00000000000 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 0+0001011001100111101111101101001001111001100010101001110001100011 from address 00000000011 (from port 0) during cycle 76 (760ns - 770ns)
*	Writing (partial) 0+0110100101100001110101010110011000101100011001010100010010111010  to  address 00000000000 with mask bit 01111101 (from port 0) during cycle 77 (770ns - 780ns)
*	Reading 0+0101100001100001110101010110011000101100011001011110001110111010 from address 00000000000 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing (partial) 0+1101010111010010010000110010100001011110010111010010111100010101  to  address 10000000010 with mask bit 01010001 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 0+0101100001100001110101010110011000101100011001011110001110111010 from address 00000000000 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 0+1110010011010010011000010010100001000111100110010000010000010101 from address 10000000010 (from port 0) during cycle 82 (820ns - 830ns)
*	Writing 0+1110100001011110011110110110101110111110101011101011111110011101  to  address 00000000000 (from port 0) during cycle 83 (830ns - 840ns)
*	Reading 0+0100100000111111001110101010011101010011101010001101110010000100 from address 00000000010 (from port 0) during cycle 84 (840ns - 850ns)
*	Reading 0+1000101000100011101100001111111110001100000111010000001110110110 from address 10000000001 (from port 0) during cycle 85 (850ns - 860ns)
*	Writing 0+1001100101010111111111010101011101000011010101010101010100100010  to  address 00000000000 (from port 0) during cycle 86 (860ns - 870ns)
*	Writing (partial) 0+0011010010101111011101101001010110001001111000000010100111111110  to  address 00000000000 with mask bit 10010001 (from port 0) during cycle 87 (870ns - 880ns)
*	Writing 0+1001100110010100010000100100111001010111010011100110001011010101  to  address 00000000001 (from port 0) during cycle 88 (880ns - 890ns)
*	Reading 0+0011010001010111111111011001010101000011010101010101010111111110 from address 00000000000 (from port 0) during cycle 89 (890ns - 900ns)
*	Writing (partial) 0+0011010011001110011111111101101111111110000101011111111001010100  to  address 00000000001 with mask bit 01110011 (from port 0) during cycle 90 (900ns - 910ns)
*	Writing (partial) 0+0001011001011111001101110011101111001001111101011000011111000100  to  address 00000000010 with mask bit 10101000 (from port 0) during cycle 91 (910ns - 920ns)
*	Writing (partial) 0+0101011010110001100000110001111000010000000111110011001100111010  to  address 10000000001 with mask bit 00010001 (from port 0) during cycle 92 (920ns - 930ns)
*	Writing 0+1111100000111001110101000000011101101111100110000000111100111011  to  address 00000000011 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 94 (940ns - 950ns)
*	Writing 0+1001011010011100010001100111001011001110010111101100001010001001  to  address 00000000011 (from port 0) during cycle 95 (950ns - 960ns)
*	Reading 0+1000101000100011101100000001111010001100000111010000001100111010 from address 10000000001 (from port 0) during cycle 96 (960ns - 970ns)
*	Writing (partial) 0+1001001101101100001000001101101011011010111100001001010001111100  to  address 00000000000 with mask bit 01000110 (from port 0) during cycle 97 (970ns - 980ns)
*	Writing (partial) 0+0111111000101110110111011100011010000010111000100101011101011110  to  address 00000000000 with mask bit 00100100 (from port 0) during cycle 98 (980ns - 990ns)
*	Writing 0+1101001111010010001000101111110001011100100010001011101001001011  to  address 00000000011 (from port 0) during cycle 99 (990ns - 1000ns)
*	Writing 0+1110000100100011011001100000100010100110110100010111000110000101  to  address 10000000010 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+1001100111001110011111111101101101010111010011101111111001010100 from address 00000000001 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 0+1101001111010010001000101111110001011100100010001011101001001011 from address 00000000011 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Reading 0+1110000100100011011001100000100010100110110100010111000110000101 from address 10000000010 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 0+0011010001101100110111011001010101000011111000101001010011111110 from address 00000000000 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Writing 0+0000010101100000101000001001110101100010001010111110100000100101  to  address 00000000000 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 0+1110000100100011011001100000100010100110110100010111000110000101 from address 10000000010 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Reading 0+1001100111001110011111111101101101010111010011101111111001010100 from address 00000000001 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Reading 0+0001011000111111001101111010011111001001101010001101110010000100 from address 00000000010 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 0+0000010101100000101000001001110101100010001010111110100000100101 from address 00000000000 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Writing (partial) 0+1111110110001010011101110010010111011011001100000001001011001000  to  address 10000000001 with mask bit 10110110 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Writing 0+0100010010110000111110010101000111111101011100001100111001111100  to  address 00000000010 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Writing (partial) 0+0011011001000010111100000010000010111001100010001001111101010110  to  address 00000000010 with mask bit 00011010 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 0+1001100111001110011111111101101101010111010011101111111001010100 from address 00000000001 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 0+1001100111001110011111111101101101010111010011101111111001010100 from address 00000000001 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Writing 0+0000011100011111001110010001001111100010100001111110010101010111  to  address 00000000001 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 124 (1240ns - 1250ns)
*	Writing (partial) 0+1011010111010001001010010000111101111001001111001111101111010100  to  address 00000000001 with mask bit 01011110 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Reading 0+0000010101100000101000001001110101100010001010111110100000100101 from address 00000000000 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 0+0000010101100000101000001001110101100010001010111110100000100101 from address 00000000000 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Reading 0+1110000100100011011001100000100010100110110100010111000110000101 from address 10000000010 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Writing (partial) 0+0000000000100101001011011011100110111101011011010011101110110000  to  address 00000000011 with mask bit 01010100 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Writing (partial) 0+1101110111110000110011101111001000111010001100101010011010010100  to  address 10000000010 with mask bit 11110001 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Writing (partial) 0+1000100101001111001010101100000010100000010111010001000100010011  to  address 00000000000 with mask bit 00000110 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 0+1101110111110000110011101111001010100110110100010111000110010100 from address 10000000010 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Writing 0+0010110110000110000100100011101011001111100001101101101110110010  to  address 00000000011 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Writing 0+1010011010101000000011010001010101000100010100100000011001010010  to  address 01111111111 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Reading 0+0000010101100000101000001001110101100010010111010001000100100101 from address 00000000000 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Reading 0+0100010010110000111110010010000010111001011100001001111101111100 from address 00000000010 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Reading 0+1101101011101101001110101000100101100011011100011110101100110011 from address 10000000000 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Writing 0+1111001110100110011011001101101000111000010111100101110001001011  to  address 00000000000 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Writing 0+1001000010011100110101001011101110001000001111111110000100100001  to  address 00000000001 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Reading 0+0100010010110000111110010010000010111001011100001001111101111100 from address 00000000010 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Reading 0+1010011010101000000011010001010101000100010100100000011001010010 from address 01111111111 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Writing (partial) 0+0011100000100111101010001110111001101110100110111101000011101111  to  address 00000000001 with mask bit 00011101 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Reading 0+1111110100100011011101110010010110001100001100000001001000111010 from address 10000000001 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Reading 0+1001000010011100110101001110111001101110100110111110000111101111 from address 00000000001 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Writing 0+0110110001111101101101111101101101100000111101010010100101111100  to  address 10000000010 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 0+1010011010101000000011010001010101000100010100100000011001010010 from address 01111111111 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Writing (partial) 0+0011110001110000000001010010000110000011101110100111011101011001  to  address 00000000010 with mask bit 00011011 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Writing 0+0010010100101110010110011001101000111001100110010010000111101111  to  address 10000000000 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Reading 0+0010110110000110000100100011101011001111100001101101101110110010 from address 00000000011 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Writing (partial) 0+0110010110111001101100010010010110011000011111011001111001101110  to  address 00000000010 with mask bit 01110110 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Writing (partial) 0+0111100100010110110011001101010001011010110001000100001111101100  to  address 00000000010 with mask bit 01100001 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 0+1010011010101000000011010001010101000100010100100000011001010010 from address 01111111111 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Writing 0+0010101010110111110110000010010101110100111101100010010101110110  to  address 00000000001 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Writing 0+0110001110111110111110000001101111001010010010001110100111000001  to  address 01111111111 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Writing (partial) 0+0101111101101010010101110010101111001011000011010101101101001000  to  address 10000000000 with mask bit 00100010 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 0+0010110110000110000100100011101011001111100001101101101110110010 from address 00000000011 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Writing (partial) 0+1010010000010001100101100111010100100110100011100101011111010110  to  address 10000000000 with mask bit 01011101 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 0+1111001110100110011011001101101000111000010111100101110001001011 from address 00000000000 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 0+0010101010110111110110000010010101110100111101100010010101110110 from address 00000000001 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Reading 0+0010101010110111110110000010010101110100111101100010010101110110 from address 00000000001 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 0+1111110100100011011101110010010110001100001100000001001000111010 from address 10000000001 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Reading 0+0010110110000110000100100011101011001111100001101101101110110010 from address 00000000011 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 0+0110110001111101101101111101101101100000111101010010100101111100 from address 10000000010 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Reading 0+0100010000010110110011000010010110000011011111011001111011101100 from address 00000000010 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Writing 0+0001011000100000011010001101111000100001100010111010101110101000  to  address 00000000011 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Reading 0+1111001110100110011011001101101000111000010111100101110001001011 from address 00000000000 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Reading 0+0110001110111110111110000001101111001010010010001110100111000001 from address 01111111111 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Reading 0+0110001110111110111110000001101111001010010010001110100111000001 from address 01111111111 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Writing (partial) 0+1001010011001111110100000000011101110010101110011010000010001001  to  address 10000000001 with mask bit 01011111 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 0+0110110001111101101101111101101101100000111101010010100101111100 from address 10000000010 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Reading 0+1111001110100110011011001101101000111000010111100101110001001011 from address 00000000000 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 0+0110110001111101101101111101101101100000111101010010100101111100 from address 10000000010 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Reading 0+0001011000100000011010001101111000100001100010111010101110101000 from address 00000000011 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Writing 0+1100101110011010110101110000110000001110110000010010001110000101  to  address 00000000000 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing (partial) 0+1010001110000001010110000101111001001110110011000000001100110111  to  address 10000000000 with mask bit 11110010 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 0+1111110111001111011101110000011101110010101110011010000010001001 from address 10000000001 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Writing 0+1011011010010010100110010010011001011000001101101011111101100101  to  address 00000000010 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Writing 0+0101111010011110000001011101111011001001101101110011101000011000  to  address 00000000000 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Writing 0+1101000100110001111101001011010100001110110110110011010101100000  to  address 10000000000 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 0+1011011010010010100110010010011001011000001101101011111101100101 from address 00000000010 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Writing 0+0110101101110111110101001011110100001000011111011101110101101111  to  address 10000000010 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 0+0110001110111110111110000001101111001010010010001110100111000001 from address 01111111111 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Writing 0+0111010011100001101100011000101010101111100111000010111110000011  to  address 01111111111 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Reading 0+0110101101110111110101001011110100001000011111011101110101101111 from address 10000000010 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing (partial) 0+1110000110101001111001011010111100100001110000001110111001000000  to  address 00000000010 with mask bit 11111001 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 0+0101111010011110000001011101111011001001101101110011101000011000 from address 00000000000 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Reading 0+0001011000100000011010001101111000100001100010111010101110101000 from address 00000000011 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 0), (890, 0), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 0), (150, 1), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 0), (340, 1), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 0), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 0), (600, 1), (610, 1), (620, 0), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 1), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 0), (950, 1), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_9  a0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 0), (150, 0), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 1), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 1), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 0), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_10  a0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 0), (410, 0), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 0), (690, 0), (700, 1), (710, 0), (720, 1), (730, 0), (740, 1), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 0), (780, 1), (790, 1), (800, 0), (810, 1), (820, 1), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of wmask signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 0), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_4  WMASK0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_5  WMASK0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_6  WMASK0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_7  WMASK0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 1.8 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 1.8 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 50
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=50.05n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 50
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=50.05n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 50
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=50.05n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 50
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=50.05n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 50
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=50.05n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 50
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=50.05n

* CHECK dout0_14 Vdout0_14ck4 = 1.8 time = 50
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=50.05n

* CHECK dout0_15 Vdout0_15ck4 = 1.8 time = 50
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=50.05n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 50
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=50.05n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 50
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=50.05n

* CHECK dout0_18 Vdout0_18ck4 = 1.8 time = 50
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=50.05n

* CHECK dout0_19 Vdout0_19ck4 = 1.8 time = 50
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=50.05n

* CHECK dout0_20 Vdout0_20ck4 = 1.8 time = 50
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=50.05n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 50
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=50.05n

* CHECK dout0_22 Vdout0_22ck4 = 0 time = 50
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=50.05n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 50
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=50.05n

* CHECK dout0_24 Vdout0_24ck4 = 1.8 time = 50
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=50.05n

* CHECK dout0_25 Vdout0_25ck4 = 1.8 time = 50
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=50.05n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 50
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=50.05n

* CHECK dout0_27 Vdout0_27ck4 = 0 time = 50
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=50.05n

* CHECK dout0_28 Vdout0_28ck4 = 1.8 time = 50
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=50.05n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 50
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=50.05n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 50
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=50.05n

* CHECK dout0_31 Vdout0_31ck4 = 0 time = 50
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=50.05n

* CHECK dout0_32 Vdout0_32ck4 = 1.8 time = 50
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=50.05n

* CHECK dout0_33 Vdout0_33ck4 = 1.8 time = 50
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=50.05n

* CHECK dout0_34 Vdout0_34ck4 = 1.8 time = 50
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=50.05n

* CHECK dout0_35 Vdout0_35ck4 = 0 time = 50
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=50.05n

* CHECK dout0_36 Vdout0_36ck4 = 1.8 time = 50
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=50.05n

* CHECK dout0_37 Vdout0_37ck4 = 0 time = 50
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=50.05n

* CHECK dout0_38 Vdout0_38ck4 = 1.8 time = 50
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=50.05n

* CHECK dout0_39 Vdout0_39ck4 = 1.8 time = 50
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=50.05n

* CHECK dout0_40 Vdout0_40ck4 = 0 time = 50
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=50.05n

* CHECK dout0_41 Vdout0_41ck4 = 0 time = 50
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=50.05n

* CHECK dout0_42 Vdout0_42ck4 = 1.8 time = 50
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=50.05n

* CHECK dout0_43 Vdout0_43ck4 = 1.8 time = 50
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=50.05n

* CHECK dout0_44 Vdout0_44ck4 = 0 time = 50
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=50.05n

* CHECK dout0_45 Vdout0_45ck4 = 0 time = 50
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=50.05n

* CHECK dout0_46 Vdout0_46ck4 = 1.8 time = 50
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=50.05n

* CHECK dout0_47 Vdout0_47ck4 = 0 time = 50
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=50.05n

* CHECK dout0_48 Vdout0_48ck4 = 0 time = 50
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=50.05n

* CHECK dout0_49 Vdout0_49ck4 = 0 time = 50
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=50.05n

* CHECK dout0_50 Vdout0_50ck4 = 0 time = 50
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=50.05n

* CHECK dout0_51 Vdout0_51ck4 = 0 time = 50
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=50.05n

* CHECK dout0_52 Vdout0_52ck4 = 0 time = 50
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=50.05n

* CHECK dout0_53 Vdout0_53ck4 = 0 time = 50
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=50.05n

* CHECK dout0_54 Vdout0_54ck4 = 1.8 time = 50
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=50.05n

* CHECK dout0_55 Vdout0_55ck4 = 0 time = 50
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=50.05n

* CHECK dout0_56 Vdout0_56ck4 = 0 time = 50
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=50.05n

* CHECK dout0_57 Vdout0_57ck4 = 0 time = 50
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=50.05n

* CHECK dout0_58 Vdout0_58ck4 = 0 time = 50
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=50.05n

* CHECK dout0_59 Vdout0_59ck4 = 0 time = 50
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=50.05n

* CHECK dout0_60 Vdout0_60ck4 = 1.8 time = 50
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=50.05n

* CHECK dout0_61 Vdout0_61ck4 = 1.8 time = 50
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=50.05n

* CHECK dout0_62 Vdout0_62ck4 = 0 time = 50
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=50.05n

* CHECK dout0_63 Vdout0_63ck4 = 1.8 time = 50
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=50.05n

* CHECK dout0_64 Vdout0_64ck4 = 0 time = 50
.meas tran vdout0_64ck4 FIND v(dout0_64) AT=50.05n

* CHECK dout0_0 Vdout0_0ck5 = 0 time = 60
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=60.05n

* CHECK dout0_1 Vdout0_1ck5 = 0 time = 60
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=60.05n

* CHECK dout0_2 Vdout0_2ck5 = 1.8 time = 60
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=60.05n

* CHECK dout0_3 Vdout0_3ck5 = 0 time = 60
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=60.05n

* CHECK dout0_4 Vdout0_4ck5 = 0 time = 60
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=60.05n

* CHECK dout0_5 Vdout0_5ck5 = 1.8 time = 60
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=60.05n

* CHECK dout0_6 Vdout0_6ck5 = 0 time = 60
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=60.05n

* CHECK dout0_7 Vdout0_7ck5 = 1.8 time = 60
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=60.05n

* CHECK dout0_8 Vdout0_8ck5 = 0 time = 60
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=60.05n

* CHECK dout0_9 Vdout0_9ck5 = 0 time = 60
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=60.05n

* CHECK dout0_10 Vdout0_10ck5 = 0 time = 60
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=60.05n

* CHECK dout0_11 Vdout0_11ck5 = 0 time = 60
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=60.05n

* CHECK dout0_12 Vdout0_12ck5 = 1.8 time = 60
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=60.05n

* CHECK dout0_13 Vdout0_13ck5 = 1.8 time = 60
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=60.05n

* CHECK dout0_14 Vdout0_14ck5 = 0 time = 60
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=60.05n

* CHECK dout0_15 Vdout0_15ck5 = 0 time = 60
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=60.05n

* CHECK dout0_16 Vdout0_16ck5 = 1.8 time = 60
.meas tran vdout0_16ck5 FIND v(dout0_16) AT=60.05n

* CHECK dout0_17 Vdout0_17ck5 = 0 time = 60
.meas tran vdout0_17ck5 FIND v(dout0_17) AT=60.05n

* CHECK dout0_18 Vdout0_18ck5 = 1.8 time = 60
.meas tran vdout0_18ck5 FIND v(dout0_18) AT=60.05n

* CHECK dout0_19 Vdout0_19ck5 = 1.8 time = 60
.meas tran vdout0_19ck5 FIND v(dout0_19) AT=60.05n

* CHECK dout0_20 Vdout0_20ck5 = 0 time = 60
.meas tran vdout0_20ck5 FIND v(dout0_20) AT=60.05n

* CHECK dout0_21 Vdout0_21ck5 = 0 time = 60
.meas tran vdout0_21ck5 FIND v(dout0_21) AT=60.05n

* CHECK dout0_22 Vdout0_22ck5 = 0 time = 60
.meas tran vdout0_22ck5 FIND v(dout0_22) AT=60.05n

* CHECK dout0_23 Vdout0_23ck5 = 1.8 time = 60
.meas tran vdout0_23ck5 FIND v(dout0_23) AT=60.05n

* CHECK dout0_24 Vdout0_24ck5 = 0 time = 60
.meas tran vdout0_24ck5 FIND v(dout0_24) AT=60.05n

* CHECK dout0_25 Vdout0_25ck5 = 1.8 time = 60
.meas tran vdout0_25ck5 FIND v(dout0_25) AT=60.05n

* CHECK dout0_26 Vdout0_26ck5 = 1.8 time = 60
.meas tran vdout0_26ck5 FIND v(dout0_26) AT=60.05n

* CHECK dout0_27 Vdout0_27ck5 = 1.8 time = 60
.meas tran vdout0_27ck5 FIND v(dout0_27) AT=60.05n

* CHECK dout0_28 Vdout0_28ck5 = 0 time = 60
.meas tran vdout0_28ck5 FIND v(dout0_28) AT=60.05n

* CHECK dout0_29 Vdout0_29ck5 = 0 time = 60
.meas tran vdout0_29ck5 FIND v(dout0_29) AT=60.05n

* CHECK dout0_30 Vdout0_30ck5 = 0 time = 60
.meas tran vdout0_30ck5 FIND v(dout0_30) AT=60.05n

* CHECK dout0_31 Vdout0_31ck5 = 1.8 time = 60
.meas tran vdout0_31ck5 FIND v(dout0_31) AT=60.05n

* CHECK dout0_32 Vdout0_32ck5 = 0 time = 60
.meas tran vdout0_32ck5 FIND v(dout0_32) AT=60.05n

* CHECK dout0_33 Vdout0_33ck5 = 1.8 time = 60
.meas tran vdout0_33ck5 FIND v(dout0_33) AT=60.05n

* CHECK dout0_34 Vdout0_34ck5 = 1.8 time = 60
.meas tran vdout0_34ck5 FIND v(dout0_34) AT=60.05n

* CHECK dout0_35 Vdout0_35ck5 = 1.8 time = 60
.meas tran vdout0_35ck5 FIND v(dout0_35) AT=60.05n

* CHECK dout0_36 Vdout0_36ck5 = 0 time = 60
.meas tran vdout0_36ck5 FIND v(dout0_36) AT=60.05n

* CHECK dout0_37 Vdout0_37ck5 = 1.8 time = 60
.meas tran vdout0_37ck5 FIND v(dout0_37) AT=60.05n

* CHECK dout0_38 Vdout0_38ck5 = 0 time = 60
.meas tran vdout0_38ck5 FIND v(dout0_38) AT=60.05n

* CHECK dout0_39 Vdout0_39ck5 = 0 time = 60
.meas tran vdout0_39ck5 FIND v(dout0_39) AT=60.05n

* CHECK dout0_40 Vdout0_40ck5 = 0 time = 60
.meas tran vdout0_40ck5 FIND v(dout0_40) AT=60.05n

* CHECK dout0_41 Vdout0_41ck5 = 1.8 time = 60
.meas tran vdout0_41ck5 FIND v(dout0_41) AT=60.05n

* CHECK dout0_42 Vdout0_42ck5 = 1.8 time = 60
.meas tran vdout0_42ck5 FIND v(dout0_42) AT=60.05n

* CHECK dout0_43 Vdout0_43ck5 = 0 time = 60
.meas tran vdout0_43ck5 FIND v(dout0_43) AT=60.05n

* CHECK dout0_44 Vdout0_44ck5 = 0 time = 60
.meas tran vdout0_44ck5 FIND v(dout0_44) AT=60.05n

* CHECK dout0_45 Vdout0_45ck5 = 1.8 time = 60
.meas tran vdout0_45ck5 FIND v(dout0_45) AT=60.05n

* CHECK dout0_46 Vdout0_46ck5 = 0 time = 60
.meas tran vdout0_46ck5 FIND v(dout0_46) AT=60.05n

* CHECK dout0_47 Vdout0_47ck5 = 0 time = 60
.meas tran vdout0_47ck5 FIND v(dout0_47) AT=60.05n

* CHECK dout0_48 Vdout0_48ck5 = 0 time = 60
.meas tran vdout0_48ck5 FIND v(dout0_48) AT=60.05n

* CHECK dout0_49 Vdout0_49ck5 = 0 time = 60
.meas tran vdout0_49ck5 FIND v(dout0_49) AT=60.05n

* CHECK dout0_50 Vdout0_50ck5 = 1.8 time = 60
.meas tran vdout0_50ck5 FIND v(dout0_50) AT=60.05n

* CHECK dout0_51 Vdout0_51ck5 = 0 time = 60
.meas tran vdout0_51ck5 FIND v(dout0_51) AT=60.05n

* CHECK dout0_52 Vdout0_52ck5 = 0 time = 60
.meas tran vdout0_52ck5 FIND v(dout0_52) AT=60.05n

* CHECK dout0_53 Vdout0_53ck5 = 1.8 time = 60
.meas tran vdout0_53ck5 FIND v(dout0_53) AT=60.05n

* CHECK dout0_54 Vdout0_54ck5 = 0 time = 60
.meas tran vdout0_54ck5 FIND v(dout0_54) AT=60.05n

* CHECK dout0_55 Vdout0_55ck5 = 0 time = 60
.meas tran vdout0_55ck5 FIND v(dout0_55) AT=60.05n

* CHECK dout0_56 Vdout0_56ck5 = 1.8 time = 60
.meas tran vdout0_56ck5 FIND v(dout0_56) AT=60.05n

* CHECK dout0_57 Vdout0_57ck5 = 0 time = 60
.meas tran vdout0_57ck5 FIND v(dout0_57) AT=60.05n

* CHECK dout0_58 Vdout0_58ck5 = 0 time = 60
.meas tran vdout0_58ck5 FIND v(dout0_58) AT=60.05n

* CHECK dout0_59 Vdout0_59ck5 = 1.8 time = 60
.meas tran vdout0_59ck5 FIND v(dout0_59) AT=60.05n

* CHECK dout0_60 Vdout0_60ck5 = 1.8 time = 60
.meas tran vdout0_60ck5 FIND v(dout0_60) AT=60.05n

* CHECK dout0_61 Vdout0_61ck5 = 1.8 time = 60
.meas tran vdout0_61ck5 FIND v(dout0_61) AT=60.05n

* CHECK dout0_62 Vdout0_62ck5 = 0 time = 60
.meas tran vdout0_62ck5 FIND v(dout0_62) AT=60.05n

* CHECK dout0_63 Vdout0_63ck5 = 0 time = 60
.meas tran vdout0_63ck5 FIND v(dout0_63) AT=60.05n

* CHECK dout0_64 Vdout0_64ck5 = 0 time = 60
.meas tran vdout0_64ck5 FIND v(dout0_64) AT=60.05n

* CHECK dout0_0 Vdout0_0ck9 = 0 time = 100
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=100.05n

* CHECK dout0_1 Vdout0_1ck9 = 0 time = 100
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=100.05n

* CHECK dout0_2 Vdout0_2ck9 = 1.8 time = 100
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=100.05n

* CHECK dout0_3 Vdout0_3ck9 = 1.8 time = 100
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=100.05n

* CHECK dout0_4 Vdout0_4ck9 = 1.8 time = 100
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=100.05n

* CHECK dout0_5 Vdout0_5ck9 = 1.8 time = 100
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=100.05n

* CHECK dout0_6 Vdout0_6ck9 = 1.8 time = 100
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=100.05n

* CHECK dout0_7 Vdout0_7ck9 = 1.8 time = 100
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=100.05n

* CHECK dout0_8 Vdout0_8ck9 = 1.8 time = 100
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=100.05n

* CHECK dout0_9 Vdout0_9ck9 = 1.8 time = 100
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=100.05n

* CHECK dout0_10 Vdout0_10ck9 = 0 time = 100
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=100.05n

* CHECK dout0_11 Vdout0_11ck9 = 0 time = 100
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=100.05n

* CHECK dout0_12 Vdout0_12ck9 = 0 time = 100
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=100.05n

* CHECK dout0_13 Vdout0_13ck9 = 1.8 time = 100
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=100.05n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 100
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=100.05n

* CHECK dout0_15 Vdout0_15ck9 = 1.8 time = 100
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=100.05n

* CHECK dout0_16 Vdout0_16ck9 = 0 time = 100
.meas tran vdout0_16ck9 FIND v(dout0_16) AT=100.05n

* CHECK dout0_17 Vdout0_17ck9 = 1.8 time = 100
.meas tran vdout0_17ck9 FIND v(dout0_17) AT=100.05n

* CHECK dout0_18 Vdout0_18ck9 = 1.8 time = 100
.meas tran vdout0_18ck9 FIND v(dout0_18) AT=100.05n

* CHECK dout0_19 Vdout0_19ck9 = 1.8 time = 100
.meas tran vdout0_19ck9 FIND v(dout0_19) AT=100.05n

* CHECK dout0_20 Vdout0_20ck9 = 1.8 time = 100
.meas tran vdout0_20ck9 FIND v(dout0_20) AT=100.05n

* CHECK dout0_21 Vdout0_21ck9 = 1.8 time = 100
.meas tran vdout0_21ck9 FIND v(dout0_21) AT=100.05n

* CHECK dout0_22 Vdout0_22ck9 = 1.8 time = 100
.meas tran vdout0_22ck9 FIND v(dout0_22) AT=100.05n

* CHECK dout0_23 Vdout0_23ck9 = 0 time = 100
.meas tran vdout0_23ck9 FIND v(dout0_23) AT=100.05n

* CHECK dout0_24 Vdout0_24ck9 = 1.8 time = 100
.meas tran vdout0_24ck9 FIND v(dout0_24) AT=100.05n

* CHECK dout0_25 Vdout0_25ck9 = 1.8 time = 100
.meas tran vdout0_25ck9 FIND v(dout0_25) AT=100.05n

* CHECK dout0_26 Vdout0_26ck9 = 1.8 time = 100
.meas tran vdout0_26ck9 FIND v(dout0_26) AT=100.05n

* CHECK dout0_27 Vdout0_27ck9 = 0 time = 100
.meas tran vdout0_27ck9 FIND v(dout0_27) AT=100.05n

* CHECK dout0_28 Vdout0_28ck9 = 1.8 time = 100
.meas tran vdout0_28ck9 FIND v(dout0_28) AT=100.05n

* CHECK dout0_29 Vdout0_29ck9 = 0 time = 100
.meas tran vdout0_29ck9 FIND v(dout0_29) AT=100.05n

* CHECK dout0_30 Vdout0_30ck9 = 1.8 time = 100
.meas tran vdout0_30ck9 FIND v(dout0_30) AT=100.05n

* CHECK dout0_31 Vdout0_31ck9 = 0 time = 100
.meas tran vdout0_31ck9 FIND v(dout0_31) AT=100.05n

* CHECK dout0_32 Vdout0_32ck9 = 0 time = 100
.meas tran vdout0_32ck9 FIND v(dout0_32) AT=100.05n

* CHECK dout0_33 Vdout0_33ck9 = 0 time = 100
.meas tran vdout0_33ck9 FIND v(dout0_33) AT=100.05n

* CHECK dout0_34 Vdout0_34ck9 = 1.8 time = 100
.meas tran vdout0_34ck9 FIND v(dout0_34) AT=100.05n

* CHECK dout0_35 Vdout0_35ck9 = 1.8 time = 100
.meas tran vdout0_35ck9 FIND v(dout0_35) AT=100.05n

* CHECK dout0_36 Vdout0_36ck9 = 0 time = 100
.meas tran vdout0_36ck9 FIND v(dout0_36) AT=100.05n

* CHECK dout0_37 Vdout0_37ck9 = 0 time = 100
.meas tran vdout0_37ck9 FIND v(dout0_37) AT=100.05n

* CHECK dout0_38 Vdout0_38ck9 = 1.8 time = 100
.meas tran vdout0_38ck9 FIND v(dout0_38) AT=100.05n

* CHECK dout0_39 Vdout0_39ck9 = 0 time = 100
.meas tran vdout0_39ck9 FIND v(dout0_39) AT=100.05n

* CHECK dout0_40 Vdout0_40ck9 = 1.8 time = 100
.meas tran vdout0_40ck9 FIND v(dout0_40) AT=100.05n

* CHECK dout0_41 Vdout0_41ck9 = 0 time = 100
.meas tran vdout0_41ck9 FIND v(dout0_41) AT=100.05n

* CHECK dout0_42 Vdout0_42ck9 = 1.8 time = 100
.meas tran vdout0_42ck9 FIND v(dout0_42) AT=100.05n

* CHECK dout0_43 Vdout0_43ck9 = 1.8 time = 100
.meas tran vdout0_43ck9 FIND v(dout0_43) AT=100.05n

* CHECK dout0_44 Vdout0_44ck9 = 0 time = 100
.meas tran vdout0_44ck9 FIND v(dout0_44) AT=100.05n

* CHECK dout0_45 Vdout0_45ck9 = 0 time = 100
.meas tran vdout0_45ck9 FIND v(dout0_45) AT=100.05n

* CHECK dout0_46 Vdout0_46ck9 = 0 time = 100
.meas tran vdout0_46ck9 FIND v(dout0_46) AT=100.05n

* CHECK dout0_47 Vdout0_47ck9 = 1.8 time = 100
.meas tran vdout0_47ck9 FIND v(dout0_47) AT=100.05n

* CHECK dout0_48 Vdout0_48ck9 = 1.8 time = 100
.meas tran vdout0_48ck9 FIND v(dout0_48) AT=100.05n

* CHECK dout0_49 Vdout0_49ck9 = 1.8 time = 100
.meas tran vdout0_49ck9 FIND v(dout0_49) AT=100.05n

* CHECK dout0_50 Vdout0_50ck9 = 1.8 time = 100
.meas tran vdout0_50ck9 FIND v(dout0_50) AT=100.05n

* CHECK dout0_51 Vdout0_51ck9 = 0 time = 100
.meas tran vdout0_51ck9 FIND v(dout0_51) AT=100.05n

* CHECK dout0_52 Vdout0_52ck9 = 0 time = 100
.meas tran vdout0_52ck9 FIND v(dout0_52) AT=100.05n

* CHECK dout0_53 Vdout0_53ck9 = 1.8 time = 100
.meas tran vdout0_53ck9 FIND v(dout0_53) AT=100.05n

* CHECK dout0_54 Vdout0_54ck9 = 0 time = 100
.meas tran vdout0_54ck9 FIND v(dout0_54) AT=100.05n

* CHECK dout0_55 Vdout0_55ck9 = 0 time = 100
.meas tran vdout0_55ck9 FIND v(dout0_55) AT=100.05n

* CHECK dout0_56 Vdout0_56ck9 = 1.8 time = 100
.meas tran vdout0_56ck9 FIND v(dout0_56) AT=100.05n

* CHECK dout0_57 Vdout0_57ck9 = 0 time = 100
.meas tran vdout0_57ck9 FIND v(dout0_57) AT=100.05n

* CHECK dout0_58 Vdout0_58ck9 = 0 time = 100
.meas tran vdout0_58ck9 FIND v(dout0_58) AT=100.05n

* CHECK dout0_59 Vdout0_59ck9 = 1.8 time = 100
.meas tran vdout0_59ck9 FIND v(dout0_59) AT=100.05n

* CHECK dout0_60 Vdout0_60ck9 = 1.8 time = 100
.meas tran vdout0_60ck9 FIND v(dout0_60) AT=100.05n

* CHECK dout0_61 Vdout0_61ck9 = 0 time = 100
.meas tran vdout0_61ck9 FIND v(dout0_61) AT=100.05n

* CHECK dout0_62 Vdout0_62ck9 = 0 time = 100
.meas tran vdout0_62ck9 FIND v(dout0_62) AT=100.05n

* CHECK dout0_63 Vdout0_63ck9 = 1.8 time = 100
.meas tran vdout0_63ck9 FIND v(dout0_63) AT=100.05n

* CHECK dout0_64 Vdout0_64ck9 = 0 time = 100
.meas tran vdout0_64ck9 FIND v(dout0_64) AT=100.05n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 110
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=110.05n

* CHECK dout0_1 Vdout0_1ck10 = 0 time = 110
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=110.05n

* CHECK dout0_2 Vdout0_2ck10 = 1.8 time = 110
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=110.05n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 110
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=110.05n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 110
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=110.05n

* CHECK dout0_5 Vdout0_5ck10 = 1.8 time = 110
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=110.05n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 110
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=110.05n

* CHECK dout0_7 Vdout0_7ck10 = 1.8 time = 110
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=110.05n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 110
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=110.05n

* CHECK dout0_9 Vdout0_9ck10 = 0 time = 110
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=110.05n

* CHECK dout0_10 Vdout0_10ck10 = 0 time = 110
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=110.05n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 110
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=110.05n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 110
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=110.05n

* CHECK dout0_13 Vdout0_13ck10 = 1.8 time = 110
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=110.05n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 110
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=110.05n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 110
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=110.05n

* CHECK dout0_16 Vdout0_16ck10 = 1.8 time = 110
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=110.05n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 110
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=110.05n

* CHECK dout0_18 Vdout0_18ck10 = 1.8 time = 110
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=110.05n

* CHECK dout0_19 Vdout0_19ck10 = 1.8 time = 110
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=110.05n

* CHECK dout0_20 Vdout0_20ck10 = 0 time = 110
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=110.05n

* CHECK dout0_21 Vdout0_21ck10 = 0 time = 110
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=110.05n

* CHECK dout0_22 Vdout0_22ck10 = 0 time = 110
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=110.05n

* CHECK dout0_23 Vdout0_23ck10 = 1.8 time = 110
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=110.05n

* CHECK dout0_24 Vdout0_24ck10 = 0 time = 110
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=110.05n

* CHECK dout0_25 Vdout0_25ck10 = 1.8 time = 110
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=110.05n

* CHECK dout0_26 Vdout0_26ck10 = 1.8 time = 110
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=110.05n

* CHECK dout0_27 Vdout0_27ck10 = 1.8 time = 110
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=110.05n

* CHECK dout0_28 Vdout0_28ck10 = 0 time = 110
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=110.05n

* CHECK dout0_29 Vdout0_29ck10 = 0 time = 110
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=110.05n

* CHECK dout0_30 Vdout0_30ck10 = 0 time = 110
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=110.05n

* CHECK dout0_31 Vdout0_31ck10 = 1.8 time = 110
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=110.05n

* CHECK dout0_32 Vdout0_32ck10 = 0 time = 110
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=110.05n

* CHECK dout0_33 Vdout0_33ck10 = 1.8 time = 110
.meas tran vdout0_33ck10 FIND v(dout0_33) AT=110.05n

* CHECK dout0_34 Vdout0_34ck10 = 1.8 time = 110
.meas tran vdout0_34ck10 FIND v(dout0_34) AT=110.05n

* CHECK dout0_35 Vdout0_35ck10 = 1.8 time = 110
.meas tran vdout0_35ck10 FIND v(dout0_35) AT=110.05n

* CHECK dout0_36 Vdout0_36ck10 = 0 time = 110
.meas tran vdout0_36ck10 FIND v(dout0_36) AT=110.05n

* CHECK dout0_37 Vdout0_37ck10 = 1.8 time = 110
.meas tran vdout0_37ck10 FIND v(dout0_37) AT=110.05n

* CHECK dout0_38 Vdout0_38ck10 = 0 time = 110
.meas tran vdout0_38ck10 FIND v(dout0_38) AT=110.05n

* CHECK dout0_39 Vdout0_39ck10 = 0 time = 110
.meas tran vdout0_39ck10 FIND v(dout0_39) AT=110.05n

* CHECK dout0_40 Vdout0_40ck10 = 0 time = 110
.meas tran vdout0_40ck10 FIND v(dout0_40) AT=110.05n

* CHECK dout0_41 Vdout0_41ck10 = 1.8 time = 110
.meas tran vdout0_41ck10 FIND v(dout0_41) AT=110.05n

* CHECK dout0_42 Vdout0_42ck10 = 1.8 time = 110
.meas tran vdout0_42ck10 FIND v(dout0_42) AT=110.05n

* CHECK dout0_43 Vdout0_43ck10 = 0 time = 110
.meas tran vdout0_43ck10 FIND v(dout0_43) AT=110.05n

* CHECK dout0_44 Vdout0_44ck10 = 0 time = 110
.meas tran vdout0_44ck10 FIND v(dout0_44) AT=110.05n

* CHECK dout0_45 Vdout0_45ck10 = 1.8 time = 110
.meas tran vdout0_45ck10 FIND v(dout0_45) AT=110.05n

* CHECK dout0_46 Vdout0_46ck10 = 0 time = 110
.meas tran vdout0_46ck10 FIND v(dout0_46) AT=110.05n

* CHECK dout0_47 Vdout0_47ck10 = 0 time = 110
.meas tran vdout0_47ck10 FIND v(dout0_47) AT=110.05n

* CHECK dout0_48 Vdout0_48ck10 = 0 time = 110
.meas tran vdout0_48ck10 FIND v(dout0_48) AT=110.05n

* CHECK dout0_49 Vdout0_49ck10 = 0 time = 110
.meas tran vdout0_49ck10 FIND v(dout0_49) AT=110.05n

* CHECK dout0_50 Vdout0_50ck10 = 1.8 time = 110
.meas tran vdout0_50ck10 FIND v(dout0_50) AT=110.05n

* CHECK dout0_51 Vdout0_51ck10 = 0 time = 110
.meas tran vdout0_51ck10 FIND v(dout0_51) AT=110.05n

* CHECK dout0_52 Vdout0_52ck10 = 0 time = 110
.meas tran vdout0_52ck10 FIND v(dout0_52) AT=110.05n

* CHECK dout0_53 Vdout0_53ck10 = 1.8 time = 110
.meas tran vdout0_53ck10 FIND v(dout0_53) AT=110.05n

* CHECK dout0_54 Vdout0_54ck10 = 0 time = 110
.meas tran vdout0_54ck10 FIND v(dout0_54) AT=110.05n

* CHECK dout0_55 Vdout0_55ck10 = 0 time = 110
.meas tran vdout0_55ck10 FIND v(dout0_55) AT=110.05n

* CHECK dout0_56 Vdout0_56ck10 = 1.8 time = 110
.meas tran vdout0_56ck10 FIND v(dout0_56) AT=110.05n

* CHECK dout0_57 Vdout0_57ck10 = 0 time = 110
.meas tran vdout0_57ck10 FIND v(dout0_57) AT=110.05n

* CHECK dout0_58 Vdout0_58ck10 = 0 time = 110
.meas tran vdout0_58ck10 FIND v(dout0_58) AT=110.05n

* CHECK dout0_59 Vdout0_59ck10 = 1.8 time = 110
.meas tran vdout0_59ck10 FIND v(dout0_59) AT=110.05n

* CHECK dout0_60 Vdout0_60ck10 = 1.8 time = 110
.meas tran vdout0_60ck10 FIND v(dout0_60) AT=110.05n

* CHECK dout0_61 Vdout0_61ck10 = 1.8 time = 110
.meas tran vdout0_61ck10 FIND v(dout0_61) AT=110.05n

* CHECK dout0_62 Vdout0_62ck10 = 0 time = 110
.meas tran vdout0_62ck10 FIND v(dout0_62) AT=110.05n

* CHECK dout0_63 Vdout0_63ck10 = 0 time = 110
.meas tran vdout0_63ck10 FIND v(dout0_63) AT=110.05n

* CHECK dout0_64 Vdout0_64ck10 = 0 time = 110
.meas tran vdout0_64ck10 FIND v(dout0_64) AT=110.05n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 130
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=130.05n

* CHECK dout0_1 Vdout0_1ck12 = 1.8 time = 130
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=130.05n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 130
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=130.05n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 130
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=130.05n

* CHECK dout0_4 Vdout0_4ck12 = 1.8 time = 130
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=130.05n

* CHECK dout0_5 Vdout0_5ck12 = 1.8 time = 130
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=130.05n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 130
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=130.05n

* CHECK dout0_7 Vdout0_7ck12 = 0 time = 130
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=130.05n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 130
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=130.05n

* CHECK dout0_9 Vdout0_9ck12 = 0 time = 130
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=130.05n

* CHECK dout0_10 Vdout0_10ck12 = 0 time = 130
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=130.05n

* CHECK dout0_11 Vdout0_11ck12 = 1.8 time = 130
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=130.05n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 130
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=130.05n

* CHECK dout0_13 Vdout0_13ck12 = 1.8 time = 130
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=130.05n

* CHECK dout0_14 Vdout0_14ck12 = 1.8 time = 130
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=130.05n

* CHECK dout0_15 Vdout0_15ck12 = 1.8 time = 130
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=130.05n

* CHECK dout0_16 Vdout0_16ck12 = 0 time = 130
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=130.05n

* CHECK dout0_17 Vdout0_17ck12 = 0 time = 130
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=130.05n

* CHECK dout0_18 Vdout0_18ck12 = 1.8 time = 130
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=130.05n

* CHECK dout0_19 Vdout0_19ck12 = 1.8 time = 130
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=130.05n

* CHECK dout0_20 Vdout0_20ck12 = 1.8 time = 130
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=130.05n

* CHECK dout0_21 Vdout0_21ck12 = 0 time = 130
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=130.05n

* CHECK dout0_22 Vdout0_22ck12 = 0 time = 130
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=130.05n

* CHECK dout0_23 Vdout0_23ck12 = 0 time = 130
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=130.05n

* CHECK dout0_24 Vdout0_24ck12 = 1.8 time = 130
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=130.05n

* CHECK dout0_25 Vdout0_25ck12 = 1.8 time = 130
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=130.05n

* CHECK dout0_26 Vdout0_26ck12 = 0 time = 130
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=130.05n

* CHECK dout0_27 Vdout0_27ck12 = 0 time = 130
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=130.05n

* CHECK dout0_28 Vdout0_28ck12 = 1.8 time = 130
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=130.05n

* CHECK dout0_29 Vdout0_29ck12 = 0 time = 130
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=130.05n

* CHECK dout0_30 Vdout0_30ck12 = 0 time = 130
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=130.05n

* CHECK dout0_31 Vdout0_31ck12 = 0 time = 130
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=130.05n

* CHECK dout0_32 Vdout0_32ck12 = 1.8 time = 130
.meas tran vdout0_32ck12 FIND v(dout0_32) AT=130.05n

* CHECK dout0_33 Vdout0_33ck12 = 1.8 time = 130
.meas tran vdout0_33ck12 FIND v(dout0_33) AT=130.05n

* CHECK dout0_34 Vdout0_34ck12 = 1.8 time = 130
.meas tran vdout0_34ck12 FIND v(dout0_34) AT=130.05n

* CHECK dout0_35 Vdout0_35ck12 = 0 time = 130
.meas tran vdout0_35ck12 FIND v(dout0_35) AT=130.05n

* CHECK dout0_36 Vdout0_36ck12 = 1.8 time = 130
.meas tran vdout0_36ck12 FIND v(dout0_36) AT=130.05n

* CHECK dout0_37 Vdout0_37ck12 = 0 time = 130
.meas tran vdout0_37ck12 FIND v(dout0_37) AT=130.05n

* CHECK dout0_38 Vdout0_38ck12 = 1.8 time = 130
.meas tran vdout0_38ck12 FIND v(dout0_38) AT=130.05n

* CHECK dout0_39 Vdout0_39ck12 = 1.8 time = 130
.meas tran vdout0_39ck12 FIND v(dout0_39) AT=130.05n

* CHECK dout0_40 Vdout0_40ck12 = 0 time = 130
.meas tran vdout0_40ck12 FIND v(dout0_40) AT=130.05n

* CHECK dout0_41 Vdout0_41ck12 = 0 time = 130
.meas tran vdout0_41ck12 FIND v(dout0_41) AT=130.05n

* CHECK dout0_42 Vdout0_42ck12 = 1.8 time = 130
.meas tran vdout0_42ck12 FIND v(dout0_42) AT=130.05n

* CHECK dout0_43 Vdout0_43ck12 = 1.8 time = 130
.meas tran vdout0_43ck12 FIND v(dout0_43) AT=130.05n

* CHECK dout0_44 Vdout0_44ck12 = 0 time = 130
.meas tran vdout0_44ck12 FIND v(dout0_44) AT=130.05n

* CHECK dout0_45 Vdout0_45ck12 = 0 time = 130
.meas tran vdout0_45ck12 FIND v(dout0_45) AT=130.05n

* CHECK dout0_46 Vdout0_46ck12 = 1.8 time = 130
.meas tran vdout0_46ck12 FIND v(dout0_46) AT=130.05n

* CHECK dout0_47 Vdout0_47ck12 = 0 time = 130
.meas tran vdout0_47ck12 FIND v(dout0_47) AT=130.05n

* CHECK dout0_48 Vdout0_48ck12 = 0 time = 130
.meas tran vdout0_48ck12 FIND v(dout0_48) AT=130.05n

* CHECK dout0_49 Vdout0_49ck12 = 0 time = 130
.meas tran vdout0_49ck12 FIND v(dout0_49) AT=130.05n

* CHECK dout0_50 Vdout0_50ck12 = 0 time = 130
.meas tran vdout0_50ck12 FIND v(dout0_50) AT=130.05n

* CHECK dout0_51 Vdout0_51ck12 = 0 time = 130
.meas tran vdout0_51ck12 FIND v(dout0_51) AT=130.05n

* CHECK dout0_52 Vdout0_52ck12 = 0 time = 130
.meas tran vdout0_52ck12 FIND v(dout0_52) AT=130.05n

* CHECK dout0_53 Vdout0_53ck12 = 0 time = 130
.meas tran vdout0_53ck12 FIND v(dout0_53) AT=130.05n

* CHECK dout0_54 Vdout0_54ck12 = 1.8 time = 130
.meas tran vdout0_54ck12 FIND v(dout0_54) AT=130.05n

* CHECK dout0_55 Vdout0_55ck12 = 0 time = 130
.meas tran vdout0_55ck12 FIND v(dout0_55) AT=130.05n

* CHECK dout0_56 Vdout0_56ck12 = 0 time = 130
.meas tran vdout0_56ck12 FIND v(dout0_56) AT=130.05n

* CHECK dout0_57 Vdout0_57ck12 = 0 time = 130
.meas tran vdout0_57ck12 FIND v(dout0_57) AT=130.05n

* CHECK dout0_58 Vdout0_58ck12 = 0 time = 130
.meas tran vdout0_58ck12 FIND v(dout0_58) AT=130.05n

* CHECK dout0_59 Vdout0_59ck12 = 0 time = 130
.meas tran vdout0_59ck12 FIND v(dout0_59) AT=130.05n

* CHECK dout0_60 Vdout0_60ck12 = 1.8 time = 130
.meas tran vdout0_60ck12 FIND v(dout0_60) AT=130.05n

* CHECK dout0_61 Vdout0_61ck12 = 1.8 time = 130
.meas tran vdout0_61ck12 FIND v(dout0_61) AT=130.05n

* CHECK dout0_62 Vdout0_62ck12 = 0 time = 130
.meas tran vdout0_62ck12 FIND v(dout0_62) AT=130.05n

* CHECK dout0_63 Vdout0_63ck12 = 1.8 time = 130
.meas tran vdout0_63ck12 FIND v(dout0_63) AT=130.05n

* CHECK dout0_64 Vdout0_64ck12 = 0 time = 130
.meas tran vdout0_64ck12 FIND v(dout0_64) AT=130.05n

* CHECK dout0_0 Vdout0_0ck15 = 0 time = 160
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=160.05n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 160
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=160.05n

* CHECK dout0_2 Vdout0_2ck15 = 1.8 time = 160
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=160.05n

* CHECK dout0_3 Vdout0_3ck15 = 1.8 time = 160
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=160.05n

* CHECK dout0_4 Vdout0_4ck15 = 1.8 time = 160
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=160.05n

* CHECK dout0_5 Vdout0_5ck15 = 1.8 time = 160
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=160.05n

* CHECK dout0_6 Vdout0_6ck15 = 1.8 time = 160
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=160.05n

* CHECK dout0_7 Vdout0_7ck15 = 1.8 time = 160
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=160.05n

* CHECK dout0_8 Vdout0_8ck15 = 1.8 time = 160
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=160.05n

* CHECK dout0_9 Vdout0_9ck15 = 1.8 time = 160
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=160.05n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 160
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=160.05n

* CHECK dout0_11 Vdout0_11ck15 = 0 time = 160
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=160.05n

* CHECK dout0_12 Vdout0_12ck15 = 0 time = 160
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=160.05n

* CHECK dout0_13 Vdout0_13ck15 = 1.8 time = 160
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=160.05n

* CHECK dout0_14 Vdout0_14ck15 = 0 time = 160
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=160.05n

* CHECK dout0_15 Vdout0_15ck15 = 1.8 time = 160
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=160.05n

* CHECK dout0_16 Vdout0_16ck15 = 0 time = 160
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=160.05n

* CHECK dout0_17 Vdout0_17ck15 = 1.8 time = 160
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=160.05n

* CHECK dout0_18 Vdout0_18ck15 = 1.8 time = 160
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=160.05n

* CHECK dout0_19 Vdout0_19ck15 = 1.8 time = 160
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=160.05n

* CHECK dout0_20 Vdout0_20ck15 = 1.8 time = 160
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=160.05n

* CHECK dout0_21 Vdout0_21ck15 = 1.8 time = 160
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=160.05n

* CHECK dout0_22 Vdout0_22ck15 = 1.8 time = 160
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=160.05n

* CHECK dout0_23 Vdout0_23ck15 = 0 time = 160
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=160.05n

* CHECK dout0_24 Vdout0_24ck15 = 1.8 time = 160
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=160.05n

* CHECK dout0_25 Vdout0_25ck15 = 1.8 time = 160
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=160.05n

* CHECK dout0_26 Vdout0_26ck15 = 1.8 time = 160
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=160.05n

* CHECK dout0_27 Vdout0_27ck15 = 0 time = 160
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=160.05n

* CHECK dout0_28 Vdout0_28ck15 = 1.8 time = 160
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=160.05n

* CHECK dout0_29 Vdout0_29ck15 = 0 time = 160
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=160.05n

* CHECK dout0_30 Vdout0_30ck15 = 1.8 time = 160
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=160.05n

* CHECK dout0_31 Vdout0_31ck15 = 0 time = 160
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=160.05n

* CHECK dout0_32 Vdout0_32ck15 = 0 time = 160
.meas tran vdout0_32ck15 FIND v(dout0_32) AT=160.05n

* CHECK dout0_33 Vdout0_33ck15 = 0 time = 160
.meas tran vdout0_33ck15 FIND v(dout0_33) AT=160.05n

* CHECK dout0_34 Vdout0_34ck15 = 1.8 time = 160
.meas tran vdout0_34ck15 FIND v(dout0_34) AT=160.05n

* CHECK dout0_35 Vdout0_35ck15 = 1.8 time = 160
.meas tran vdout0_35ck15 FIND v(dout0_35) AT=160.05n

* CHECK dout0_36 Vdout0_36ck15 = 0 time = 160
.meas tran vdout0_36ck15 FIND v(dout0_36) AT=160.05n

* CHECK dout0_37 Vdout0_37ck15 = 0 time = 160
.meas tran vdout0_37ck15 FIND v(dout0_37) AT=160.05n

* CHECK dout0_38 Vdout0_38ck15 = 1.8 time = 160
.meas tran vdout0_38ck15 FIND v(dout0_38) AT=160.05n

* CHECK dout0_39 Vdout0_39ck15 = 0 time = 160
.meas tran vdout0_39ck15 FIND v(dout0_39) AT=160.05n

* CHECK dout0_40 Vdout0_40ck15 = 1.8 time = 160
.meas tran vdout0_40ck15 FIND v(dout0_40) AT=160.05n

* CHECK dout0_41 Vdout0_41ck15 = 0 time = 160
.meas tran vdout0_41ck15 FIND v(dout0_41) AT=160.05n

* CHECK dout0_42 Vdout0_42ck15 = 1.8 time = 160
.meas tran vdout0_42ck15 FIND v(dout0_42) AT=160.05n

* CHECK dout0_43 Vdout0_43ck15 = 1.8 time = 160
.meas tran vdout0_43ck15 FIND v(dout0_43) AT=160.05n

* CHECK dout0_44 Vdout0_44ck15 = 0 time = 160
.meas tran vdout0_44ck15 FIND v(dout0_44) AT=160.05n

* CHECK dout0_45 Vdout0_45ck15 = 0 time = 160
.meas tran vdout0_45ck15 FIND v(dout0_45) AT=160.05n

* CHECK dout0_46 Vdout0_46ck15 = 0 time = 160
.meas tran vdout0_46ck15 FIND v(dout0_46) AT=160.05n

* CHECK dout0_47 Vdout0_47ck15 = 1.8 time = 160
.meas tran vdout0_47ck15 FIND v(dout0_47) AT=160.05n

* CHECK dout0_48 Vdout0_48ck15 = 1.8 time = 160
.meas tran vdout0_48ck15 FIND v(dout0_48) AT=160.05n

* CHECK dout0_49 Vdout0_49ck15 = 1.8 time = 160
.meas tran vdout0_49ck15 FIND v(dout0_49) AT=160.05n

* CHECK dout0_50 Vdout0_50ck15 = 1.8 time = 160
.meas tran vdout0_50ck15 FIND v(dout0_50) AT=160.05n

* CHECK dout0_51 Vdout0_51ck15 = 0 time = 160
.meas tran vdout0_51ck15 FIND v(dout0_51) AT=160.05n

* CHECK dout0_52 Vdout0_52ck15 = 0 time = 160
.meas tran vdout0_52ck15 FIND v(dout0_52) AT=160.05n

* CHECK dout0_53 Vdout0_53ck15 = 1.8 time = 160
.meas tran vdout0_53ck15 FIND v(dout0_53) AT=160.05n

* CHECK dout0_54 Vdout0_54ck15 = 0 time = 160
.meas tran vdout0_54ck15 FIND v(dout0_54) AT=160.05n

* CHECK dout0_55 Vdout0_55ck15 = 0 time = 160
.meas tran vdout0_55ck15 FIND v(dout0_55) AT=160.05n

* CHECK dout0_56 Vdout0_56ck15 = 1.8 time = 160
.meas tran vdout0_56ck15 FIND v(dout0_56) AT=160.05n

* CHECK dout0_57 Vdout0_57ck15 = 0 time = 160
.meas tran vdout0_57ck15 FIND v(dout0_57) AT=160.05n

* CHECK dout0_58 Vdout0_58ck15 = 0 time = 160
.meas tran vdout0_58ck15 FIND v(dout0_58) AT=160.05n

* CHECK dout0_59 Vdout0_59ck15 = 1.8 time = 160
.meas tran vdout0_59ck15 FIND v(dout0_59) AT=160.05n

* CHECK dout0_60 Vdout0_60ck15 = 1.8 time = 160
.meas tran vdout0_60ck15 FIND v(dout0_60) AT=160.05n

* CHECK dout0_61 Vdout0_61ck15 = 0 time = 160
.meas tran vdout0_61ck15 FIND v(dout0_61) AT=160.05n

* CHECK dout0_62 Vdout0_62ck15 = 0 time = 160
.meas tran vdout0_62ck15 FIND v(dout0_62) AT=160.05n

* CHECK dout0_63 Vdout0_63ck15 = 1.8 time = 160
.meas tran vdout0_63ck15 FIND v(dout0_63) AT=160.05n

* CHECK dout0_64 Vdout0_64ck15 = 0 time = 160
.meas tran vdout0_64ck15 FIND v(dout0_64) AT=160.05n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 180
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=180.05n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 180
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=180.05n

* CHECK dout0_2 Vdout0_2ck17 = 1.8 time = 180
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=180.05n

* CHECK dout0_3 Vdout0_3ck17 = 1.8 time = 180
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=180.05n

* CHECK dout0_4 Vdout0_4ck17 = 1.8 time = 180
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=180.05n

* CHECK dout0_5 Vdout0_5ck17 = 1.8 time = 180
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=180.05n

* CHECK dout0_6 Vdout0_6ck17 = 1.8 time = 180
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=180.05n

* CHECK dout0_7 Vdout0_7ck17 = 1.8 time = 180
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=180.05n

* CHECK dout0_8 Vdout0_8ck17 = 1.8 time = 180
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=180.05n

* CHECK dout0_9 Vdout0_9ck17 = 1.8 time = 180
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=180.05n

* CHECK dout0_10 Vdout0_10ck17 = 0 time = 180
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=180.05n

* CHECK dout0_11 Vdout0_11ck17 = 0 time = 180
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=180.05n

* CHECK dout0_12 Vdout0_12ck17 = 0 time = 180
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=180.05n

* CHECK dout0_13 Vdout0_13ck17 = 1.8 time = 180
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=180.05n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 180
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=180.05n

* CHECK dout0_15 Vdout0_15ck17 = 1.8 time = 180
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=180.05n

* CHECK dout0_16 Vdout0_16ck17 = 0 time = 180
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=180.05n

* CHECK dout0_17 Vdout0_17ck17 = 1.8 time = 180
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=180.05n

* CHECK dout0_18 Vdout0_18ck17 = 1.8 time = 180
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=180.05n

* CHECK dout0_19 Vdout0_19ck17 = 1.8 time = 180
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=180.05n

* CHECK dout0_20 Vdout0_20ck17 = 1.8 time = 180
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=180.05n

* CHECK dout0_21 Vdout0_21ck17 = 1.8 time = 180
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=180.05n

* CHECK dout0_22 Vdout0_22ck17 = 1.8 time = 180
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=180.05n

* CHECK dout0_23 Vdout0_23ck17 = 0 time = 180
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=180.05n

* CHECK dout0_24 Vdout0_24ck17 = 1.8 time = 180
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=180.05n

* CHECK dout0_25 Vdout0_25ck17 = 1.8 time = 180
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=180.05n

* CHECK dout0_26 Vdout0_26ck17 = 1.8 time = 180
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=180.05n

* CHECK dout0_27 Vdout0_27ck17 = 0 time = 180
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=180.05n

* CHECK dout0_28 Vdout0_28ck17 = 1.8 time = 180
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=180.05n

* CHECK dout0_29 Vdout0_29ck17 = 0 time = 180
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=180.05n

* CHECK dout0_30 Vdout0_30ck17 = 1.8 time = 180
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=180.05n

* CHECK dout0_31 Vdout0_31ck17 = 0 time = 180
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=180.05n

* CHECK dout0_32 Vdout0_32ck17 = 0 time = 180
.meas tran vdout0_32ck17 FIND v(dout0_32) AT=180.05n

* CHECK dout0_33 Vdout0_33ck17 = 0 time = 180
.meas tran vdout0_33ck17 FIND v(dout0_33) AT=180.05n

* CHECK dout0_34 Vdout0_34ck17 = 1.8 time = 180
.meas tran vdout0_34ck17 FIND v(dout0_34) AT=180.05n

* CHECK dout0_35 Vdout0_35ck17 = 1.8 time = 180
.meas tran vdout0_35ck17 FIND v(dout0_35) AT=180.05n

* CHECK dout0_36 Vdout0_36ck17 = 0 time = 180
.meas tran vdout0_36ck17 FIND v(dout0_36) AT=180.05n

* CHECK dout0_37 Vdout0_37ck17 = 0 time = 180
.meas tran vdout0_37ck17 FIND v(dout0_37) AT=180.05n

* CHECK dout0_38 Vdout0_38ck17 = 1.8 time = 180
.meas tran vdout0_38ck17 FIND v(dout0_38) AT=180.05n

* CHECK dout0_39 Vdout0_39ck17 = 0 time = 180
.meas tran vdout0_39ck17 FIND v(dout0_39) AT=180.05n

* CHECK dout0_40 Vdout0_40ck17 = 1.8 time = 180
.meas tran vdout0_40ck17 FIND v(dout0_40) AT=180.05n

* CHECK dout0_41 Vdout0_41ck17 = 0 time = 180
.meas tran vdout0_41ck17 FIND v(dout0_41) AT=180.05n

* CHECK dout0_42 Vdout0_42ck17 = 1.8 time = 180
.meas tran vdout0_42ck17 FIND v(dout0_42) AT=180.05n

* CHECK dout0_43 Vdout0_43ck17 = 1.8 time = 180
.meas tran vdout0_43ck17 FIND v(dout0_43) AT=180.05n

* CHECK dout0_44 Vdout0_44ck17 = 0 time = 180
.meas tran vdout0_44ck17 FIND v(dout0_44) AT=180.05n

* CHECK dout0_45 Vdout0_45ck17 = 0 time = 180
.meas tran vdout0_45ck17 FIND v(dout0_45) AT=180.05n

* CHECK dout0_46 Vdout0_46ck17 = 0 time = 180
.meas tran vdout0_46ck17 FIND v(dout0_46) AT=180.05n

* CHECK dout0_47 Vdout0_47ck17 = 1.8 time = 180
.meas tran vdout0_47ck17 FIND v(dout0_47) AT=180.05n

* CHECK dout0_48 Vdout0_48ck17 = 1.8 time = 180
.meas tran vdout0_48ck17 FIND v(dout0_48) AT=180.05n

* CHECK dout0_49 Vdout0_49ck17 = 1.8 time = 180
.meas tran vdout0_49ck17 FIND v(dout0_49) AT=180.05n

* CHECK dout0_50 Vdout0_50ck17 = 1.8 time = 180
.meas tran vdout0_50ck17 FIND v(dout0_50) AT=180.05n

* CHECK dout0_51 Vdout0_51ck17 = 0 time = 180
.meas tran vdout0_51ck17 FIND v(dout0_51) AT=180.05n

* CHECK dout0_52 Vdout0_52ck17 = 0 time = 180
.meas tran vdout0_52ck17 FIND v(dout0_52) AT=180.05n

* CHECK dout0_53 Vdout0_53ck17 = 1.8 time = 180
.meas tran vdout0_53ck17 FIND v(dout0_53) AT=180.05n

* CHECK dout0_54 Vdout0_54ck17 = 0 time = 180
.meas tran vdout0_54ck17 FIND v(dout0_54) AT=180.05n

* CHECK dout0_55 Vdout0_55ck17 = 0 time = 180
.meas tran vdout0_55ck17 FIND v(dout0_55) AT=180.05n

* CHECK dout0_56 Vdout0_56ck17 = 1.8 time = 180
.meas tran vdout0_56ck17 FIND v(dout0_56) AT=180.05n

* CHECK dout0_57 Vdout0_57ck17 = 0 time = 180
.meas tran vdout0_57ck17 FIND v(dout0_57) AT=180.05n

* CHECK dout0_58 Vdout0_58ck17 = 0 time = 180
.meas tran vdout0_58ck17 FIND v(dout0_58) AT=180.05n

* CHECK dout0_59 Vdout0_59ck17 = 1.8 time = 180
.meas tran vdout0_59ck17 FIND v(dout0_59) AT=180.05n

* CHECK dout0_60 Vdout0_60ck17 = 1.8 time = 180
.meas tran vdout0_60ck17 FIND v(dout0_60) AT=180.05n

* CHECK dout0_61 Vdout0_61ck17 = 0 time = 180
.meas tran vdout0_61ck17 FIND v(dout0_61) AT=180.05n

* CHECK dout0_62 Vdout0_62ck17 = 0 time = 180
.meas tran vdout0_62ck17 FIND v(dout0_62) AT=180.05n

* CHECK dout0_63 Vdout0_63ck17 = 1.8 time = 180
.meas tran vdout0_63ck17 FIND v(dout0_63) AT=180.05n

* CHECK dout0_64 Vdout0_64ck17 = 0 time = 180
.meas tran vdout0_64ck17 FIND v(dout0_64) AT=180.05n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 200
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=200.05n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 200
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=200.05n

* CHECK dout0_2 Vdout0_2ck19 = 1.8 time = 200
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=200.05n

* CHECK dout0_3 Vdout0_3ck19 = 0 time = 200
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=200.05n

* CHECK dout0_4 Vdout0_4ck19 = 0 time = 200
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=200.05n

* CHECK dout0_5 Vdout0_5ck19 = 1.8 time = 200
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=200.05n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 200
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=200.05n

* CHECK dout0_7 Vdout0_7ck19 = 1.8 time = 200
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=200.05n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 200
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=200.05n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 200
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=200.05n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 200
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=200.05n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 200
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=200.05n

* CHECK dout0_12 Vdout0_12ck19 = 1.8 time = 200
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=200.05n

* CHECK dout0_13 Vdout0_13ck19 = 1.8 time = 200
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=200.05n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 200
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=200.05n

* CHECK dout0_15 Vdout0_15ck19 = 0 time = 200
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=200.05n

* CHECK dout0_16 Vdout0_16ck19 = 1.8 time = 200
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=200.05n

* CHECK dout0_17 Vdout0_17ck19 = 0 time = 200
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=200.05n

* CHECK dout0_18 Vdout0_18ck19 = 1.8 time = 200
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=200.05n

* CHECK dout0_19 Vdout0_19ck19 = 1.8 time = 200
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=200.05n

* CHECK dout0_20 Vdout0_20ck19 = 0 time = 200
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=200.05n

* CHECK dout0_21 Vdout0_21ck19 = 0 time = 200
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=200.05n

* CHECK dout0_22 Vdout0_22ck19 = 0 time = 200
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=200.05n

* CHECK dout0_23 Vdout0_23ck19 = 1.8 time = 200
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=200.05n

* CHECK dout0_24 Vdout0_24ck19 = 0 time = 200
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=200.05n

* CHECK dout0_25 Vdout0_25ck19 = 1.8 time = 200
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=200.05n

* CHECK dout0_26 Vdout0_26ck19 = 1.8 time = 200
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=200.05n

* CHECK dout0_27 Vdout0_27ck19 = 1.8 time = 200
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=200.05n

* CHECK dout0_28 Vdout0_28ck19 = 0 time = 200
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=200.05n

* CHECK dout0_29 Vdout0_29ck19 = 0 time = 200
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=200.05n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 200
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=200.05n

* CHECK dout0_31 Vdout0_31ck19 = 1.8 time = 200
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=200.05n

* CHECK dout0_32 Vdout0_32ck19 = 0 time = 200
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=200.05n

* CHECK dout0_33 Vdout0_33ck19 = 1.8 time = 200
.meas tran vdout0_33ck19 FIND v(dout0_33) AT=200.05n

* CHECK dout0_34 Vdout0_34ck19 = 1.8 time = 200
.meas tran vdout0_34ck19 FIND v(dout0_34) AT=200.05n

* CHECK dout0_35 Vdout0_35ck19 = 1.8 time = 200
.meas tran vdout0_35ck19 FIND v(dout0_35) AT=200.05n

* CHECK dout0_36 Vdout0_36ck19 = 0 time = 200
.meas tran vdout0_36ck19 FIND v(dout0_36) AT=200.05n

* CHECK dout0_37 Vdout0_37ck19 = 1.8 time = 200
.meas tran vdout0_37ck19 FIND v(dout0_37) AT=200.05n

* CHECK dout0_38 Vdout0_38ck19 = 0 time = 200
.meas tran vdout0_38ck19 FIND v(dout0_38) AT=200.05n

* CHECK dout0_39 Vdout0_39ck19 = 0 time = 200
.meas tran vdout0_39ck19 FIND v(dout0_39) AT=200.05n

* CHECK dout0_40 Vdout0_40ck19 = 0 time = 200
.meas tran vdout0_40ck19 FIND v(dout0_40) AT=200.05n

* CHECK dout0_41 Vdout0_41ck19 = 1.8 time = 200
.meas tran vdout0_41ck19 FIND v(dout0_41) AT=200.05n

* CHECK dout0_42 Vdout0_42ck19 = 1.8 time = 200
.meas tran vdout0_42ck19 FIND v(dout0_42) AT=200.05n

* CHECK dout0_43 Vdout0_43ck19 = 0 time = 200
.meas tran vdout0_43ck19 FIND v(dout0_43) AT=200.05n

* CHECK dout0_44 Vdout0_44ck19 = 0 time = 200
.meas tran vdout0_44ck19 FIND v(dout0_44) AT=200.05n

* CHECK dout0_45 Vdout0_45ck19 = 1.8 time = 200
.meas tran vdout0_45ck19 FIND v(dout0_45) AT=200.05n

* CHECK dout0_46 Vdout0_46ck19 = 0 time = 200
.meas tran vdout0_46ck19 FIND v(dout0_46) AT=200.05n

* CHECK dout0_47 Vdout0_47ck19 = 0 time = 200
.meas tran vdout0_47ck19 FIND v(dout0_47) AT=200.05n

* CHECK dout0_48 Vdout0_48ck19 = 0 time = 200
.meas tran vdout0_48ck19 FIND v(dout0_48) AT=200.05n

* CHECK dout0_49 Vdout0_49ck19 = 0 time = 200
.meas tran vdout0_49ck19 FIND v(dout0_49) AT=200.05n

* CHECK dout0_50 Vdout0_50ck19 = 1.8 time = 200
.meas tran vdout0_50ck19 FIND v(dout0_50) AT=200.05n

* CHECK dout0_51 Vdout0_51ck19 = 0 time = 200
.meas tran vdout0_51ck19 FIND v(dout0_51) AT=200.05n

* CHECK dout0_52 Vdout0_52ck19 = 0 time = 200
.meas tran vdout0_52ck19 FIND v(dout0_52) AT=200.05n

* CHECK dout0_53 Vdout0_53ck19 = 1.8 time = 200
.meas tran vdout0_53ck19 FIND v(dout0_53) AT=200.05n

* CHECK dout0_54 Vdout0_54ck19 = 0 time = 200
.meas tran vdout0_54ck19 FIND v(dout0_54) AT=200.05n

* CHECK dout0_55 Vdout0_55ck19 = 0 time = 200
.meas tran vdout0_55ck19 FIND v(dout0_55) AT=200.05n

* CHECK dout0_56 Vdout0_56ck19 = 1.8 time = 200
.meas tran vdout0_56ck19 FIND v(dout0_56) AT=200.05n

* CHECK dout0_57 Vdout0_57ck19 = 0 time = 200
.meas tran vdout0_57ck19 FIND v(dout0_57) AT=200.05n

* CHECK dout0_58 Vdout0_58ck19 = 0 time = 200
.meas tran vdout0_58ck19 FIND v(dout0_58) AT=200.05n

* CHECK dout0_59 Vdout0_59ck19 = 1.8 time = 200
.meas tran vdout0_59ck19 FIND v(dout0_59) AT=200.05n

* CHECK dout0_60 Vdout0_60ck19 = 1.8 time = 200
.meas tran vdout0_60ck19 FIND v(dout0_60) AT=200.05n

* CHECK dout0_61 Vdout0_61ck19 = 1.8 time = 200
.meas tran vdout0_61ck19 FIND v(dout0_61) AT=200.05n

* CHECK dout0_62 Vdout0_62ck19 = 0 time = 200
.meas tran vdout0_62ck19 FIND v(dout0_62) AT=200.05n

* CHECK dout0_63 Vdout0_63ck19 = 0 time = 200
.meas tran vdout0_63ck19 FIND v(dout0_63) AT=200.05n

* CHECK dout0_64 Vdout0_64ck19 = 0 time = 200
.meas tran vdout0_64ck19 FIND v(dout0_64) AT=200.05n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 210
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=210.05n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 210
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=210.05n

* CHECK dout0_2 Vdout0_2ck20 = 1.8 time = 210
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=210.05n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 210
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=210.05n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 210
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=210.05n

* CHECK dout0_5 Vdout0_5ck20 = 1.8 time = 210
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=210.05n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 210
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=210.05n

* CHECK dout0_7 Vdout0_7ck20 = 1.8 time = 210
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=210.05n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 210
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=210.05n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 210
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=210.05n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 210
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=210.05n

* CHECK dout0_11 Vdout0_11ck20 = 0 time = 210
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=210.05n

* CHECK dout0_12 Vdout0_12ck20 = 1.8 time = 210
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=210.05n

* CHECK dout0_13 Vdout0_13ck20 = 1.8 time = 210
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=210.05n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 210
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=210.05n

* CHECK dout0_15 Vdout0_15ck20 = 0 time = 210
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=210.05n

* CHECK dout0_16 Vdout0_16ck20 = 1.8 time = 210
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=210.05n

* CHECK dout0_17 Vdout0_17ck20 = 0 time = 210
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=210.05n

* CHECK dout0_18 Vdout0_18ck20 = 1.8 time = 210
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=210.05n

* CHECK dout0_19 Vdout0_19ck20 = 1.8 time = 210
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=210.05n

* CHECK dout0_20 Vdout0_20ck20 = 0 time = 210
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=210.05n

* CHECK dout0_21 Vdout0_21ck20 = 0 time = 210
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=210.05n

* CHECK dout0_22 Vdout0_22ck20 = 0 time = 210
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=210.05n

* CHECK dout0_23 Vdout0_23ck20 = 1.8 time = 210
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=210.05n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 210
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=210.05n

* CHECK dout0_25 Vdout0_25ck20 = 1.8 time = 210
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=210.05n

* CHECK dout0_26 Vdout0_26ck20 = 1.8 time = 210
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=210.05n

* CHECK dout0_27 Vdout0_27ck20 = 1.8 time = 210
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=210.05n

* CHECK dout0_28 Vdout0_28ck20 = 0 time = 210
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=210.05n

* CHECK dout0_29 Vdout0_29ck20 = 0 time = 210
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=210.05n

* CHECK dout0_30 Vdout0_30ck20 = 0 time = 210
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=210.05n

* CHECK dout0_31 Vdout0_31ck20 = 1.8 time = 210
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=210.05n

* CHECK dout0_32 Vdout0_32ck20 = 0 time = 210
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=210.05n

* CHECK dout0_33 Vdout0_33ck20 = 1.8 time = 210
.meas tran vdout0_33ck20 FIND v(dout0_33) AT=210.05n

* CHECK dout0_34 Vdout0_34ck20 = 1.8 time = 210
.meas tran vdout0_34ck20 FIND v(dout0_34) AT=210.05n

* CHECK dout0_35 Vdout0_35ck20 = 1.8 time = 210
.meas tran vdout0_35ck20 FIND v(dout0_35) AT=210.05n

* CHECK dout0_36 Vdout0_36ck20 = 0 time = 210
.meas tran vdout0_36ck20 FIND v(dout0_36) AT=210.05n

* CHECK dout0_37 Vdout0_37ck20 = 1.8 time = 210
.meas tran vdout0_37ck20 FIND v(dout0_37) AT=210.05n

* CHECK dout0_38 Vdout0_38ck20 = 0 time = 210
.meas tran vdout0_38ck20 FIND v(dout0_38) AT=210.05n

* CHECK dout0_39 Vdout0_39ck20 = 0 time = 210
.meas tran vdout0_39ck20 FIND v(dout0_39) AT=210.05n

* CHECK dout0_40 Vdout0_40ck20 = 0 time = 210
.meas tran vdout0_40ck20 FIND v(dout0_40) AT=210.05n

* CHECK dout0_41 Vdout0_41ck20 = 1.8 time = 210
.meas tran vdout0_41ck20 FIND v(dout0_41) AT=210.05n

* CHECK dout0_42 Vdout0_42ck20 = 1.8 time = 210
.meas tran vdout0_42ck20 FIND v(dout0_42) AT=210.05n

* CHECK dout0_43 Vdout0_43ck20 = 0 time = 210
.meas tran vdout0_43ck20 FIND v(dout0_43) AT=210.05n

* CHECK dout0_44 Vdout0_44ck20 = 0 time = 210
.meas tran vdout0_44ck20 FIND v(dout0_44) AT=210.05n

* CHECK dout0_45 Vdout0_45ck20 = 1.8 time = 210
.meas tran vdout0_45ck20 FIND v(dout0_45) AT=210.05n

* CHECK dout0_46 Vdout0_46ck20 = 0 time = 210
.meas tran vdout0_46ck20 FIND v(dout0_46) AT=210.05n

* CHECK dout0_47 Vdout0_47ck20 = 0 time = 210
.meas tran vdout0_47ck20 FIND v(dout0_47) AT=210.05n

* CHECK dout0_48 Vdout0_48ck20 = 0 time = 210
.meas tran vdout0_48ck20 FIND v(dout0_48) AT=210.05n

* CHECK dout0_49 Vdout0_49ck20 = 0 time = 210
.meas tran vdout0_49ck20 FIND v(dout0_49) AT=210.05n

* CHECK dout0_50 Vdout0_50ck20 = 1.8 time = 210
.meas tran vdout0_50ck20 FIND v(dout0_50) AT=210.05n

* CHECK dout0_51 Vdout0_51ck20 = 0 time = 210
.meas tran vdout0_51ck20 FIND v(dout0_51) AT=210.05n

* CHECK dout0_52 Vdout0_52ck20 = 0 time = 210
.meas tran vdout0_52ck20 FIND v(dout0_52) AT=210.05n

* CHECK dout0_53 Vdout0_53ck20 = 1.8 time = 210
.meas tran vdout0_53ck20 FIND v(dout0_53) AT=210.05n

* CHECK dout0_54 Vdout0_54ck20 = 0 time = 210
.meas tran vdout0_54ck20 FIND v(dout0_54) AT=210.05n

* CHECK dout0_55 Vdout0_55ck20 = 0 time = 210
.meas tran vdout0_55ck20 FIND v(dout0_55) AT=210.05n

* CHECK dout0_56 Vdout0_56ck20 = 1.8 time = 210
.meas tran vdout0_56ck20 FIND v(dout0_56) AT=210.05n

* CHECK dout0_57 Vdout0_57ck20 = 0 time = 210
.meas tran vdout0_57ck20 FIND v(dout0_57) AT=210.05n

* CHECK dout0_58 Vdout0_58ck20 = 0 time = 210
.meas tran vdout0_58ck20 FIND v(dout0_58) AT=210.05n

* CHECK dout0_59 Vdout0_59ck20 = 1.8 time = 210
.meas tran vdout0_59ck20 FIND v(dout0_59) AT=210.05n

* CHECK dout0_60 Vdout0_60ck20 = 1.8 time = 210
.meas tran vdout0_60ck20 FIND v(dout0_60) AT=210.05n

* CHECK dout0_61 Vdout0_61ck20 = 1.8 time = 210
.meas tran vdout0_61ck20 FIND v(dout0_61) AT=210.05n

* CHECK dout0_62 Vdout0_62ck20 = 0 time = 210
.meas tran vdout0_62ck20 FIND v(dout0_62) AT=210.05n

* CHECK dout0_63 Vdout0_63ck20 = 0 time = 210
.meas tran vdout0_63ck20 FIND v(dout0_63) AT=210.05n

* CHECK dout0_64 Vdout0_64ck20 = 0 time = 210
.meas tran vdout0_64ck20 FIND v(dout0_64) AT=210.05n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 230
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=230.05n

* CHECK dout0_1 Vdout0_1ck22 = 0 time = 230
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=230.05n

* CHECK dout0_2 Vdout0_2ck22 = 1.8 time = 230
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=230.05n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 230
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=230.05n

* CHECK dout0_4 Vdout0_4ck22 = 0 time = 230
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=230.05n

* CHECK dout0_5 Vdout0_5ck22 = 1.8 time = 230
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=230.05n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 230
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=230.05n

* CHECK dout0_7 Vdout0_7ck22 = 1.8 time = 230
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=230.05n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 230
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=230.05n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 230
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=230.05n

* CHECK dout0_10 Vdout0_10ck22 = 0 time = 230
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=230.05n

* CHECK dout0_11 Vdout0_11ck22 = 0 time = 230
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=230.05n

* CHECK dout0_12 Vdout0_12ck22 = 1.8 time = 230
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=230.05n

* CHECK dout0_13 Vdout0_13ck22 = 1.8 time = 230
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=230.05n

* CHECK dout0_14 Vdout0_14ck22 = 0 time = 230
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=230.05n

* CHECK dout0_15 Vdout0_15ck22 = 0 time = 230
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=230.05n

* CHECK dout0_16 Vdout0_16ck22 = 1.8 time = 230
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=230.05n

* CHECK dout0_17 Vdout0_17ck22 = 0 time = 230
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=230.05n

* CHECK dout0_18 Vdout0_18ck22 = 1.8 time = 230
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=230.05n

* CHECK dout0_19 Vdout0_19ck22 = 1.8 time = 230
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=230.05n

* CHECK dout0_20 Vdout0_20ck22 = 0 time = 230
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=230.05n

* CHECK dout0_21 Vdout0_21ck22 = 0 time = 230
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=230.05n

* CHECK dout0_22 Vdout0_22ck22 = 0 time = 230
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=230.05n

* CHECK dout0_23 Vdout0_23ck22 = 1.8 time = 230
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=230.05n

* CHECK dout0_24 Vdout0_24ck22 = 0 time = 230
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=230.05n

* CHECK dout0_25 Vdout0_25ck22 = 1.8 time = 230
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=230.05n

* CHECK dout0_26 Vdout0_26ck22 = 1.8 time = 230
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=230.05n

* CHECK dout0_27 Vdout0_27ck22 = 1.8 time = 230
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=230.05n

* CHECK dout0_28 Vdout0_28ck22 = 0 time = 230
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=230.05n

* CHECK dout0_29 Vdout0_29ck22 = 0 time = 230
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=230.05n

* CHECK dout0_30 Vdout0_30ck22 = 0 time = 230
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=230.05n

* CHECK dout0_31 Vdout0_31ck22 = 1.8 time = 230
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=230.05n

* CHECK dout0_32 Vdout0_32ck22 = 0 time = 230
.meas tran vdout0_32ck22 FIND v(dout0_32) AT=230.05n

* CHECK dout0_33 Vdout0_33ck22 = 1.8 time = 230
.meas tran vdout0_33ck22 FIND v(dout0_33) AT=230.05n

* CHECK dout0_34 Vdout0_34ck22 = 1.8 time = 230
.meas tran vdout0_34ck22 FIND v(dout0_34) AT=230.05n

* CHECK dout0_35 Vdout0_35ck22 = 1.8 time = 230
.meas tran vdout0_35ck22 FIND v(dout0_35) AT=230.05n

* CHECK dout0_36 Vdout0_36ck22 = 0 time = 230
.meas tran vdout0_36ck22 FIND v(dout0_36) AT=230.05n

* CHECK dout0_37 Vdout0_37ck22 = 1.8 time = 230
.meas tran vdout0_37ck22 FIND v(dout0_37) AT=230.05n

* CHECK dout0_38 Vdout0_38ck22 = 0 time = 230
.meas tran vdout0_38ck22 FIND v(dout0_38) AT=230.05n

* CHECK dout0_39 Vdout0_39ck22 = 0 time = 230
.meas tran vdout0_39ck22 FIND v(dout0_39) AT=230.05n

* CHECK dout0_40 Vdout0_40ck22 = 0 time = 230
.meas tran vdout0_40ck22 FIND v(dout0_40) AT=230.05n

* CHECK dout0_41 Vdout0_41ck22 = 1.8 time = 230
.meas tran vdout0_41ck22 FIND v(dout0_41) AT=230.05n

* CHECK dout0_42 Vdout0_42ck22 = 1.8 time = 230
.meas tran vdout0_42ck22 FIND v(dout0_42) AT=230.05n

* CHECK dout0_43 Vdout0_43ck22 = 0 time = 230
.meas tran vdout0_43ck22 FIND v(dout0_43) AT=230.05n

* CHECK dout0_44 Vdout0_44ck22 = 0 time = 230
.meas tran vdout0_44ck22 FIND v(dout0_44) AT=230.05n

* CHECK dout0_45 Vdout0_45ck22 = 1.8 time = 230
.meas tran vdout0_45ck22 FIND v(dout0_45) AT=230.05n

* CHECK dout0_46 Vdout0_46ck22 = 0 time = 230
.meas tran vdout0_46ck22 FIND v(dout0_46) AT=230.05n

* CHECK dout0_47 Vdout0_47ck22 = 0 time = 230
.meas tran vdout0_47ck22 FIND v(dout0_47) AT=230.05n

* CHECK dout0_48 Vdout0_48ck22 = 0 time = 230
.meas tran vdout0_48ck22 FIND v(dout0_48) AT=230.05n

* CHECK dout0_49 Vdout0_49ck22 = 0 time = 230
.meas tran vdout0_49ck22 FIND v(dout0_49) AT=230.05n

* CHECK dout0_50 Vdout0_50ck22 = 1.8 time = 230
.meas tran vdout0_50ck22 FIND v(dout0_50) AT=230.05n

* CHECK dout0_51 Vdout0_51ck22 = 0 time = 230
.meas tran vdout0_51ck22 FIND v(dout0_51) AT=230.05n

* CHECK dout0_52 Vdout0_52ck22 = 0 time = 230
.meas tran vdout0_52ck22 FIND v(dout0_52) AT=230.05n

* CHECK dout0_53 Vdout0_53ck22 = 1.8 time = 230
.meas tran vdout0_53ck22 FIND v(dout0_53) AT=230.05n

* CHECK dout0_54 Vdout0_54ck22 = 0 time = 230
.meas tran vdout0_54ck22 FIND v(dout0_54) AT=230.05n

* CHECK dout0_55 Vdout0_55ck22 = 0 time = 230
.meas tran vdout0_55ck22 FIND v(dout0_55) AT=230.05n

* CHECK dout0_56 Vdout0_56ck22 = 1.8 time = 230
.meas tran vdout0_56ck22 FIND v(dout0_56) AT=230.05n

* CHECK dout0_57 Vdout0_57ck22 = 0 time = 230
.meas tran vdout0_57ck22 FIND v(dout0_57) AT=230.05n

* CHECK dout0_58 Vdout0_58ck22 = 0 time = 230
.meas tran vdout0_58ck22 FIND v(dout0_58) AT=230.05n

* CHECK dout0_59 Vdout0_59ck22 = 1.8 time = 230
.meas tran vdout0_59ck22 FIND v(dout0_59) AT=230.05n

* CHECK dout0_60 Vdout0_60ck22 = 1.8 time = 230
.meas tran vdout0_60ck22 FIND v(dout0_60) AT=230.05n

* CHECK dout0_61 Vdout0_61ck22 = 1.8 time = 230
.meas tran vdout0_61ck22 FIND v(dout0_61) AT=230.05n

* CHECK dout0_62 Vdout0_62ck22 = 0 time = 230
.meas tran vdout0_62ck22 FIND v(dout0_62) AT=230.05n

* CHECK dout0_63 Vdout0_63ck22 = 0 time = 230
.meas tran vdout0_63ck22 FIND v(dout0_63) AT=230.05n

* CHECK dout0_64 Vdout0_64ck22 = 0 time = 230
.meas tran vdout0_64ck22 FIND v(dout0_64) AT=230.05n

* CHECK dout0_0 Vdout0_0ck23 = 0 time = 240
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=240.05n

* CHECK dout0_1 Vdout0_1ck23 = 0 time = 240
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=240.05n

* CHECK dout0_2 Vdout0_2ck23 = 1.8 time = 240
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=240.05n

* CHECK dout0_3 Vdout0_3ck23 = 1.8 time = 240
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=240.05n

* CHECK dout0_4 Vdout0_4ck23 = 1.8 time = 240
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=240.05n

* CHECK dout0_5 Vdout0_5ck23 = 1.8 time = 240
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=240.05n

* CHECK dout0_6 Vdout0_6ck23 = 1.8 time = 240
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=240.05n

* CHECK dout0_7 Vdout0_7ck23 = 1.8 time = 240
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=240.05n

* CHECK dout0_8 Vdout0_8ck23 = 1.8 time = 240
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=240.05n

* CHECK dout0_9 Vdout0_9ck23 = 1.8 time = 240
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=240.05n

* CHECK dout0_10 Vdout0_10ck23 = 0 time = 240
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=240.05n

* CHECK dout0_11 Vdout0_11ck23 = 0 time = 240
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=240.05n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 240
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=240.05n

* CHECK dout0_13 Vdout0_13ck23 = 1.8 time = 240
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=240.05n

* CHECK dout0_14 Vdout0_14ck23 = 0 time = 240
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=240.05n

* CHECK dout0_15 Vdout0_15ck23 = 1.8 time = 240
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=240.05n

* CHECK dout0_16 Vdout0_16ck23 = 0 time = 240
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=240.05n

* CHECK dout0_17 Vdout0_17ck23 = 1.8 time = 240
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=240.05n

* CHECK dout0_18 Vdout0_18ck23 = 1.8 time = 240
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=240.05n

* CHECK dout0_19 Vdout0_19ck23 = 1.8 time = 240
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=240.05n

* CHECK dout0_20 Vdout0_20ck23 = 1.8 time = 240
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=240.05n

* CHECK dout0_21 Vdout0_21ck23 = 1.8 time = 240
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=240.05n

* CHECK dout0_22 Vdout0_22ck23 = 1.8 time = 240
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=240.05n

* CHECK dout0_23 Vdout0_23ck23 = 0 time = 240
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=240.05n

* CHECK dout0_24 Vdout0_24ck23 = 1.8 time = 240
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=240.05n

* CHECK dout0_25 Vdout0_25ck23 = 1.8 time = 240
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=240.05n

* CHECK dout0_26 Vdout0_26ck23 = 1.8 time = 240
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=240.05n

* CHECK dout0_27 Vdout0_27ck23 = 0 time = 240
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=240.05n

* CHECK dout0_28 Vdout0_28ck23 = 1.8 time = 240
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=240.05n

* CHECK dout0_29 Vdout0_29ck23 = 0 time = 240
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=240.05n

* CHECK dout0_30 Vdout0_30ck23 = 1.8 time = 240
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=240.05n

* CHECK dout0_31 Vdout0_31ck23 = 0 time = 240
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=240.05n

* CHECK dout0_32 Vdout0_32ck23 = 0 time = 240
.meas tran vdout0_32ck23 FIND v(dout0_32) AT=240.05n

* CHECK dout0_33 Vdout0_33ck23 = 0 time = 240
.meas tran vdout0_33ck23 FIND v(dout0_33) AT=240.05n

* CHECK dout0_34 Vdout0_34ck23 = 1.8 time = 240
.meas tran vdout0_34ck23 FIND v(dout0_34) AT=240.05n

* CHECK dout0_35 Vdout0_35ck23 = 1.8 time = 240
.meas tran vdout0_35ck23 FIND v(dout0_35) AT=240.05n

* CHECK dout0_36 Vdout0_36ck23 = 0 time = 240
.meas tran vdout0_36ck23 FIND v(dout0_36) AT=240.05n

* CHECK dout0_37 Vdout0_37ck23 = 0 time = 240
.meas tran vdout0_37ck23 FIND v(dout0_37) AT=240.05n

* CHECK dout0_38 Vdout0_38ck23 = 1.8 time = 240
.meas tran vdout0_38ck23 FIND v(dout0_38) AT=240.05n

* CHECK dout0_39 Vdout0_39ck23 = 0 time = 240
.meas tran vdout0_39ck23 FIND v(dout0_39) AT=240.05n

* CHECK dout0_40 Vdout0_40ck23 = 1.8 time = 240
.meas tran vdout0_40ck23 FIND v(dout0_40) AT=240.05n

* CHECK dout0_41 Vdout0_41ck23 = 0 time = 240
.meas tran vdout0_41ck23 FIND v(dout0_41) AT=240.05n

* CHECK dout0_42 Vdout0_42ck23 = 1.8 time = 240
.meas tran vdout0_42ck23 FIND v(dout0_42) AT=240.05n

* CHECK dout0_43 Vdout0_43ck23 = 1.8 time = 240
.meas tran vdout0_43ck23 FIND v(dout0_43) AT=240.05n

* CHECK dout0_44 Vdout0_44ck23 = 0 time = 240
.meas tran vdout0_44ck23 FIND v(dout0_44) AT=240.05n

* CHECK dout0_45 Vdout0_45ck23 = 0 time = 240
.meas tran vdout0_45ck23 FIND v(dout0_45) AT=240.05n

* CHECK dout0_46 Vdout0_46ck23 = 0 time = 240
.meas tran vdout0_46ck23 FIND v(dout0_46) AT=240.05n

* CHECK dout0_47 Vdout0_47ck23 = 1.8 time = 240
.meas tran vdout0_47ck23 FIND v(dout0_47) AT=240.05n

* CHECK dout0_48 Vdout0_48ck23 = 1.8 time = 240
.meas tran vdout0_48ck23 FIND v(dout0_48) AT=240.05n

* CHECK dout0_49 Vdout0_49ck23 = 1.8 time = 240
.meas tran vdout0_49ck23 FIND v(dout0_49) AT=240.05n

* CHECK dout0_50 Vdout0_50ck23 = 1.8 time = 240
.meas tran vdout0_50ck23 FIND v(dout0_50) AT=240.05n

* CHECK dout0_51 Vdout0_51ck23 = 0 time = 240
.meas tran vdout0_51ck23 FIND v(dout0_51) AT=240.05n

* CHECK dout0_52 Vdout0_52ck23 = 0 time = 240
.meas tran vdout0_52ck23 FIND v(dout0_52) AT=240.05n

* CHECK dout0_53 Vdout0_53ck23 = 1.8 time = 240
.meas tran vdout0_53ck23 FIND v(dout0_53) AT=240.05n

* CHECK dout0_54 Vdout0_54ck23 = 0 time = 240
.meas tran vdout0_54ck23 FIND v(dout0_54) AT=240.05n

* CHECK dout0_55 Vdout0_55ck23 = 0 time = 240
.meas tran vdout0_55ck23 FIND v(dout0_55) AT=240.05n

* CHECK dout0_56 Vdout0_56ck23 = 1.8 time = 240
.meas tran vdout0_56ck23 FIND v(dout0_56) AT=240.05n

* CHECK dout0_57 Vdout0_57ck23 = 0 time = 240
.meas tran vdout0_57ck23 FIND v(dout0_57) AT=240.05n

* CHECK dout0_58 Vdout0_58ck23 = 0 time = 240
.meas tran vdout0_58ck23 FIND v(dout0_58) AT=240.05n

* CHECK dout0_59 Vdout0_59ck23 = 1.8 time = 240
.meas tran vdout0_59ck23 FIND v(dout0_59) AT=240.05n

* CHECK dout0_60 Vdout0_60ck23 = 1.8 time = 240
.meas tran vdout0_60ck23 FIND v(dout0_60) AT=240.05n

* CHECK dout0_61 Vdout0_61ck23 = 0 time = 240
.meas tran vdout0_61ck23 FIND v(dout0_61) AT=240.05n

* CHECK dout0_62 Vdout0_62ck23 = 0 time = 240
.meas tran vdout0_62ck23 FIND v(dout0_62) AT=240.05n

* CHECK dout0_63 Vdout0_63ck23 = 1.8 time = 240
.meas tran vdout0_63ck23 FIND v(dout0_63) AT=240.05n

* CHECK dout0_64 Vdout0_64ck23 = 0 time = 240
.meas tran vdout0_64ck23 FIND v(dout0_64) AT=240.05n

* CHECK dout0_0 Vdout0_0ck24 = 1.8 time = 250
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=250.05n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 250
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=250.05n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 250
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=250.05n

* CHECK dout0_3 Vdout0_3ck24 = 0 time = 250
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=250.05n

* CHECK dout0_4 Vdout0_4ck24 = 1.8 time = 250
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=250.05n

* CHECK dout0_5 Vdout0_5ck24 = 1.8 time = 250
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=250.05n

* CHECK dout0_6 Vdout0_6ck24 = 0 time = 250
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=250.05n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 250
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=250.05n

* CHECK dout0_8 Vdout0_8ck24 = 0 time = 250
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=250.05n

* CHECK dout0_9 Vdout0_9ck24 = 0 time = 250
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=250.05n

* CHECK dout0_10 Vdout0_10ck24 = 1.8 time = 250
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=250.05n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 250
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=250.05n

* CHECK dout0_12 Vdout0_12ck24 = 0 time = 250
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=250.05n

* CHECK dout0_13 Vdout0_13ck24 = 0 time = 250
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=250.05n

* CHECK dout0_14 Vdout0_14ck24 = 0 time = 250
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=250.05n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 250
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=250.05n

* CHECK dout0_16 Vdout0_16ck24 = 1.8 time = 250
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=250.05n

* CHECK dout0_17 Vdout0_17ck24 = 0 time = 250
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=250.05n

* CHECK dout0_18 Vdout0_18ck24 = 0 time = 250
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=250.05n

* CHECK dout0_19 Vdout0_19ck24 = 1.8 time = 250
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=250.05n

* CHECK dout0_20 Vdout0_20ck24 = 1.8 time = 250
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=250.05n

* CHECK dout0_21 Vdout0_21ck24 = 1.8 time = 250
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=250.05n

* CHECK dout0_22 Vdout0_22ck24 = 1.8 time = 250
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=250.05n

* CHECK dout0_23 Vdout0_23ck24 = 1.8 time = 250
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=250.05n

* CHECK dout0_24 Vdout0_24ck24 = 0 time = 250
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=250.05n

* CHECK dout0_25 Vdout0_25ck24 = 0 time = 250
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=250.05n

* CHECK dout0_26 Vdout0_26ck24 = 0 time = 250
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=250.05n

* CHECK dout0_27 Vdout0_27ck24 = 0 time = 250
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=250.05n

* CHECK dout0_28 Vdout0_28ck24 = 0 time = 250
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=250.05n

* CHECK dout0_29 Vdout0_29ck24 = 0 time = 250
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=250.05n

* CHECK dout0_30 Vdout0_30ck24 = 0 time = 250
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=250.05n

* CHECK dout0_31 Vdout0_31ck24 = 0 time = 250
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=250.05n

* CHECK dout0_32 Vdout0_32ck24 = 0 time = 250
.meas tran vdout0_32ck24 FIND v(dout0_32) AT=250.05n

* CHECK dout0_33 Vdout0_33ck24 = 0 time = 250
.meas tran vdout0_33ck24 FIND v(dout0_33) AT=250.05n

* CHECK dout0_34 Vdout0_34ck24 = 0 time = 250
.meas tran vdout0_34ck24 FIND v(dout0_34) AT=250.05n

* CHECK dout0_35 Vdout0_35ck24 = 1.8 time = 250
.meas tran vdout0_35ck24 FIND v(dout0_35) AT=250.05n

* CHECK dout0_36 Vdout0_36ck24 = 0 time = 250
.meas tran vdout0_36ck24 FIND v(dout0_36) AT=250.05n

* CHECK dout0_37 Vdout0_37ck24 = 1.8 time = 250
.meas tran vdout0_37ck24 FIND v(dout0_37) AT=250.05n

* CHECK dout0_38 Vdout0_38ck24 = 0 time = 250
.meas tran vdout0_38ck24 FIND v(dout0_38) AT=250.05n

* CHECK dout0_39 Vdout0_39ck24 = 1.8 time = 250
.meas tran vdout0_39ck24 FIND v(dout0_39) AT=250.05n

* CHECK dout0_40 Vdout0_40ck24 = 1.8 time = 250
.meas tran vdout0_40ck24 FIND v(dout0_40) AT=250.05n

* CHECK dout0_41 Vdout0_41ck24 = 0 time = 250
.meas tran vdout0_41ck24 FIND v(dout0_41) AT=250.05n

* CHECK dout0_42 Vdout0_42ck24 = 1.8 time = 250
.meas tran vdout0_42ck24 FIND v(dout0_42) AT=250.05n

* CHECK dout0_43 Vdout0_43ck24 = 1.8 time = 250
.meas tran vdout0_43ck24 FIND v(dout0_43) AT=250.05n

* CHECK dout0_44 Vdout0_44ck24 = 1.8 time = 250
.meas tran vdout0_44ck24 FIND v(dout0_44) AT=250.05n

* CHECK dout0_45 Vdout0_45ck24 = 0 time = 250
.meas tran vdout0_45ck24 FIND v(dout0_45) AT=250.05n

* CHECK dout0_46 Vdout0_46ck24 = 0 time = 250
.meas tran vdout0_46ck24 FIND v(dout0_46) AT=250.05n

* CHECK dout0_47 Vdout0_47ck24 = 1.8 time = 250
.meas tran vdout0_47ck24 FIND v(dout0_47) AT=250.05n

* CHECK dout0_48 Vdout0_48ck24 = 0 time = 250
.meas tran vdout0_48ck24 FIND v(dout0_48) AT=250.05n

* CHECK dout0_49 Vdout0_49ck24 = 1.8 time = 250
.meas tran vdout0_49ck24 FIND v(dout0_49) AT=250.05n

* CHECK dout0_50 Vdout0_50ck24 = 1.8 time = 250
.meas tran vdout0_50ck24 FIND v(dout0_50) AT=250.05n

* CHECK dout0_51 Vdout0_51ck24 = 1.8 time = 250
.meas tran vdout0_51ck24 FIND v(dout0_51) AT=250.05n

* CHECK dout0_52 Vdout0_52ck24 = 1.8 time = 250
.meas tran vdout0_52ck24 FIND v(dout0_52) AT=250.05n

* CHECK dout0_53 Vdout0_53ck24 = 1.8 time = 250
.meas tran vdout0_53ck24 FIND v(dout0_53) AT=250.05n

* CHECK dout0_54 Vdout0_54ck24 = 1.8 time = 250
.meas tran vdout0_54ck24 FIND v(dout0_54) AT=250.05n

* CHECK dout0_55 Vdout0_55ck24 = 1.8 time = 250
.meas tran vdout0_55ck24 FIND v(dout0_55) AT=250.05n

* CHECK dout0_56 Vdout0_56ck24 = 0 time = 250
.meas tran vdout0_56ck24 FIND v(dout0_56) AT=250.05n

* CHECK dout0_57 Vdout0_57ck24 = 0 time = 250
.meas tran vdout0_57ck24 FIND v(dout0_57) AT=250.05n

* CHECK dout0_58 Vdout0_58ck24 = 1.8 time = 250
.meas tran vdout0_58ck24 FIND v(dout0_58) AT=250.05n

* CHECK dout0_59 Vdout0_59ck24 = 0 time = 250
.meas tran vdout0_59ck24 FIND v(dout0_59) AT=250.05n

* CHECK dout0_60 Vdout0_60ck24 = 0 time = 250
.meas tran vdout0_60ck24 FIND v(dout0_60) AT=250.05n

* CHECK dout0_61 Vdout0_61ck24 = 1.8 time = 250
.meas tran vdout0_61ck24 FIND v(dout0_61) AT=250.05n

* CHECK dout0_62 Vdout0_62ck24 = 1.8 time = 250
.meas tran vdout0_62ck24 FIND v(dout0_62) AT=250.05n

* CHECK dout0_63 Vdout0_63ck24 = 1.8 time = 250
.meas tran vdout0_63ck24 FIND v(dout0_63) AT=250.05n

* CHECK dout0_64 Vdout0_64ck24 = 0 time = 250
.meas tran vdout0_64ck24 FIND v(dout0_64) AT=250.05n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 270
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=270.05n

* CHECK dout0_1 Vdout0_1ck26 = 0 time = 270
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=270.05n

* CHECK dout0_2 Vdout0_2ck26 = 1.8 time = 270
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=270.05n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 270
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=270.05n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 270
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=270.05n

* CHECK dout0_5 Vdout0_5ck26 = 1.8 time = 270
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=270.05n

* CHECK dout0_6 Vdout0_6ck26 = 0 time = 270
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=270.05n

* CHECK dout0_7 Vdout0_7ck26 = 1.8 time = 270
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=270.05n

* CHECK dout0_8 Vdout0_8ck26 = 0 time = 270
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=270.05n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 270
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=270.05n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 270
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=270.05n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 270
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=270.05n

* CHECK dout0_12 Vdout0_12ck26 = 1.8 time = 270
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=270.05n

* CHECK dout0_13 Vdout0_13ck26 = 1.8 time = 270
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=270.05n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 270
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=270.05n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 270
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=270.05n

* CHECK dout0_16 Vdout0_16ck26 = 1.8 time = 270
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=270.05n

* CHECK dout0_17 Vdout0_17ck26 = 0 time = 270
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=270.05n

* CHECK dout0_18 Vdout0_18ck26 = 1.8 time = 270
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=270.05n

* CHECK dout0_19 Vdout0_19ck26 = 1.8 time = 270
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=270.05n

* CHECK dout0_20 Vdout0_20ck26 = 0 time = 270
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=270.05n

* CHECK dout0_21 Vdout0_21ck26 = 0 time = 270
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=270.05n

* CHECK dout0_22 Vdout0_22ck26 = 0 time = 270
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=270.05n

* CHECK dout0_23 Vdout0_23ck26 = 1.8 time = 270
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=270.05n

* CHECK dout0_24 Vdout0_24ck26 = 0 time = 270
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=270.05n

* CHECK dout0_25 Vdout0_25ck26 = 1.8 time = 270
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=270.05n

* CHECK dout0_26 Vdout0_26ck26 = 1.8 time = 270
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=270.05n

* CHECK dout0_27 Vdout0_27ck26 = 1.8 time = 270
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=270.05n

* CHECK dout0_28 Vdout0_28ck26 = 0 time = 270
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=270.05n

* CHECK dout0_29 Vdout0_29ck26 = 0 time = 270
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=270.05n

* CHECK dout0_30 Vdout0_30ck26 = 0 time = 270
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=270.05n

* CHECK dout0_31 Vdout0_31ck26 = 1.8 time = 270
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=270.05n

* CHECK dout0_32 Vdout0_32ck26 = 0 time = 270
.meas tran vdout0_32ck26 FIND v(dout0_32) AT=270.05n

* CHECK dout0_33 Vdout0_33ck26 = 1.8 time = 270
.meas tran vdout0_33ck26 FIND v(dout0_33) AT=270.05n

* CHECK dout0_34 Vdout0_34ck26 = 1.8 time = 270
.meas tran vdout0_34ck26 FIND v(dout0_34) AT=270.05n

* CHECK dout0_35 Vdout0_35ck26 = 1.8 time = 270
.meas tran vdout0_35ck26 FIND v(dout0_35) AT=270.05n

* CHECK dout0_36 Vdout0_36ck26 = 0 time = 270
.meas tran vdout0_36ck26 FIND v(dout0_36) AT=270.05n

* CHECK dout0_37 Vdout0_37ck26 = 1.8 time = 270
.meas tran vdout0_37ck26 FIND v(dout0_37) AT=270.05n

* CHECK dout0_38 Vdout0_38ck26 = 0 time = 270
.meas tran vdout0_38ck26 FIND v(dout0_38) AT=270.05n

* CHECK dout0_39 Vdout0_39ck26 = 0 time = 270
.meas tran vdout0_39ck26 FIND v(dout0_39) AT=270.05n

* CHECK dout0_40 Vdout0_40ck26 = 0 time = 270
.meas tran vdout0_40ck26 FIND v(dout0_40) AT=270.05n

* CHECK dout0_41 Vdout0_41ck26 = 1.8 time = 270
.meas tran vdout0_41ck26 FIND v(dout0_41) AT=270.05n

* CHECK dout0_42 Vdout0_42ck26 = 1.8 time = 270
.meas tran vdout0_42ck26 FIND v(dout0_42) AT=270.05n

* CHECK dout0_43 Vdout0_43ck26 = 0 time = 270
.meas tran vdout0_43ck26 FIND v(dout0_43) AT=270.05n

* CHECK dout0_44 Vdout0_44ck26 = 0 time = 270
.meas tran vdout0_44ck26 FIND v(dout0_44) AT=270.05n

* CHECK dout0_45 Vdout0_45ck26 = 1.8 time = 270
.meas tran vdout0_45ck26 FIND v(dout0_45) AT=270.05n

* CHECK dout0_46 Vdout0_46ck26 = 0 time = 270
.meas tran vdout0_46ck26 FIND v(dout0_46) AT=270.05n

* CHECK dout0_47 Vdout0_47ck26 = 0 time = 270
.meas tran vdout0_47ck26 FIND v(dout0_47) AT=270.05n

* CHECK dout0_48 Vdout0_48ck26 = 0 time = 270
.meas tran vdout0_48ck26 FIND v(dout0_48) AT=270.05n

* CHECK dout0_49 Vdout0_49ck26 = 0 time = 270
.meas tran vdout0_49ck26 FIND v(dout0_49) AT=270.05n

* CHECK dout0_50 Vdout0_50ck26 = 1.8 time = 270
.meas tran vdout0_50ck26 FIND v(dout0_50) AT=270.05n

* CHECK dout0_51 Vdout0_51ck26 = 0 time = 270
.meas tran vdout0_51ck26 FIND v(dout0_51) AT=270.05n

* CHECK dout0_52 Vdout0_52ck26 = 0 time = 270
.meas tran vdout0_52ck26 FIND v(dout0_52) AT=270.05n

* CHECK dout0_53 Vdout0_53ck26 = 1.8 time = 270
.meas tran vdout0_53ck26 FIND v(dout0_53) AT=270.05n

* CHECK dout0_54 Vdout0_54ck26 = 0 time = 270
.meas tran vdout0_54ck26 FIND v(dout0_54) AT=270.05n

* CHECK dout0_55 Vdout0_55ck26 = 0 time = 270
.meas tran vdout0_55ck26 FIND v(dout0_55) AT=270.05n

* CHECK dout0_56 Vdout0_56ck26 = 1.8 time = 270
.meas tran vdout0_56ck26 FIND v(dout0_56) AT=270.05n

* CHECK dout0_57 Vdout0_57ck26 = 0 time = 270
.meas tran vdout0_57ck26 FIND v(dout0_57) AT=270.05n

* CHECK dout0_58 Vdout0_58ck26 = 0 time = 270
.meas tran vdout0_58ck26 FIND v(dout0_58) AT=270.05n

* CHECK dout0_59 Vdout0_59ck26 = 1.8 time = 270
.meas tran vdout0_59ck26 FIND v(dout0_59) AT=270.05n

* CHECK dout0_60 Vdout0_60ck26 = 1.8 time = 270
.meas tran vdout0_60ck26 FIND v(dout0_60) AT=270.05n

* CHECK dout0_61 Vdout0_61ck26 = 1.8 time = 270
.meas tran vdout0_61ck26 FIND v(dout0_61) AT=270.05n

* CHECK dout0_62 Vdout0_62ck26 = 0 time = 270
.meas tran vdout0_62ck26 FIND v(dout0_62) AT=270.05n

* CHECK dout0_63 Vdout0_63ck26 = 0 time = 270
.meas tran vdout0_63ck26 FIND v(dout0_63) AT=270.05n

* CHECK dout0_64 Vdout0_64ck26 = 0 time = 270
.meas tran vdout0_64ck26 FIND v(dout0_64) AT=270.05n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 280
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=280.05n

* CHECK dout0_1 Vdout0_1ck27 = 0 time = 280
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=280.05n

* CHECK dout0_2 Vdout0_2ck27 = 1.8 time = 280
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=280.05n

* CHECK dout0_3 Vdout0_3ck27 = 1.8 time = 280
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=280.05n

* CHECK dout0_4 Vdout0_4ck27 = 1.8 time = 280
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=280.05n

* CHECK dout0_5 Vdout0_5ck27 = 0 time = 280
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=280.05n

* CHECK dout0_6 Vdout0_6ck27 = 0 time = 280
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=280.05n

* CHECK dout0_7 Vdout0_7ck27 = 0 time = 280
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=280.05n

* CHECK dout0_8 Vdout0_8ck27 = 1.8 time = 280
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=280.05n

* CHECK dout0_9 Vdout0_9ck27 = 0 time = 280
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=280.05n

* CHECK dout0_10 Vdout0_10ck27 = 1.8 time = 280
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=280.05n

* CHECK dout0_11 Vdout0_11ck27 = 1.8 time = 280
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=280.05n

* CHECK dout0_12 Vdout0_12ck27 = 1.8 time = 280
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=280.05n

* CHECK dout0_13 Vdout0_13ck27 = 1.8 time = 280
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=280.05n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 280
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=280.05n

* CHECK dout0_15 Vdout0_15ck27 = 1.8 time = 280
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=280.05n

* CHECK dout0_16 Vdout0_16ck27 = 0 time = 280
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=280.05n

* CHECK dout0_17 Vdout0_17ck27 = 1.8 time = 280
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=280.05n

* CHECK dout0_18 Vdout0_18ck27 = 0 time = 280
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=280.05n

* CHECK dout0_19 Vdout0_19ck27 = 0 time = 280
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=280.05n

* CHECK dout0_20 Vdout0_20ck27 = 1.8 time = 280
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=280.05n

* CHECK dout0_21 Vdout0_21ck27 = 1.8 time = 280
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=280.05n

* CHECK dout0_22 Vdout0_22ck27 = 0 time = 280
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=280.05n

* CHECK dout0_23 Vdout0_23ck27 = 0 time = 280
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=280.05n

* CHECK dout0_24 Vdout0_24ck27 = 0 time = 280
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=280.05n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 280
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=280.05n

* CHECK dout0_26 Vdout0_26ck27 = 0 time = 280
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=280.05n

* CHECK dout0_27 Vdout0_27ck27 = 0 time = 280
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=280.05n

* CHECK dout0_28 Vdout0_28ck27 = 1.8 time = 280
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=280.05n

* CHECK dout0_29 Vdout0_29ck27 = 1.8 time = 280
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=280.05n

* CHECK dout0_30 Vdout0_30ck27 = 0 time = 280
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=280.05n

* CHECK dout0_31 Vdout0_31ck27 = 1.8 time = 280
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=280.05n

* CHECK dout0_32 Vdout0_32ck27 = 0 time = 280
.meas tran vdout0_32ck27 FIND v(dout0_32) AT=280.05n

* CHECK dout0_33 Vdout0_33ck27 = 0 time = 280
.meas tran vdout0_33ck27 FIND v(dout0_33) AT=280.05n

* CHECK dout0_34 Vdout0_34ck27 = 1.8 time = 280
.meas tran vdout0_34ck27 FIND v(dout0_34) AT=280.05n

* CHECK dout0_35 Vdout0_35ck27 = 1.8 time = 280
.meas tran vdout0_35ck27 FIND v(dout0_35) AT=280.05n

* CHECK dout0_36 Vdout0_36ck27 = 1.8 time = 280
.meas tran vdout0_36ck27 FIND v(dout0_36) AT=280.05n

* CHECK dout0_37 Vdout0_37ck27 = 1.8 time = 280
.meas tran vdout0_37ck27 FIND v(dout0_37) AT=280.05n

* CHECK dout0_38 Vdout0_38ck27 = 0 time = 280
.meas tran vdout0_38ck27 FIND v(dout0_38) AT=280.05n

* CHECK dout0_39 Vdout0_39ck27 = 0 time = 280
.meas tran vdout0_39ck27 FIND v(dout0_39) AT=280.05n

* CHECK dout0_40 Vdout0_40ck27 = 1.8 time = 280
.meas tran vdout0_40ck27 FIND v(dout0_40) AT=280.05n

* CHECK dout0_41 Vdout0_41ck27 = 1.8 time = 280
.meas tran vdout0_41ck27 FIND v(dout0_41) AT=280.05n

* CHECK dout0_42 Vdout0_42ck27 = 1.8 time = 280
.meas tran vdout0_42ck27 FIND v(dout0_42) AT=280.05n

* CHECK dout0_43 Vdout0_43ck27 = 0 time = 280
.meas tran vdout0_43ck27 FIND v(dout0_43) AT=280.05n

* CHECK dout0_44 Vdout0_44ck27 = 1.8 time = 280
.meas tran vdout0_44ck27 FIND v(dout0_44) AT=280.05n

* CHECK dout0_45 Vdout0_45ck27 = 0 time = 280
.meas tran vdout0_45ck27 FIND v(dout0_45) AT=280.05n

* CHECK dout0_46 Vdout0_46ck27 = 0 time = 280
.meas tran vdout0_46ck27 FIND v(dout0_46) AT=280.05n

* CHECK dout0_47 Vdout0_47ck27 = 0 time = 280
.meas tran vdout0_47ck27 FIND v(dout0_47) AT=280.05n

* CHECK dout0_48 Vdout0_48ck27 = 1.8 time = 280
.meas tran vdout0_48ck27 FIND v(dout0_48) AT=280.05n

* CHECK dout0_49 Vdout0_49ck27 = 0 time = 280
.meas tran vdout0_49ck27 FIND v(dout0_49) AT=280.05n

* CHECK dout0_50 Vdout0_50ck27 = 1.8 time = 280
.meas tran vdout0_50ck27 FIND v(dout0_50) AT=280.05n

* CHECK dout0_51 Vdout0_51ck27 = 0 time = 280
.meas tran vdout0_51ck27 FIND v(dout0_51) AT=280.05n

* CHECK dout0_52 Vdout0_52ck27 = 1.8 time = 280
.meas tran vdout0_52ck27 FIND v(dout0_52) AT=280.05n

* CHECK dout0_53 Vdout0_53ck27 = 1.8 time = 280
.meas tran vdout0_53ck27 FIND v(dout0_53) AT=280.05n

* CHECK dout0_54 Vdout0_54ck27 = 1.8 time = 280
.meas tran vdout0_54ck27 FIND v(dout0_54) AT=280.05n

* CHECK dout0_55 Vdout0_55ck27 = 0 time = 280
.meas tran vdout0_55ck27 FIND v(dout0_55) AT=280.05n

* CHECK dout0_56 Vdout0_56ck27 = 1.8 time = 280
.meas tran vdout0_56ck27 FIND v(dout0_56) AT=280.05n

* CHECK dout0_57 Vdout0_57ck27 = 1.8 time = 280
.meas tran vdout0_57ck27 FIND v(dout0_57) AT=280.05n

* CHECK dout0_58 Vdout0_58ck27 = 1.8 time = 280
.meas tran vdout0_58ck27 FIND v(dout0_58) AT=280.05n

* CHECK dout0_59 Vdout0_59ck27 = 1.8 time = 280
.meas tran vdout0_59ck27 FIND v(dout0_59) AT=280.05n

* CHECK dout0_60 Vdout0_60ck27 = 0 time = 280
.meas tran vdout0_60ck27 FIND v(dout0_60) AT=280.05n

* CHECK dout0_61 Vdout0_61ck27 = 1.8 time = 280
.meas tran vdout0_61ck27 FIND v(dout0_61) AT=280.05n

* CHECK dout0_62 Vdout0_62ck27 = 0 time = 280
.meas tran vdout0_62ck27 FIND v(dout0_62) AT=280.05n

* CHECK dout0_63 Vdout0_63ck27 = 0 time = 280
.meas tran vdout0_63ck27 FIND v(dout0_63) AT=280.05n

* CHECK dout0_64 Vdout0_64ck27 = 0 time = 280
.meas tran vdout0_64ck27 FIND v(dout0_64) AT=280.05n

* CHECK dout0_0 Vdout0_0ck33 = 1.8 time = 340
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=340.05n

* CHECK dout0_1 Vdout0_1ck33 = 1.8 time = 340
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=340.05n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 340
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=340.05n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 340
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=340.05n

* CHECK dout0_4 Vdout0_4ck33 = 1.8 time = 340
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=340.05n

* CHECK dout0_5 Vdout0_5ck33 = 1.8 time = 340
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=340.05n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 340
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=340.05n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 340
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=340.05n

* CHECK dout0_8 Vdout0_8ck33 = 1.8 time = 340
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=340.05n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 340
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=340.05n

* CHECK dout0_10 Vdout0_10ck33 = 0 time = 340
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=340.05n

* CHECK dout0_11 Vdout0_11ck33 = 1.8 time = 340
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=340.05n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 340
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=340.05n

* CHECK dout0_13 Vdout0_13ck33 = 1.8 time = 340
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=340.05n

* CHECK dout0_14 Vdout0_14ck33 = 1.8 time = 340
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=340.05n

* CHECK dout0_15 Vdout0_15ck33 = 1.8 time = 340
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=340.05n

* CHECK dout0_16 Vdout0_16ck33 = 1.8 time = 340
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=340.05n

* CHECK dout0_17 Vdout0_17ck33 = 0 time = 340
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=340.05n

* CHECK dout0_18 Vdout0_18ck33 = 0 time = 340
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=340.05n

* CHECK dout0_19 Vdout0_19ck33 = 0 time = 340
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=340.05n

* CHECK dout0_20 Vdout0_20ck33 = 1.8 time = 340
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=340.05n

* CHECK dout0_21 Vdout0_21ck33 = 1.8 time = 340
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=340.05n

* CHECK dout0_22 Vdout0_22ck33 = 1.8 time = 340
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=340.05n

* CHECK dout0_23 Vdout0_23ck33 = 0 time = 340
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=340.05n

* CHECK dout0_24 Vdout0_24ck33 = 1.8 time = 340
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=340.05n

* CHECK dout0_25 Vdout0_25ck33 = 1.8 time = 340
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=340.05n

* CHECK dout0_26 Vdout0_26ck33 = 0 time = 340
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=340.05n

* CHECK dout0_27 Vdout0_27ck33 = 0 time = 340
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=340.05n

* CHECK dout0_28 Vdout0_28ck33 = 0 time = 340
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=340.05n

* CHECK dout0_29 Vdout0_29ck33 = 1.8 time = 340
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=340.05n

* CHECK dout0_30 Vdout0_30ck33 = 1.8 time = 340
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=340.05n

* CHECK dout0_31 Vdout0_31ck33 = 0 time = 340
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=340.05n

* CHECK dout0_32 Vdout0_32ck33 = 1.8 time = 340
.meas tran vdout0_32ck33 FIND v(dout0_32) AT=340.05n

* CHECK dout0_33 Vdout0_33ck33 = 0 time = 340
.meas tran vdout0_33ck33 FIND v(dout0_33) AT=340.05n

* CHECK dout0_34 Vdout0_34ck33 = 0 time = 340
.meas tran vdout0_34ck33 FIND v(dout0_34) AT=340.05n

* CHECK dout0_35 Vdout0_35ck33 = 1.8 time = 340
.meas tran vdout0_35ck33 FIND v(dout0_35) AT=340.05n

* CHECK dout0_36 Vdout0_36ck33 = 0 time = 340
.meas tran vdout0_36ck33 FIND v(dout0_36) AT=340.05n

* CHECK dout0_37 Vdout0_37ck33 = 0 time = 340
.meas tran vdout0_37ck33 FIND v(dout0_37) AT=340.05n

* CHECK dout0_38 Vdout0_38ck33 = 0 time = 340
.meas tran vdout0_38ck33 FIND v(dout0_38) AT=340.05n

* CHECK dout0_39 Vdout0_39ck33 = 1.8 time = 340
.meas tran vdout0_39ck33 FIND v(dout0_39) AT=340.05n

* CHECK dout0_40 Vdout0_40ck33 = 0 time = 340
.meas tran vdout0_40ck33 FIND v(dout0_40) AT=340.05n

* CHECK dout0_41 Vdout0_41ck33 = 1.8 time = 340
.meas tran vdout0_41ck33 FIND v(dout0_41) AT=340.05n

* CHECK dout0_42 Vdout0_42ck33 = 0 time = 340
.meas tran vdout0_42ck33 FIND v(dout0_42) AT=340.05n

* CHECK dout0_43 Vdout0_43ck33 = 1.8 time = 340
.meas tran vdout0_43ck33 FIND v(dout0_43) AT=340.05n

* CHECK dout0_44 Vdout0_44ck33 = 1.8 time = 340
.meas tran vdout0_44ck33 FIND v(dout0_44) AT=340.05n

* CHECK dout0_45 Vdout0_45ck33 = 1.8 time = 340
.meas tran vdout0_45ck33 FIND v(dout0_45) AT=340.05n

* CHECK dout0_46 Vdout0_46ck33 = 0 time = 340
.meas tran vdout0_46ck33 FIND v(dout0_46) AT=340.05n

* CHECK dout0_47 Vdout0_47ck33 = 0 time = 340
.meas tran vdout0_47ck33 FIND v(dout0_47) AT=340.05n

* CHECK dout0_48 Vdout0_48ck33 = 1.8 time = 340
.meas tran vdout0_48ck33 FIND v(dout0_48) AT=340.05n

* CHECK dout0_49 Vdout0_49ck33 = 0 time = 340
.meas tran vdout0_49ck33 FIND v(dout0_49) AT=340.05n

* CHECK dout0_50 Vdout0_50ck33 = 1.8 time = 340
.meas tran vdout0_50ck33 FIND v(dout0_50) AT=340.05n

* CHECK dout0_51 Vdout0_51ck33 = 1.8 time = 340
.meas tran vdout0_51ck33 FIND v(dout0_51) AT=340.05n

* CHECK dout0_52 Vdout0_52ck33 = 0 time = 340
.meas tran vdout0_52ck33 FIND v(dout0_52) AT=340.05n

* CHECK dout0_53 Vdout0_53ck33 = 1.8 time = 340
.meas tran vdout0_53ck33 FIND v(dout0_53) AT=340.05n

* CHECK dout0_54 Vdout0_54ck33 = 1.8 time = 340
.meas tran vdout0_54ck33 FIND v(dout0_54) AT=340.05n

* CHECK dout0_55 Vdout0_55ck33 = 1.8 time = 340
.meas tran vdout0_55ck33 FIND v(dout0_55) AT=340.05n

* CHECK dout0_56 Vdout0_56ck33 = 0 time = 340
.meas tran vdout0_56ck33 FIND v(dout0_56) AT=340.05n

* CHECK dout0_57 Vdout0_57ck33 = 1.8 time = 340
.meas tran vdout0_57ck33 FIND v(dout0_57) AT=340.05n

* CHECK dout0_58 Vdout0_58ck33 = 0 time = 340
.meas tran vdout0_58ck33 FIND v(dout0_58) AT=340.05n

* CHECK dout0_59 Vdout0_59ck33 = 1.8 time = 340
.meas tran vdout0_59ck33 FIND v(dout0_59) AT=340.05n

* CHECK dout0_60 Vdout0_60ck33 = 1.8 time = 340
.meas tran vdout0_60ck33 FIND v(dout0_60) AT=340.05n

* CHECK dout0_61 Vdout0_61ck33 = 0 time = 340
.meas tran vdout0_61ck33 FIND v(dout0_61) AT=340.05n

* CHECK dout0_62 Vdout0_62ck33 = 1.8 time = 340
.meas tran vdout0_62ck33 FIND v(dout0_62) AT=340.05n

* CHECK dout0_63 Vdout0_63ck33 = 1.8 time = 340
.meas tran vdout0_63ck33 FIND v(dout0_63) AT=340.05n

* CHECK dout0_64 Vdout0_64ck33 = 0 time = 340
.meas tran vdout0_64ck33 FIND v(dout0_64) AT=340.05n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 350
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=350.05n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 350
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=350.05n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 350
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=350.05n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 350
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=350.05n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 350
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=350.05n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 350
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=350.05n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 350
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=350.05n

* CHECK dout0_7 Vdout0_7ck34 = 1.8 time = 350
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=350.05n

* CHECK dout0_8 Vdout0_8ck34 = 1.8 time = 350
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=350.05n

* CHECK dout0_9 Vdout0_9ck34 = 1.8 time = 350
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=350.05n

* CHECK dout0_10 Vdout0_10ck34 = 1.8 time = 350
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=350.05n

* CHECK dout0_11 Vdout0_11ck34 = 1.8 time = 350
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=350.05n

* CHECK dout0_12 Vdout0_12ck34 = 0 time = 350
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=350.05n

* CHECK dout0_13 Vdout0_13ck34 = 1.8 time = 350
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=350.05n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 350
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=350.05n

* CHECK dout0_15 Vdout0_15ck34 = 0 time = 350
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=350.05n

* CHECK dout0_16 Vdout0_16ck34 = 1.8 time = 350
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=350.05n

* CHECK dout0_17 Vdout0_17ck34 = 1.8 time = 350
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=350.05n

* CHECK dout0_18 Vdout0_18ck34 = 0 time = 350
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=350.05n

* CHECK dout0_19 Vdout0_19ck34 = 1.8 time = 350
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=350.05n

* CHECK dout0_20 Vdout0_20ck34 = 0 time = 350
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=350.05n

* CHECK dout0_21 Vdout0_21ck34 = 1.8 time = 350
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=350.05n

* CHECK dout0_22 Vdout0_22ck34 = 1.8 time = 350
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=350.05n

* CHECK dout0_23 Vdout0_23ck34 = 1.8 time = 350
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=350.05n

* CHECK dout0_24 Vdout0_24ck34 = 1.8 time = 350
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=350.05n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 350
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=350.05n

* CHECK dout0_26 Vdout0_26ck34 = 1.8 time = 350
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=350.05n

* CHECK dout0_27 Vdout0_27ck34 = 1.8 time = 350
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=350.05n

* CHECK dout0_28 Vdout0_28ck34 = 1.8 time = 350
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=350.05n

* CHECK dout0_29 Vdout0_29ck34 = 1.8 time = 350
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=350.05n

* CHECK dout0_30 Vdout0_30ck34 = 1.8 time = 350
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=350.05n

* CHECK dout0_31 Vdout0_31ck34 = 0 time = 350
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=350.05n

* CHECK dout0_32 Vdout0_32ck34 = 1.8 time = 350
.meas tran vdout0_32ck34 FIND v(dout0_32) AT=350.05n

* CHECK dout0_33 Vdout0_33ck34 = 1.8 time = 350
.meas tran vdout0_33ck34 FIND v(dout0_33) AT=350.05n

* CHECK dout0_34 Vdout0_34ck34 = 1.8 time = 350
.meas tran vdout0_34ck34 FIND v(dout0_34) AT=350.05n

* CHECK dout0_35 Vdout0_35ck34 = 0 time = 350
.meas tran vdout0_35ck34 FIND v(dout0_35) AT=350.05n

* CHECK dout0_36 Vdout0_36ck34 = 1.8 time = 350
.meas tran vdout0_36ck34 FIND v(dout0_36) AT=350.05n

* CHECK dout0_37 Vdout0_37ck34 = 0 time = 350
.meas tran vdout0_37ck34 FIND v(dout0_37) AT=350.05n

* CHECK dout0_38 Vdout0_38ck34 = 1.8 time = 350
.meas tran vdout0_38ck34 FIND v(dout0_38) AT=350.05n

* CHECK dout0_39 Vdout0_39ck34 = 1.8 time = 350
.meas tran vdout0_39ck34 FIND v(dout0_39) AT=350.05n

* CHECK dout0_40 Vdout0_40ck34 = 0 time = 350
.meas tran vdout0_40ck34 FIND v(dout0_40) AT=350.05n

* CHECK dout0_41 Vdout0_41ck34 = 1.8 time = 350
.meas tran vdout0_41ck34 FIND v(dout0_41) AT=350.05n

* CHECK dout0_42 Vdout0_42ck34 = 0 time = 350
.meas tran vdout0_42ck34 FIND v(dout0_42) AT=350.05n

* CHECK dout0_43 Vdout0_43ck34 = 0 time = 350
.meas tran vdout0_43ck34 FIND v(dout0_43) AT=350.05n

* CHECK dout0_44 Vdout0_44ck34 = 0 time = 350
.meas tran vdout0_44ck34 FIND v(dout0_44) AT=350.05n

* CHECK dout0_45 Vdout0_45ck34 = 0 time = 350
.meas tran vdout0_45ck34 FIND v(dout0_45) AT=350.05n

* CHECK dout0_46 Vdout0_46ck34 = 1.8 time = 350
.meas tran vdout0_46ck34 FIND v(dout0_46) AT=350.05n

* CHECK dout0_47 Vdout0_47ck34 = 1.8 time = 350
.meas tran vdout0_47ck34 FIND v(dout0_47) AT=350.05n

* CHECK dout0_48 Vdout0_48ck34 = 1.8 time = 350
.meas tran vdout0_48ck34 FIND v(dout0_48) AT=350.05n

* CHECK dout0_49 Vdout0_49ck34 = 1.8 time = 350
.meas tran vdout0_49ck34 FIND v(dout0_49) AT=350.05n

* CHECK dout0_50 Vdout0_50ck34 = 1.8 time = 350
.meas tran vdout0_50ck34 FIND v(dout0_50) AT=350.05n

* CHECK dout0_51 Vdout0_51ck34 = 1.8 time = 350
.meas tran vdout0_51ck34 FIND v(dout0_51) AT=350.05n

* CHECK dout0_52 Vdout0_52ck34 = 1.8 time = 350
.meas tran vdout0_52ck34 FIND v(dout0_52) AT=350.05n

* CHECK dout0_53 Vdout0_53ck34 = 1.8 time = 350
.meas tran vdout0_53ck34 FIND v(dout0_53) AT=350.05n

* CHECK dout0_54 Vdout0_54ck34 = 0 time = 350
.meas tran vdout0_54ck34 FIND v(dout0_54) AT=350.05n

* CHECK dout0_55 Vdout0_55ck34 = 1.8 time = 350
.meas tran vdout0_55ck34 FIND v(dout0_55) AT=350.05n

* CHECK dout0_56 Vdout0_56ck34 = 0 time = 350
.meas tran vdout0_56ck34 FIND v(dout0_56) AT=350.05n

* CHECK dout0_57 Vdout0_57ck34 = 0 time = 350
.meas tran vdout0_57ck34 FIND v(dout0_57) AT=350.05n

* CHECK dout0_58 Vdout0_58ck34 = 1.8 time = 350
.meas tran vdout0_58ck34 FIND v(dout0_58) AT=350.05n

* CHECK dout0_59 Vdout0_59ck34 = 0 time = 350
.meas tran vdout0_59ck34 FIND v(dout0_59) AT=350.05n

* CHECK dout0_60 Vdout0_60ck34 = 0 time = 350
.meas tran vdout0_60ck34 FIND v(dout0_60) AT=350.05n

* CHECK dout0_61 Vdout0_61ck34 = 0 time = 350
.meas tran vdout0_61ck34 FIND v(dout0_61) AT=350.05n

* CHECK dout0_62 Vdout0_62ck34 = 0 time = 350
.meas tran vdout0_62ck34 FIND v(dout0_62) AT=350.05n

* CHECK dout0_63 Vdout0_63ck34 = 0 time = 350
.meas tran vdout0_63ck34 FIND v(dout0_63) AT=350.05n

* CHECK dout0_64 Vdout0_64ck34 = 0 time = 350
.meas tran vdout0_64ck34 FIND v(dout0_64) AT=350.05n

* CHECK dout0_0 Vdout0_0ck35 = 1.8 time = 360
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=360.05n

* CHECK dout0_1 Vdout0_1ck35 = 0 time = 360
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=360.05n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 360
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=360.05n

* CHECK dout0_3 Vdout0_3ck35 = 0 time = 360
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=360.05n

* CHECK dout0_4 Vdout0_4ck35 = 1.8 time = 360
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=360.05n

* CHECK dout0_5 Vdout0_5ck35 = 1.8 time = 360
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=360.05n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 360
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=360.05n

* CHECK dout0_7 Vdout0_7ck35 = 0 time = 360
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=360.05n

* CHECK dout0_8 Vdout0_8ck35 = 0 time = 360
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=360.05n

* CHECK dout0_9 Vdout0_9ck35 = 0 time = 360
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=360.05n

* CHECK dout0_10 Vdout0_10ck35 = 1.8 time = 360
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=360.05n

* CHECK dout0_11 Vdout0_11ck35 = 0 time = 360
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=360.05n

* CHECK dout0_12 Vdout0_12ck35 = 0 time = 360
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=360.05n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 360
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=360.05n

* CHECK dout0_14 Vdout0_14ck35 = 0 time = 360
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=360.05n

* CHECK dout0_15 Vdout0_15ck35 = 0 time = 360
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=360.05n

* CHECK dout0_16 Vdout0_16ck35 = 1.8 time = 360
.meas tran vdout0_16ck35 FIND v(dout0_16) AT=360.05n

* CHECK dout0_17 Vdout0_17ck35 = 0 time = 360
.meas tran vdout0_17ck35 FIND v(dout0_17) AT=360.05n

* CHECK dout0_18 Vdout0_18ck35 = 0 time = 360
.meas tran vdout0_18ck35 FIND v(dout0_18) AT=360.05n

* CHECK dout0_19 Vdout0_19ck35 = 1.8 time = 360
.meas tran vdout0_19ck35 FIND v(dout0_19) AT=360.05n

* CHECK dout0_20 Vdout0_20ck35 = 1.8 time = 360
.meas tran vdout0_20ck35 FIND v(dout0_20) AT=360.05n

* CHECK dout0_21 Vdout0_21ck35 = 1.8 time = 360
.meas tran vdout0_21ck35 FIND v(dout0_21) AT=360.05n

* CHECK dout0_22 Vdout0_22ck35 = 1.8 time = 360
.meas tran vdout0_22ck35 FIND v(dout0_22) AT=360.05n

* CHECK dout0_23 Vdout0_23ck35 = 1.8 time = 360
.meas tran vdout0_23ck35 FIND v(dout0_23) AT=360.05n

* CHECK dout0_24 Vdout0_24ck35 = 0 time = 360
.meas tran vdout0_24ck35 FIND v(dout0_24) AT=360.05n

* CHECK dout0_25 Vdout0_25ck35 = 0 time = 360
.meas tran vdout0_25ck35 FIND v(dout0_25) AT=360.05n

* CHECK dout0_26 Vdout0_26ck35 = 0 time = 360
.meas tran vdout0_26ck35 FIND v(dout0_26) AT=360.05n

* CHECK dout0_27 Vdout0_27ck35 = 0 time = 360
.meas tran vdout0_27ck35 FIND v(dout0_27) AT=360.05n

* CHECK dout0_28 Vdout0_28ck35 = 0 time = 360
.meas tran vdout0_28ck35 FIND v(dout0_28) AT=360.05n

* CHECK dout0_29 Vdout0_29ck35 = 0 time = 360
.meas tran vdout0_29ck35 FIND v(dout0_29) AT=360.05n

* CHECK dout0_30 Vdout0_30ck35 = 0 time = 360
.meas tran vdout0_30ck35 FIND v(dout0_30) AT=360.05n

* CHECK dout0_31 Vdout0_31ck35 = 0 time = 360
.meas tran vdout0_31ck35 FIND v(dout0_31) AT=360.05n

* CHECK dout0_32 Vdout0_32ck35 = 0 time = 360
.meas tran vdout0_32ck35 FIND v(dout0_32) AT=360.05n

* CHECK dout0_33 Vdout0_33ck35 = 0 time = 360
.meas tran vdout0_33ck35 FIND v(dout0_33) AT=360.05n

* CHECK dout0_34 Vdout0_34ck35 = 0 time = 360
.meas tran vdout0_34ck35 FIND v(dout0_34) AT=360.05n

* CHECK dout0_35 Vdout0_35ck35 = 1.8 time = 360
.meas tran vdout0_35ck35 FIND v(dout0_35) AT=360.05n

* CHECK dout0_36 Vdout0_36ck35 = 0 time = 360
.meas tran vdout0_36ck35 FIND v(dout0_36) AT=360.05n

* CHECK dout0_37 Vdout0_37ck35 = 1.8 time = 360
.meas tran vdout0_37ck35 FIND v(dout0_37) AT=360.05n

* CHECK dout0_38 Vdout0_38ck35 = 0 time = 360
.meas tran vdout0_38ck35 FIND v(dout0_38) AT=360.05n

* CHECK dout0_39 Vdout0_39ck35 = 1.8 time = 360
.meas tran vdout0_39ck35 FIND v(dout0_39) AT=360.05n

* CHECK dout0_40 Vdout0_40ck35 = 1.8 time = 360
.meas tran vdout0_40ck35 FIND v(dout0_40) AT=360.05n

* CHECK dout0_41 Vdout0_41ck35 = 0 time = 360
.meas tran vdout0_41ck35 FIND v(dout0_41) AT=360.05n

* CHECK dout0_42 Vdout0_42ck35 = 1.8 time = 360
.meas tran vdout0_42ck35 FIND v(dout0_42) AT=360.05n

* CHECK dout0_43 Vdout0_43ck35 = 1.8 time = 360
.meas tran vdout0_43ck35 FIND v(dout0_43) AT=360.05n

* CHECK dout0_44 Vdout0_44ck35 = 1.8 time = 360
.meas tran vdout0_44ck35 FIND v(dout0_44) AT=360.05n

* CHECK dout0_45 Vdout0_45ck35 = 0 time = 360
.meas tran vdout0_45ck35 FIND v(dout0_45) AT=360.05n

* CHECK dout0_46 Vdout0_46ck35 = 0 time = 360
.meas tran vdout0_46ck35 FIND v(dout0_46) AT=360.05n

* CHECK dout0_47 Vdout0_47ck35 = 1.8 time = 360
.meas tran vdout0_47ck35 FIND v(dout0_47) AT=360.05n

* CHECK dout0_48 Vdout0_48ck35 = 0 time = 360
.meas tran vdout0_48ck35 FIND v(dout0_48) AT=360.05n

* CHECK dout0_49 Vdout0_49ck35 = 1.8 time = 360
.meas tran vdout0_49ck35 FIND v(dout0_49) AT=360.05n

* CHECK dout0_50 Vdout0_50ck35 = 1.8 time = 360
.meas tran vdout0_50ck35 FIND v(dout0_50) AT=360.05n

* CHECK dout0_51 Vdout0_51ck35 = 1.8 time = 360
.meas tran vdout0_51ck35 FIND v(dout0_51) AT=360.05n

* CHECK dout0_52 Vdout0_52ck35 = 1.8 time = 360
.meas tran vdout0_52ck35 FIND v(dout0_52) AT=360.05n

* CHECK dout0_53 Vdout0_53ck35 = 1.8 time = 360
.meas tran vdout0_53ck35 FIND v(dout0_53) AT=360.05n

* CHECK dout0_54 Vdout0_54ck35 = 1.8 time = 360
.meas tran vdout0_54ck35 FIND v(dout0_54) AT=360.05n

* CHECK dout0_55 Vdout0_55ck35 = 1.8 time = 360
.meas tran vdout0_55ck35 FIND v(dout0_55) AT=360.05n

* CHECK dout0_56 Vdout0_56ck35 = 0 time = 360
.meas tran vdout0_56ck35 FIND v(dout0_56) AT=360.05n

* CHECK dout0_57 Vdout0_57ck35 = 0 time = 360
.meas tran vdout0_57ck35 FIND v(dout0_57) AT=360.05n

* CHECK dout0_58 Vdout0_58ck35 = 1.8 time = 360
.meas tran vdout0_58ck35 FIND v(dout0_58) AT=360.05n

* CHECK dout0_59 Vdout0_59ck35 = 0 time = 360
.meas tran vdout0_59ck35 FIND v(dout0_59) AT=360.05n

* CHECK dout0_60 Vdout0_60ck35 = 0 time = 360
.meas tran vdout0_60ck35 FIND v(dout0_60) AT=360.05n

* CHECK dout0_61 Vdout0_61ck35 = 1.8 time = 360
.meas tran vdout0_61ck35 FIND v(dout0_61) AT=360.05n

* CHECK dout0_62 Vdout0_62ck35 = 1.8 time = 360
.meas tran vdout0_62ck35 FIND v(dout0_62) AT=360.05n

* CHECK dout0_63 Vdout0_63ck35 = 1.8 time = 360
.meas tran vdout0_63ck35 FIND v(dout0_63) AT=360.05n

* CHECK dout0_64 Vdout0_64ck35 = 0 time = 360
.meas tran vdout0_64ck35 FIND v(dout0_64) AT=360.05n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 410
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=410.05n

* CHECK dout0_1 Vdout0_1ck40 = 1.8 time = 410
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=410.05n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 410
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=410.05n

* CHECK dout0_3 Vdout0_3ck40 = 0 time = 410
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=410.05n

* CHECK dout0_4 Vdout0_4ck40 = 1.8 time = 410
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=410.05n

* CHECK dout0_5 Vdout0_5ck40 = 1.8 time = 410
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=410.05n

* CHECK dout0_6 Vdout0_6ck40 = 0 time = 410
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=410.05n

* CHECK dout0_7 Vdout0_7ck40 = 0 time = 410
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=410.05n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 410
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=410.05n

* CHECK dout0_9 Vdout0_9ck40 = 0 time = 410
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=410.05n

* CHECK dout0_10 Vdout0_10ck40 = 0 time = 410
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=410.05n

* CHECK dout0_11 Vdout0_11ck40 = 1.8 time = 410
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=410.05n

* CHECK dout0_12 Vdout0_12ck40 = 0 time = 410
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=410.05n

* CHECK dout0_13 Vdout0_13ck40 = 1.8 time = 410
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=410.05n

* CHECK dout0_14 Vdout0_14ck40 = 1.8 time = 410
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=410.05n

* CHECK dout0_15 Vdout0_15ck40 = 1.8 time = 410
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=410.05n

* CHECK dout0_16 Vdout0_16ck40 = 0 time = 410
.meas tran vdout0_16ck40 FIND v(dout0_16) AT=410.05n

* CHECK dout0_17 Vdout0_17ck40 = 1.8 time = 410
.meas tran vdout0_17ck40 FIND v(dout0_17) AT=410.05n

* CHECK dout0_18 Vdout0_18ck40 = 1.8 time = 410
.meas tran vdout0_18ck40 FIND v(dout0_18) AT=410.05n

* CHECK dout0_19 Vdout0_19ck40 = 1.8 time = 410
.meas tran vdout0_19ck40 FIND v(dout0_19) AT=410.05n

* CHECK dout0_20 Vdout0_20ck40 = 0 time = 410
.meas tran vdout0_20ck40 FIND v(dout0_20) AT=410.05n

* CHECK dout0_21 Vdout0_21ck40 = 0 time = 410
.meas tran vdout0_21ck40 FIND v(dout0_21) AT=410.05n

* CHECK dout0_22 Vdout0_22ck40 = 0 time = 410
.meas tran vdout0_22ck40 FIND v(dout0_22) AT=410.05n

* CHECK dout0_23 Vdout0_23ck40 = 0 time = 410
.meas tran vdout0_23ck40 FIND v(dout0_23) AT=410.05n

* CHECK dout0_24 Vdout0_24ck40 = 0 time = 410
.meas tran vdout0_24ck40 FIND v(dout0_24) AT=410.05n

* CHECK dout0_25 Vdout0_25ck40 = 1.8 time = 410
.meas tran vdout0_25ck40 FIND v(dout0_25) AT=410.05n

* CHECK dout0_26 Vdout0_26ck40 = 1.8 time = 410
.meas tran vdout0_26ck40 FIND v(dout0_26) AT=410.05n

* CHECK dout0_27 Vdout0_27ck40 = 1.8 time = 410
.meas tran vdout0_27ck40 FIND v(dout0_27) AT=410.05n

* CHECK dout0_28 Vdout0_28ck40 = 1.8 time = 410
.meas tran vdout0_28ck40 FIND v(dout0_28) AT=410.05n

* CHECK dout0_29 Vdout0_29ck40 = 1.8 time = 410
.meas tran vdout0_29ck40 FIND v(dout0_29) AT=410.05n

* CHECK dout0_30 Vdout0_30ck40 = 0 time = 410
.meas tran vdout0_30ck40 FIND v(dout0_30) AT=410.05n

* CHECK dout0_31 Vdout0_31ck40 = 1.8 time = 410
.meas tran vdout0_31ck40 FIND v(dout0_31) AT=410.05n

* CHECK dout0_32 Vdout0_32ck40 = 1.8 time = 410
.meas tran vdout0_32ck40 FIND v(dout0_32) AT=410.05n

* CHECK dout0_33 Vdout0_33ck40 = 1.8 time = 410
.meas tran vdout0_33ck40 FIND v(dout0_33) AT=410.05n

* CHECK dout0_34 Vdout0_34ck40 = 1.8 time = 410
.meas tran vdout0_34ck40 FIND v(dout0_34) AT=410.05n

* CHECK dout0_35 Vdout0_35ck40 = 0 time = 410
.meas tran vdout0_35ck40 FIND v(dout0_35) AT=410.05n

* CHECK dout0_36 Vdout0_36ck40 = 1.8 time = 410
.meas tran vdout0_36ck40 FIND v(dout0_36) AT=410.05n

* CHECK dout0_37 Vdout0_37ck40 = 0 time = 410
.meas tran vdout0_37ck40 FIND v(dout0_37) AT=410.05n

* CHECK dout0_38 Vdout0_38ck40 = 1.8 time = 410
.meas tran vdout0_38ck40 FIND v(dout0_38) AT=410.05n

* CHECK dout0_39 Vdout0_39ck40 = 1.8 time = 410
.meas tran vdout0_39ck40 FIND v(dout0_39) AT=410.05n

* CHECK dout0_40 Vdout0_40ck40 = 1.8 time = 410
.meas tran vdout0_40ck40 FIND v(dout0_40) AT=410.05n

* CHECK dout0_41 Vdout0_41ck40 = 0 time = 410
.meas tran vdout0_41ck40 FIND v(dout0_41) AT=410.05n

* CHECK dout0_42 Vdout0_42ck40 = 0 time = 410
.meas tran vdout0_42ck40 FIND v(dout0_42) AT=410.05n

* CHECK dout0_43 Vdout0_43ck40 = 1.8 time = 410
.meas tran vdout0_43ck40 FIND v(dout0_43) AT=410.05n

* CHECK dout0_44 Vdout0_44ck40 = 1.8 time = 410
.meas tran vdout0_44ck40 FIND v(dout0_44) AT=410.05n

* CHECK dout0_45 Vdout0_45ck40 = 0 time = 410
.meas tran vdout0_45ck40 FIND v(dout0_45) AT=410.05n

* CHECK dout0_46 Vdout0_46ck40 = 0 time = 410
.meas tran vdout0_46ck40 FIND v(dout0_46) AT=410.05n

* CHECK dout0_47 Vdout0_47ck40 = 1.8 time = 410
.meas tran vdout0_47ck40 FIND v(dout0_47) AT=410.05n

* CHECK dout0_48 Vdout0_48ck40 = 0 time = 410
.meas tran vdout0_48ck40 FIND v(dout0_48) AT=410.05n

* CHECK dout0_49 Vdout0_49ck40 = 0 time = 410
.meas tran vdout0_49ck40 FIND v(dout0_49) AT=410.05n

* CHECK dout0_50 Vdout0_50ck40 = 0 time = 410
.meas tran vdout0_50ck40 FIND v(dout0_50) AT=410.05n

* CHECK dout0_51 Vdout0_51ck40 = 0 time = 410
.meas tran vdout0_51ck40 FIND v(dout0_51) AT=410.05n

* CHECK dout0_52 Vdout0_52ck40 = 0 time = 410
.meas tran vdout0_52ck40 FIND v(dout0_52) AT=410.05n

* CHECK dout0_53 Vdout0_53ck40 = 0 time = 410
.meas tran vdout0_53ck40 FIND v(dout0_53) AT=410.05n

* CHECK dout0_54 Vdout0_54ck40 = 1.8 time = 410
.meas tran vdout0_54ck40 FIND v(dout0_54) AT=410.05n

* CHECK dout0_55 Vdout0_55ck40 = 0 time = 410
.meas tran vdout0_55ck40 FIND v(dout0_55) AT=410.05n

* CHECK dout0_56 Vdout0_56ck40 = 0 time = 410
.meas tran vdout0_56ck40 FIND v(dout0_56) AT=410.05n

* CHECK dout0_57 Vdout0_57ck40 = 0 time = 410
.meas tran vdout0_57ck40 FIND v(dout0_57) AT=410.05n

* CHECK dout0_58 Vdout0_58ck40 = 0 time = 410
.meas tran vdout0_58ck40 FIND v(dout0_58) AT=410.05n

* CHECK dout0_59 Vdout0_59ck40 = 0 time = 410
.meas tran vdout0_59ck40 FIND v(dout0_59) AT=410.05n

* CHECK dout0_60 Vdout0_60ck40 = 1.8 time = 410
.meas tran vdout0_60ck40 FIND v(dout0_60) AT=410.05n

* CHECK dout0_61 Vdout0_61ck40 = 1.8 time = 410
.meas tran vdout0_61ck40 FIND v(dout0_61) AT=410.05n

* CHECK dout0_62 Vdout0_62ck40 = 0 time = 410
.meas tran vdout0_62ck40 FIND v(dout0_62) AT=410.05n

* CHECK dout0_63 Vdout0_63ck40 = 1.8 time = 410
.meas tran vdout0_63ck40 FIND v(dout0_63) AT=410.05n

* CHECK dout0_64 Vdout0_64ck40 = 0 time = 410
.meas tran vdout0_64ck40 FIND v(dout0_64) AT=410.05n

* CHECK dout0_0 Vdout0_0ck46 = 0 time = 470
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=470.05n

* CHECK dout0_1 Vdout0_1ck46 = 1.8 time = 470
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=470.05n

* CHECK dout0_2 Vdout0_2ck46 = 0 time = 470
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=470.05n

* CHECK dout0_3 Vdout0_3ck46 = 1.8 time = 470
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=470.05n

* CHECK dout0_4 Vdout0_4ck46 = 1.8 time = 470
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=470.05n

* CHECK dout0_5 Vdout0_5ck46 = 1.8 time = 470
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=470.05n

* CHECK dout0_6 Vdout0_6ck46 = 1.8 time = 470
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=470.05n

* CHECK dout0_7 Vdout0_7ck46 = 1.8 time = 470
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=470.05n

* CHECK dout0_8 Vdout0_8ck46 = 1.8 time = 470
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=470.05n

* CHECK dout0_9 Vdout0_9ck46 = 1.8 time = 470
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=470.05n

* CHECK dout0_10 Vdout0_10ck46 = 1.8 time = 470
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=470.05n

* CHECK dout0_11 Vdout0_11ck46 = 0 time = 470
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=470.05n

* CHECK dout0_12 Vdout0_12ck46 = 0 time = 470
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=470.05n

* CHECK dout0_13 Vdout0_13ck46 = 1.8 time = 470
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=470.05n

* CHECK dout0_14 Vdout0_14ck46 = 0 time = 470
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=470.05n

* CHECK dout0_15 Vdout0_15ck46 = 1.8 time = 470
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=470.05n

* CHECK dout0_16 Vdout0_16ck46 = 0 time = 470
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=470.05n

* CHECK dout0_17 Vdout0_17ck46 = 1.8 time = 470
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=470.05n

* CHECK dout0_18 Vdout0_18ck46 = 1.8 time = 470
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=470.05n

* CHECK dout0_19 Vdout0_19ck46 = 1.8 time = 470
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=470.05n

* CHECK dout0_20 Vdout0_20ck46 = 0 time = 470
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=470.05n

* CHECK dout0_21 Vdout0_21ck46 = 0 time = 470
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=470.05n

* CHECK dout0_22 Vdout0_22ck46 = 1.8 time = 470
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=470.05n

* CHECK dout0_23 Vdout0_23ck46 = 1.8 time = 470
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=470.05n

* CHECK dout0_24 Vdout0_24ck46 = 0 time = 470
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=470.05n

* CHECK dout0_25 Vdout0_25ck46 = 0 time = 470
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=470.05n

* CHECK dout0_26 Vdout0_26ck46 = 1.8 time = 470
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=470.05n

* CHECK dout0_27 Vdout0_27ck46 = 0 time = 470
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=470.05n

* CHECK dout0_28 Vdout0_28ck46 = 1.8 time = 470
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=470.05n

* CHECK dout0_29 Vdout0_29ck46 = 0 time = 470
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=470.05n

* CHECK dout0_30 Vdout0_30ck46 = 0 time = 470
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=470.05n

* CHECK dout0_31 Vdout0_31ck46 = 0 time = 470
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=470.05n

* CHECK dout0_32 Vdout0_32ck46 = 1.8 time = 470
.meas tran vdout0_32ck46 FIND v(dout0_32) AT=470.05n

* CHECK dout0_33 Vdout0_33ck46 = 0 time = 470
.meas tran vdout0_33ck46 FIND v(dout0_33) AT=470.05n

* CHECK dout0_34 Vdout0_34ck46 = 0 time = 470
.meas tran vdout0_34ck46 FIND v(dout0_34) AT=470.05n

* CHECK dout0_35 Vdout0_35ck46 = 0 time = 470
.meas tran vdout0_35ck46 FIND v(dout0_35) AT=470.05n

* CHECK dout0_36 Vdout0_36ck46 = 1.8 time = 470
.meas tran vdout0_36ck46 FIND v(dout0_36) AT=470.05n

* CHECK dout0_37 Vdout0_37ck46 = 0 time = 470
.meas tran vdout0_37ck46 FIND v(dout0_37) AT=470.05n

* CHECK dout0_38 Vdout0_38ck46 = 0 time = 470
.meas tran vdout0_38ck46 FIND v(dout0_38) AT=470.05n

* CHECK dout0_39 Vdout0_39ck46 = 1.8 time = 470
.meas tran vdout0_39ck46 FIND v(dout0_39) AT=470.05n

* CHECK dout0_40 Vdout0_40ck46 = 1.8 time = 470
.meas tran vdout0_40ck46 FIND v(dout0_40) AT=470.05n

* CHECK dout0_41 Vdout0_41ck46 = 0 time = 470
.meas tran vdout0_41ck46 FIND v(dout0_41) AT=470.05n

* CHECK dout0_42 Vdout0_42ck46 = 1.8 time = 470
.meas tran vdout0_42ck46 FIND v(dout0_42) AT=470.05n

* CHECK dout0_43 Vdout0_43ck46 = 0 time = 470
.meas tran vdout0_43ck46 FIND v(dout0_43) AT=470.05n

* CHECK dout0_44 Vdout0_44ck46 = 1.8 time = 470
.meas tran vdout0_44ck46 FIND v(dout0_44) AT=470.05n

* CHECK dout0_45 Vdout0_45ck46 = 0 time = 470
.meas tran vdout0_45ck46 FIND v(dout0_45) AT=470.05n

* CHECK dout0_46 Vdout0_46ck46 = 1.8 time = 470
.meas tran vdout0_46ck46 FIND v(dout0_46) AT=470.05n

* CHECK dout0_47 Vdout0_47ck46 = 1.8 time = 470
.meas tran vdout0_47ck46 FIND v(dout0_47) AT=470.05n

* CHECK dout0_48 Vdout0_48ck46 = 1.8 time = 470
.meas tran vdout0_48ck46 FIND v(dout0_48) AT=470.05n

* CHECK dout0_49 Vdout0_49ck46 = 0 time = 470
.meas tran vdout0_49ck46 FIND v(dout0_49) AT=470.05n

* CHECK dout0_50 Vdout0_50ck46 = 1.8 time = 470
.meas tran vdout0_50ck46 FIND v(dout0_50) AT=470.05n

* CHECK dout0_51 Vdout0_51ck46 = 1.8 time = 470
.meas tran vdout0_51ck46 FIND v(dout0_51) AT=470.05n

* CHECK dout0_52 Vdout0_52ck46 = 0 time = 470
.meas tran vdout0_52ck46 FIND v(dout0_52) AT=470.05n

* CHECK dout0_53 Vdout0_53ck46 = 0 time = 470
.meas tran vdout0_53ck46 FIND v(dout0_53) AT=470.05n

* CHECK dout0_54 Vdout0_54ck46 = 0 time = 470
.meas tran vdout0_54ck46 FIND v(dout0_54) AT=470.05n

* CHECK dout0_55 Vdout0_55ck46 = 0 time = 470
.meas tran vdout0_55ck46 FIND v(dout0_55) AT=470.05n

* CHECK dout0_56 Vdout0_56ck46 = 0 time = 470
.meas tran vdout0_56ck46 FIND v(dout0_56) AT=470.05n

* CHECK dout0_57 Vdout0_57ck46 = 0 time = 470
.meas tran vdout0_57ck46 FIND v(dout0_57) AT=470.05n

* CHECK dout0_58 Vdout0_58ck46 = 1.8 time = 470
.meas tran vdout0_58ck46 FIND v(dout0_58) AT=470.05n

* CHECK dout0_59 Vdout0_59ck46 = 1.8 time = 470
.meas tran vdout0_59ck46 FIND v(dout0_59) AT=470.05n

* CHECK dout0_60 Vdout0_60ck46 = 1.8 time = 470
.meas tran vdout0_60ck46 FIND v(dout0_60) AT=470.05n

* CHECK dout0_61 Vdout0_61ck46 = 1.8 time = 470
.meas tran vdout0_61ck46 FIND v(dout0_61) AT=470.05n

* CHECK dout0_62 Vdout0_62ck46 = 1.8 time = 470
.meas tran vdout0_62ck46 FIND v(dout0_62) AT=470.05n

* CHECK dout0_63 Vdout0_63ck46 = 1.8 time = 470
.meas tran vdout0_63ck46 FIND v(dout0_63) AT=470.05n

* CHECK dout0_64 Vdout0_64ck46 = 0 time = 470
.meas tran vdout0_64ck46 FIND v(dout0_64) AT=470.05n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 1.8 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 1.8 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 1.8 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 1.8 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 1.8 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_8 Vdout0_8ck47 = 1.8 time = 480
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=480.05n

* CHECK dout0_9 Vdout0_9ck47 = 1.8 time = 480
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=480.05n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 480
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=480.05n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 480
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=480.05n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 480
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=480.05n

* CHECK dout0_13 Vdout0_13ck47 = 1.8 time = 480
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=480.05n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 480
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=480.05n

* CHECK dout0_15 Vdout0_15ck47 = 1.8 time = 480
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=480.05n

* CHECK dout0_16 Vdout0_16ck47 = 0 time = 480
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=480.05n

* CHECK dout0_17 Vdout0_17ck47 = 1.8 time = 480
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=480.05n

* CHECK dout0_18 Vdout0_18ck47 = 1.8 time = 480
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=480.05n

* CHECK dout0_19 Vdout0_19ck47 = 1.8 time = 480
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=480.05n

* CHECK dout0_20 Vdout0_20ck47 = 0 time = 480
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=480.05n

* CHECK dout0_21 Vdout0_21ck47 = 0 time = 480
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=480.05n

* CHECK dout0_22 Vdout0_22ck47 = 1.8 time = 480
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=480.05n

* CHECK dout0_23 Vdout0_23ck47 = 1.8 time = 480
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=480.05n

* CHECK dout0_24 Vdout0_24ck47 = 0 time = 480
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=480.05n

* CHECK dout0_25 Vdout0_25ck47 = 0 time = 480
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=480.05n

* CHECK dout0_26 Vdout0_26ck47 = 1.8 time = 480
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=480.05n

* CHECK dout0_27 Vdout0_27ck47 = 0 time = 480
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=480.05n

* CHECK dout0_28 Vdout0_28ck47 = 1.8 time = 480
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=480.05n

* CHECK dout0_29 Vdout0_29ck47 = 0 time = 480
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=480.05n

* CHECK dout0_30 Vdout0_30ck47 = 0 time = 480
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=480.05n

* CHECK dout0_31 Vdout0_31ck47 = 0 time = 480
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=480.05n

* CHECK dout0_32 Vdout0_32ck47 = 1.8 time = 480
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=480.05n

* CHECK dout0_33 Vdout0_33ck47 = 0 time = 480
.meas tran vdout0_33ck47 FIND v(dout0_33) AT=480.05n

* CHECK dout0_34 Vdout0_34ck47 = 0 time = 480
.meas tran vdout0_34ck47 FIND v(dout0_34) AT=480.05n

* CHECK dout0_35 Vdout0_35ck47 = 0 time = 480
.meas tran vdout0_35ck47 FIND v(dout0_35) AT=480.05n

* CHECK dout0_36 Vdout0_36ck47 = 1.8 time = 480
.meas tran vdout0_36ck47 FIND v(dout0_36) AT=480.05n

* CHECK dout0_37 Vdout0_37ck47 = 0 time = 480
.meas tran vdout0_37ck47 FIND v(dout0_37) AT=480.05n

* CHECK dout0_38 Vdout0_38ck47 = 0 time = 480
.meas tran vdout0_38ck47 FIND v(dout0_38) AT=480.05n

* CHECK dout0_39 Vdout0_39ck47 = 1.8 time = 480
.meas tran vdout0_39ck47 FIND v(dout0_39) AT=480.05n

* CHECK dout0_40 Vdout0_40ck47 = 1.8 time = 480
.meas tran vdout0_40ck47 FIND v(dout0_40) AT=480.05n

* CHECK dout0_41 Vdout0_41ck47 = 0 time = 480
.meas tran vdout0_41ck47 FIND v(dout0_41) AT=480.05n

* CHECK dout0_42 Vdout0_42ck47 = 1.8 time = 480
.meas tran vdout0_42ck47 FIND v(dout0_42) AT=480.05n

* CHECK dout0_43 Vdout0_43ck47 = 0 time = 480
.meas tran vdout0_43ck47 FIND v(dout0_43) AT=480.05n

* CHECK dout0_44 Vdout0_44ck47 = 1.8 time = 480
.meas tran vdout0_44ck47 FIND v(dout0_44) AT=480.05n

* CHECK dout0_45 Vdout0_45ck47 = 0 time = 480
.meas tran vdout0_45ck47 FIND v(dout0_45) AT=480.05n

* CHECK dout0_46 Vdout0_46ck47 = 1.8 time = 480
.meas tran vdout0_46ck47 FIND v(dout0_46) AT=480.05n

* CHECK dout0_47 Vdout0_47ck47 = 1.8 time = 480
.meas tran vdout0_47ck47 FIND v(dout0_47) AT=480.05n

* CHECK dout0_48 Vdout0_48ck47 = 1.8 time = 480
.meas tran vdout0_48ck47 FIND v(dout0_48) AT=480.05n

* CHECK dout0_49 Vdout0_49ck47 = 0 time = 480
.meas tran vdout0_49ck47 FIND v(dout0_49) AT=480.05n

* CHECK dout0_50 Vdout0_50ck47 = 1.8 time = 480
.meas tran vdout0_50ck47 FIND v(dout0_50) AT=480.05n

* CHECK dout0_51 Vdout0_51ck47 = 1.8 time = 480
.meas tran vdout0_51ck47 FIND v(dout0_51) AT=480.05n

* CHECK dout0_52 Vdout0_52ck47 = 0 time = 480
.meas tran vdout0_52ck47 FIND v(dout0_52) AT=480.05n

* CHECK dout0_53 Vdout0_53ck47 = 0 time = 480
.meas tran vdout0_53ck47 FIND v(dout0_53) AT=480.05n

* CHECK dout0_54 Vdout0_54ck47 = 0 time = 480
.meas tran vdout0_54ck47 FIND v(dout0_54) AT=480.05n

* CHECK dout0_55 Vdout0_55ck47 = 0 time = 480
.meas tran vdout0_55ck47 FIND v(dout0_55) AT=480.05n

* CHECK dout0_56 Vdout0_56ck47 = 0 time = 480
.meas tran vdout0_56ck47 FIND v(dout0_56) AT=480.05n

* CHECK dout0_57 Vdout0_57ck47 = 0 time = 480
.meas tran vdout0_57ck47 FIND v(dout0_57) AT=480.05n

* CHECK dout0_58 Vdout0_58ck47 = 1.8 time = 480
.meas tran vdout0_58ck47 FIND v(dout0_58) AT=480.05n

* CHECK dout0_59 Vdout0_59ck47 = 1.8 time = 480
.meas tran vdout0_59ck47 FIND v(dout0_59) AT=480.05n

* CHECK dout0_60 Vdout0_60ck47 = 1.8 time = 480
.meas tran vdout0_60ck47 FIND v(dout0_60) AT=480.05n

* CHECK dout0_61 Vdout0_61ck47 = 1.8 time = 480
.meas tran vdout0_61ck47 FIND v(dout0_61) AT=480.05n

* CHECK dout0_62 Vdout0_62ck47 = 1.8 time = 480
.meas tran vdout0_62ck47 FIND v(dout0_62) AT=480.05n

* CHECK dout0_63 Vdout0_63ck47 = 1.8 time = 480
.meas tran vdout0_63ck47 FIND v(dout0_63) AT=480.05n

* CHECK dout0_64 Vdout0_64ck47 = 0 time = 480
.meas tran vdout0_64ck47 FIND v(dout0_64) AT=480.05n

* CHECK dout0_0 Vdout0_0ck51 = 1.8 time = 520
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=520.05n

* CHECK dout0_1 Vdout0_1ck51 = 1.8 time = 520
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=520.05n

* CHECK dout0_2 Vdout0_2ck51 = 1.8 time = 520
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=520.05n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 520
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=520.05n

* CHECK dout0_4 Vdout0_4ck51 = 1.8 time = 520
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=520.05n

* CHECK dout0_5 Vdout0_5ck51 = 1.8 time = 520
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=520.05n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 520
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=520.05n

* CHECK dout0_7 Vdout0_7ck51 = 0 time = 520
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=520.05n

* CHECK dout0_8 Vdout0_8ck51 = 1.8 time = 520
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=520.05n

* CHECK dout0_9 Vdout0_9ck51 = 0 time = 520
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=520.05n

* CHECK dout0_10 Vdout0_10ck51 = 1.8 time = 520
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=520.05n

* CHECK dout0_11 Vdout0_11ck51 = 1.8 time = 520
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=520.05n

* CHECK dout0_12 Vdout0_12ck51 = 1.8 time = 520
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=520.05n

* CHECK dout0_13 Vdout0_13ck51 = 1.8 time = 520
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=520.05n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 520
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=520.05n

* CHECK dout0_15 Vdout0_15ck51 = 0 time = 520
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=520.05n

* CHECK dout0_16 Vdout0_16ck51 = 0 time = 520
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=520.05n

* CHECK dout0_17 Vdout0_17ck51 = 0 time = 520
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=520.05n

* CHECK dout0_18 Vdout0_18ck51 = 1.8 time = 520
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=520.05n

* CHECK dout0_19 Vdout0_19ck51 = 1.8 time = 520
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=520.05n

* CHECK dout0_20 Vdout0_20ck51 = 0 time = 520
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=520.05n

* CHECK dout0_21 Vdout0_21ck51 = 1.8 time = 520
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=520.05n

* CHECK dout0_22 Vdout0_22ck51 = 1.8 time = 520
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=520.05n

* CHECK dout0_23 Vdout0_23ck51 = 1.8 time = 520
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=520.05n

* CHECK dout0_24 Vdout0_24ck51 = 0 time = 520
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=520.05n

* CHECK dout0_25 Vdout0_25ck51 = 0 time = 520
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=520.05n

* CHECK dout0_26 Vdout0_26ck51 = 0 time = 520
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=520.05n

* CHECK dout0_27 Vdout0_27ck51 = 0 time = 520
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=520.05n

* CHECK dout0_28 Vdout0_28ck51 = 1.8 time = 520
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=520.05n

* CHECK dout0_29 Vdout0_29ck51 = 0 time = 520
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=520.05n

* CHECK dout0_30 Vdout0_30ck51 = 1.8 time = 520
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=520.05n

* CHECK dout0_31 Vdout0_31ck51 = 0 time = 520
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=520.05n

* CHECK dout0_32 Vdout0_32ck51 = 0 time = 520
.meas tran vdout0_32ck51 FIND v(dout0_32) AT=520.05n

* CHECK dout0_33 Vdout0_33ck51 = 1.8 time = 520
.meas tran vdout0_33ck51 FIND v(dout0_33) AT=520.05n

* CHECK dout0_34 Vdout0_34ck51 = 1.8 time = 520
.meas tran vdout0_34ck51 FIND v(dout0_34) AT=520.05n

* CHECK dout0_35 Vdout0_35ck51 = 0 time = 520
.meas tran vdout0_35ck51 FIND v(dout0_35) AT=520.05n

* CHECK dout0_36 Vdout0_36ck51 = 0 time = 520
.meas tran vdout0_36ck51 FIND v(dout0_36) AT=520.05n

* CHECK dout0_37 Vdout0_37ck51 = 0 time = 520
.meas tran vdout0_37ck51 FIND v(dout0_37) AT=520.05n

* CHECK dout0_38 Vdout0_38ck51 = 1.8 time = 520
.meas tran vdout0_38ck51 FIND v(dout0_38) AT=520.05n

* CHECK dout0_39 Vdout0_39ck51 = 0 time = 520
.meas tran vdout0_39ck51 FIND v(dout0_39) AT=520.05n

* CHECK dout0_40 Vdout0_40ck51 = 0 time = 520
.meas tran vdout0_40ck51 FIND v(dout0_40) AT=520.05n

* CHECK dout0_41 Vdout0_41ck51 = 1.8 time = 520
.meas tran vdout0_41ck51 FIND v(dout0_41) AT=520.05n

* CHECK dout0_42 Vdout0_42ck51 = 1.8 time = 520
.meas tran vdout0_42ck51 FIND v(dout0_42) AT=520.05n

* CHECK dout0_43 Vdout0_43ck51 = 1.8 time = 520
.meas tran vdout0_43ck51 FIND v(dout0_43) AT=520.05n

* CHECK dout0_44 Vdout0_44ck51 = 1.8 time = 520
.meas tran vdout0_44ck51 FIND v(dout0_44) AT=520.05n

* CHECK dout0_45 Vdout0_45ck51 = 0 time = 520
.meas tran vdout0_45ck51 FIND v(dout0_45) AT=520.05n

* CHECK dout0_46 Vdout0_46ck51 = 1.8 time = 520
.meas tran vdout0_46ck51 FIND v(dout0_46) AT=520.05n

* CHECK dout0_47 Vdout0_47ck51 = 0 time = 520
.meas tran vdout0_47ck51 FIND v(dout0_47) AT=520.05n

* CHECK dout0_48 Vdout0_48ck51 = 0 time = 520
.meas tran vdout0_48ck51 FIND v(dout0_48) AT=520.05n

* CHECK dout0_49 Vdout0_49ck51 = 1.8 time = 520
.meas tran vdout0_49ck51 FIND v(dout0_49) AT=520.05n

* CHECK dout0_50 Vdout0_50ck51 = 0 time = 520
.meas tran vdout0_50ck51 FIND v(dout0_50) AT=520.05n

* CHECK dout0_51 Vdout0_51ck51 = 0 time = 520
.meas tran vdout0_51ck51 FIND v(dout0_51) AT=520.05n

* CHECK dout0_52 Vdout0_52ck51 = 0 time = 520
.meas tran vdout0_52ck51 FIND v(dout0_52) AT=520.05n

* CHECK dout0_53 Vdout0_53ck51 = 1.8 time = 520
.meas tran vdout0_53ck51 FIND v(dout0_53) AT=520.05n

* CHECK dout0_54 Vdout0_54ck51 = 1.8 time = 520
.meas tran vdout0_54ck51 FIND v(dout0_54) AT=520.05n

* CHECK dout0_55 Vdout0_55ck51 = 0 time = 520
.meas tran vdout0_55ck51 FIND v(dout0_55) AT=520.05n

* CHECK dout0_56 Vdout0_56ck51 = 1.8 time = 520
.meas tran vdout0_56ck51 FIND v(dout0_56) AT=520.05n

* CHECK dout0_57 Vdout0_57ck51 = 1.8 time = 520
.meas tran vdout0_57ck51 FIND v(dout0_57) AT=520.05n

* CHECK dout0_58 Vdout0_58ck51 = 1.8 time = 520
.meas tran vdout0_58ck51 FIND v(dout0_58) AT=520.05n

* CHECK dout0_59 Vdout0_59ck51 = 1.8 time = 520
.meas tran vdout0_59ck51 FIND v(dout0_59) AT=520.05n

* CHECK dout0_60 Vdout0_60ck51 = 1.8 time = 520
.meas tran vdout0_60ck51 FIND v(dout0_60) AT=520.05n

* CHECK dout0_61 Vdout0_61ck51 = 0 time = 520
.meas tran vdout0_61ck51 FIND v(dout0_61) AT=520.05n

* CHECK dout0_62 Vdout0_62ck51 = 1.8 time = 520
.meas tran vdout0_62ck51 FIND v(dout0_62) AT=520.05n

* CHECK dout0_63 Vdout0_63ck51 = 1.8 time = 520
.meas tran vdout0_63ck51 FIND v(dout0_63) AT=520.05n

* CHECK dout0_64 Vdout0_64ck51 = 0 time = 520
.meas tran vdout0_64ck51 FIND v(dout0_64) AT=520.05n

* CHECK dout0_0 Vdout0_0ck52 = 0 time = 530
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=530.05n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 530
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=530.05n

* CHECK dout0_2 Vdout0_2ck52 = 1.8 time = 530
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=530.05n

* CHECK dout0_3 Vdout0_3ck52 = 0 time = 530
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=530.05n

* CHECK dout0_4 Vdout0_4ck52 = 0 time = 530
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=530.05n

* CHECK dout0_5 Vdout0_5ck52 = 0 time = 530
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=530.05n

* CHECK dout0_6 Vdout0_6ck52 = 0 time = 530
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=530.05n

* CHECK dout0_7 Vdout0_7ck52 = 1.8 time = 530
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=530.05n

* CHECK dout0_8 Vdout0_8ck52 = 0 time = 530
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=530.05n

* CHECK dout0_9 Vdout0_9ck52 = 0 time = 530
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=530.05n

* CHECK dout0_10 Vdout0_10ck52 = 1.8 time = 530
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=530.05n

* CHECK dout0_11 Vdout0_11ck52 = 1.8 time = 530
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=530.05n

* CHECK dout0_12 Vdout0_12ck52 = 1.8 time = 530
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=530.05n

* CHECK dout0_13 Vdout0_13ck52 = 0 time = 530
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=530.05n

* CHECK dout0_14 Vdout0_14ck52 = 1.8 time = 530
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=530.05n

* CHECK dout0_15 Vdout0_15ck52 = 1.8 time = 530
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=530.05n

* CHECK dout0_16 Vdout0_16ck52 = 0 time = 530
.meas tran vdout0_16ck52 FIND v(dout0_16) AT=530.05n

* CHECK dout0_17 Vdout0_17ck52 = 0 time = 530
.meas tran vdout0_17ck52 FIND v(dout0_17) AT=530.05n

* CHECK dout0_18 Vdout0_18ck52 = 0 time = 530
.meas tran vdout0_18ck52 FIND v(dout0_18) AT=530.05n

* CHECK dout0_19 Vdout0_19ck52 = 1.8 time = 530
.meas tran vdout0_19ck52 FIND v(dout0_19) AT=530.05n

* CHECK dout0_20 Vdout0_20ck52 = 0 time = 530
.meas tran vdout0_20ck52 FIND v(dout0_20) AT=530.05n

* CHECK dout0_21 Vdout0_21ck52 = 1.8 time = 530
.meas tran vdout0_21ck52 FIND v(dout0_21) AT=530.05n

* CHECK dout0_22 Vdout0_22ck52 = 0 time = 530
.meas tran vdout0_22ck52 FIND v(dout0_22) AT=530.05n

* CHECK dout0_23 Vdout0_23ck52 = 1.8 time = 530
.meas tran vdout0_23ck52 FIND v(dout0_23) AT=530.05n

* CHECK dout0_24 Vdout0_24ck52 = 1.8 time = 530
.meas tran vdout0_24ck52 FIND v(dout0_24) AT=530.05n

* CHECK dout0_25 Vdout0_25ck52 = 1.8 time = 530
.meas tran vdout0_25ck52 FIND v(dout0_25) AT=530.05n

* CHECK dout0_26 Vdout0_26ck52 = 0 time = 530
.meas tran vdout0_26ck52 FIND v(dout0_26) AT=530.05n

* CHECK dout0_27 Vdout0_27ck52 = 0 time = 530
.meas tran vdout0_27ck52 FIND v(dout0_27) AT=530.05n

* CHECK dout0_28 Vdout0_28ck52 = 1.8 time = 530
.meas tran vdout0_28ck52 FIND v(dout0_28) AT=530.05n

* CHECK dout0_29 Vdout0_29ck52 = 0 time = 530
.meas tran vdout0_29ck52 FIND v(dout0_29) AT=530.05n

* CHECK dout0_30 Vdout0_30ck52 = 1.8 time = 530
.meas tran vdout0_30ck52 FIND v(dout0_30) AT=530.05n

* CHECK dout0_31 Vdout0_31ck52 = 0 time = 530
.meas tran vdout0_31ck52 FIND v(dout0_31) AT=530.05n

* CHECK dout0_32 Vdout0_32ck52 = 1.8 time = 530
.meas tran vdout0_32ck52 FIND v(dout0_32) AT=530.05n

* CHECK dout0_33 Vdout0_33ck52 = 1.8 time = 530
.meas tran vdout0_33ck52 FIND v(dout0_33) AT=530.05n

* CHECK dout0_34 Vdout0_34ck52 = 1.8 time = 530
.meas tran vdout0_34ck52 FIND v(dout0_34) AT=530.05n

* CHECK dout0_35 Vdout0_35ck52 = 0 time = 530
.meas tran vdout0_35ck52 FIND v(dout0_35) AT=530.05n

* CHECK dout0_36 Vdout0_36ck52 = 0 time = 530
.meas tran vdout0_36ck52 FIND v(dout0_36) AT=530.05n

* CHECK dout0_37 Vdout0_37ck52 = 1.8 time = 530
.meas tran vdout0_37ck52 FIND v(dout0_37) AT=530.05n

* CHECK dout0_38 Vdout0_38ck52 = 0 time = 530
.meas tran vdout0_38ck52 FIND v(dout0_38) AT=530.05n

* CHECK dout0_39 Vdout0_39ck52 = 1.8 time = 530
.meas tran vdout0_39ck52 FIND v(dout0_39) AT=530.05n

* CHECK dout0_40 Vdout0_40ck52 = 0 time = 530
.meas tran vdout0_40ck52 FIND v(dout0_40) AT=530.05n

* CHECK dout0_41 Vdout0_41ck52 = 1.8 time = 530
.meas tran vdout0_41ck52 FIND v(dout0_41) AT=530.05n

* CHECK dout0_42 Vdout0_42ck52 = 0 time = 530
.meas tran vdout0_42ck52 FIND v(dout0_42) AT=530.05n

* CHECK dout0_43 Vdout0_43ck52 = 1.8 time = 530
.meas tran vdout0_43ck52 FIND v(dout0_43) AT=530.05n

* CHECK dout0_44 Vdout0_44ck52 = 1.8 time = 530
.meas tran vdout0_44ck52 FIND v(dout0_44) AT=530.05n

* CHECK dout0_45 Vdout0_45ck52 = 1.8 time = 530
.meas tran vdout0_45ck52 FIND v(dout0_45) AT=530.05n

* CHECK dout0_46 Vdout0_46ck52 = 0 time = 530
.meas tran vdout0_46ck52 FIND v(dout0_46) AT=530.05n

* CHECK dout0_47 Vdout0_47ck52 = 0 time = 530
.meas tran vdout0_47ck52 FIND v(dout0_47) AT=530.05n

* CHECK dout0_48 Vdout0_48ck52 = 1.8 time = 530
.meas tran vdout0_48ck52 FIND v(dout0_48) AT=530.05n

* CHECK dout0_49 Vdout0_49ck52 = 1.8 time = 530
.meas tran vdout0_49ck52 FIND v(dout0_49) AT=530.05n

* CHECK dout0_50 Vdout0_50ck52 = 1.8 time = 530
.meas tran vdout0_50ck52 FIND v(dout0_50) AT=530.05n

* CHECK dout0_51 Vdout0_51ck52 = 1.8 time = 530
.meas tran vdout0_51ck52 FIND v(dout0_51) AT=530.05n

* CHECK dout0_52 Vdout0_52ck52 = 1.8 time = 530
.meas tran vdout0_52ck52 FIND v(dout0_52) AT=530.05n

* CHECK dout0_53 Vdout0_53ck52 = 1.8 time = 530
.meas tran vdout0_53ck52 FIND v(dout0_53) AT=530.05n

* CHECK dout0_54 Vdout0_54ck52 = 0 time = 530
.meas tran vdout0_54ck52 FIND v(dout0_54) AT=530.05n

* CHECK dout0_55 Vdout0_55ck52 = 0 time = 530
.meas tran vdout0_55ck52 FIND v(dout0_55) AT=530.05n

* CHECK dout0_56 Vdout0_56ck52 = 0 time = 530
.meas tran vdout0_56ck52 FIND v(dout0_56) AT=530.05n

* CHECK dout0_57 Vdout0_57ck52 = 0 time = 530
.meas tran vdout0_57ck52 FIND v(dout0_57) AT=530.05n

* CHECK dout0_58 Vdout0_58ck52 = 0 time = 530
.meas tran vdout0_58ck52 FIND v(dout0_58) AT=530.05n

* CHECK dout0_59 Vdout0_59ck52 = 1.8 time = 530
.meas tran vdout0_59ck52 FIND v(dout0_59) AT=530.05n

* CHECK dout0_60 Vdout0_60ck52 = 0 time = 530
.meas tran vdout0_60ck52 FIND v(dout0_60) AT=530.05n

* CHECK dout0_61 Vdout0_61ck52 = 0 time = 530
.meas tran vdout0_61ck52 FIND v(dout0_61) AT=530.05n

* CHECK dout0_62 Vdout0_62ck52 = 1.8 time = 530
.meas tran vdout0_62ck52 FIND v(dout0_62) AT=530.05n

* CHECK dout0_63 Vdout0_63ck52 = 0 time = 530
.meas tran vdout0_63ck52 FIND v(dout0_63) AT=530.05n

* CHECK dout0_64 Vdout0_64ck52 = 0 time = 530
.meas tran vdout0_64ck52 FIND v(dout0_64) AT=530.05n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 540
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=540.05n

* CHECK dout0_1 Vdout0_1ck53 = 0 time = 540
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=540.05n

* CHECK dout0_2 Vdout0_2ck53 = 1.8 time = 540
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=540.05n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 540
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=540.05n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 540
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=540.05n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 540
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=540.05n

* CHECK dout0_6 Vdout0_6ck53 = 1.8 time = 540
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=540.05n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 540
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=540.05n

* CHECK dout0_8 Vdout0_8ck53 = 1.8 time = 540
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=540.05n

* CHECK dout0_9 Vdout0_9ck53 = 1.8 time = 540
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=540.05n

* CHECK dout0_10 Vdout0_10ck53 = 1.8 time = 540
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=540.05n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 540
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=540.05n

* CHECK dout0_12 Vdout0_12ck53 = 0 time = 540
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=540.05n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 540
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=540.05n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 540
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=540.05n

* CHECK dout0_15 Vdout0_15ck53 = 1.8 time = 540
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=540.05n

* CHECK dout0_16 Vdout0_16ck53 = 1.8 time = 540
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=540.05n

* CHECK dout0_17 Vdout0_17ck53 = 0 time = 540
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=540.05n

* CHECK dout0_18 Vdout0_18ck53 = 1.8 time = 540
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=540.05n

* CHECK dout0_19 Vdout0_19ck53 = 1.8 time = 540
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=540.05n

* CHECK dout0_20 Vdout0_20ck53 = 0 time = 540
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=540.05n

* CHECK dout0_21 Vdout0_21ck53 = 0 time = 540
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=540.05n

* CHECK dout0_22 Vdout0_22ck53 = 0 time = 540
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=540.05n

* CHECK dout0_23 Vdout0_23ck53 = 1.8 time = 540
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=540.05n

* CHECK dout0_24 Vdout0_24ck53 = 0 time = 540
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=540.05n

* CHECK dout0_25 Vdout0_25ck53 = 1.8 time = 540
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=540.05n

* CHECK dout0_26 Vdout0_26ck53 = 1.8 time = 540
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=540.05n

* CHECK dout0_27 Vdout0_27ck53 = 1.8 time = 540
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=540.05n

* CHECK dout0_28 Vdout0_28ck53 = 0 time = 540
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=540.05n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 540
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=540.05n

* CHECK dout0_30 Vdout0_30ck53 = 0 time = 540
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=540.05n

* CHECK dout0_31 Vdout0_31ck53 = 1.8 time = 540
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=540.05n

* CHECK dout0_32 Vdout0_32ck53 = 1.8 time = 540
.meas tran vdout0_32ck53 FIND v(dout0_32) AT=540.05n

* CHECK dout0_33 Vdout0_33ck53 = 1.8 time = 540
.meas tran vdout0_33ck53 FIND v(dout0_33) AT=540.05n

* CHECK dout0_34 Vdout0_34ck53 = 1.8 time = 540
.meas tran vdout0_34ck53 FIND v(dout0_34) AT=540.05n

* CHECK dout0_35 Vdout0_35ck53 = 1.8 time = 540
.meas tran vdout0_35ck53 FIND v(dout0_35) AT=540.05n

* CHECK dout0_36 Vdout0_36ck53 = 1.8 time = 540
.meas tran vdout0_36ck53 FIND v(dout0_36) AT=540.05n

* CHECK dout0_37 Vdout0_37ck53 = 0 time = 540
.meas tran vdout0_37ck53 FIND v(dout0_37) AT=540.05n

* CHECK dout0_38 Vdout0_38ck53 = 1.8 time = 540
.meas tran vdout0_38ck53 FIND v(dout0_38) AT=540.05n

* CHECK dout0_39 Vdout0_39ck53 = 1.8 time = 540
.meas tran vdout0_39ck53 FIND v(dout0_39) AT=540.05n

* CHECK dout0_40 Vdout0_40ck53 = 0 time = 540
.meas tran vdout0_40ck53 FIND v(dout0_40) AT=540.05n

* CHECK dout0_41 Vdout0_41ck53 = 1.8 time = 540
.meas tran vdout0_41ck53 FIND v(dout0_41) AT=540.05n

* CHECK dout0_42 Vdout0_42ck53 = 0 time = 540
.meas tran vdout0_42ck53 FIND v(dout0_42) AT=540.05n

* CHECK dout0_43 Vdout0_43ck53 = 0 time = 540
.meas tran vdout0_43ck53 FIND v(dout0_43) AT=540.05n

* CHECK dout0_44 Vdout0_44ck53 = 1.8 time = 540
.meas tran vdout0_44ck53 FIND v(dout0_44) AT=540.05n

* CHECK dout0_45 Vdout0_45ck53 = 0 time = 540
.meas tran vdout0_45ck53 FIND v(dout0_45) AT=540.05n

* CHECK dout0_46 Vdout0_46ck53 = 1.8 time = 540
.meas tran vdout0_46ck53 FIND v(dout0_46) AT=540.05n

* CHECK dout0_47 Vdout0_47ck53 = 0 time = 540
.meas tran vdout0_47ck53 FIND v(dout0_47) AT=540.05n

* CHECK dout0_48 Vdout0_48ck53 = 0 time = 540
.meas tran vdout0_48ck53 FIND v(dout0_48) AT=540.05n

* CHECK dout0_49 Vdout0_49ck53 = 1.8 time = 540
.meas tran vdout0_49ck53 FIND v(dout0_49) AT=540.05n

* CHECK dout0_50 Vdout0_50ck53 = 0 time = 540
.meas tran vdout0_50ck53 FIND v(dout0_50) AT=540.05n

* CHECK dout0_51 Vdout0_51ck53 = 1.8 time = 540
.meas tran vdout0_51ck53 FIND v(dout0_51) AT=540.05n

* CHECK dout0_52 Vdout0_52ck53 = 1.8 time = 540
.meas tran vdout0_52ck53 FIND v(dout0_52) AT=540.05n

* CHECK dout0_53 Vdout0_53ck53 = 1.8 time = 540
.meas tran vdout0_53ck53 FIND v(dout0_53) AT=540.05n

* CHECK dout0_54 Vdout0_54ck53 = 1.8 time = 540
.meas tran vdout0_54ck53 FIND v(dout0_54) AT=540.05n

* CHECK dout0_55 Vdout0_55ck53 = 0 time = 540
.meas tran vdout0_55ck53 FIND v(dout0_55) AT=540.05n

* CHECK dout0_56 Vdout0_56ck53 = 1.8 time = 540
.meas tran vdout0_56ck53 FIND v(dout0_56) AT=540.05n

* CHECK dout0_57 Vdout0_57ck53 = 1.8 time = 540
.meas tran vdout0_57ck53 FIND v(dout0_57) AT=540.05n

* CHECK dout0_58 Vdout0_58ck53 = 0 time = 540
.meas tran vdout0_58ck53 FIND v(dout0_58) AT=540.05n

* CHECK dout0_59 Vdout0_59ck53 = 1.8 time = 540
.meas tran vdout0_59ck53 FIND v(dout0_59) AT=540.05n

* CHECK dout0_60 Vdout0_60ck53 = 1.8 time = 540
.meas tran vdout0_60ck53 FIND v(dout0_60) AT=540.05n

* CHECK dout0_61 Vdout0_61ck53 = 1.8 time = 540
.meas tran vdout0_61ck53 FIND v(dout0_61) AT=540.05n

* CHECK dout0_62 Vdout0_62ck53 = 0 time = 540
.meas tran vdout0_62ck53 FIND v(dout0_62) AT=540.05n

* CHECK dout0_63 Vdout0_63ck53 = 1.8 time = 540
.meas tran vdout0_63ck53 FIND v(dout0_63) AT=540.05n

* CHECK dout0_64 Vdout0_64ck53 = 0 time = 540
.meas tran vdout0_64ck53 FIND v(dout0_64) AT=540.05n

* CHECK dout0_0 Vdout0_0ck59 = 1.8 time = 600
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=600.05n

* CHECK dout0_1 Vdout0_1ck59 = 1.8 time = 600
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=600.05n

* CHECK dout0_2 Vdout0_2ck59 = 0 time = 600
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=600.05n

* CHECK dout0_3 Vdout0_3ck59 = 0 time = 600
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=600.05n

* CHECK dout0_4 Vdout0_4ck59 = 1.8 time = 600
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=600.05n

* CHECK dout0_5 Vdout0_5ck59 = 1.8 time = 600
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=600.05n

* CHECK dout0_6 Vdout0_6ck59 = 0 time = 600
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=600.05n

* CHECK dout0_7 Vdout0_7ck59 = 0 time = 600
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=600.05n

* CHECK dout0_8 Vdout0_8ck59 = 1.8 time = 600
.meas tran vdout0_8ck59 FIND v(dout0_8) AT=600.05n

* CHECK dout0_9 Vdout0_9ck59 = 1.8 time = 600
.meas tran vdout0_9ck59 FIND v(dout0_9) AT=600.05n

* CHECK dout0_10 Vdout0_10ck59 = 0 time = 600
.meas tran vdout0_10ck59 FIND v(dout0_10) AT=600.05n

* CHECK dout0_11 Vdout0_11ck59 = 1.8 time = 600
.meas tran vdout0_11ck59 FIND v(dout0_11) AT=600.05n

* CHECK dout0_12 Vdout0_12ck59 = 0 time = 600
.meas tran vdout0_12ck59 FIND v(dout0_12) AT=600.05n

* CHECK dout0_13 Vdout0_13ck59 = 1.8 time = 600
.meas tran vdout0_13ck59 FIND v(dout0_13) AT=600.05n

* CHECK dout0_14 Vdout0_14ck59 = 1.8 time = 600
.meas tran vdout0_14ck59 FIND v(dout0_14) AT=600.05n

* CHECK dout0_15 Vdout0_15ck59 = 1.8 time = 600
.meas tran vdout0_15ck59 FIND v(dout0_15) AT=600.05n

* CHECK dout0_16 Vdout0_16ck59 = 1.8 time = 600
.meas tran vdout0_16ck59 FIND v(dout0_16) AT=600.05n

* CHECK dout0_17 Vdout0_17ck59 = 0 time = 600
.meas tran vdout0_17ck59 FIND v(dout0_17) AT=600.05n

* CHECK dout0_18 Vdout0_18ck59 = 0 time = 600
.meas tran vdout0_18ck59 FIND v(dout0_18) AT=600.05n

* CHECK dout0_19 Vdout0_19ck59 = 0 time = 600
.meas tran vdout0_19ck59 FIND v(dout0_19) AT=600.05n

* CHECK dout0_20 Vdout0_20ck59 = 1.8 time = 600
.meas tran vdout0_20ck59 FIND v(dout0_20) AT=600.05n

* CHECK dout0_21 Vdout0_21ck59 = 1.8 time = 600
.meas tran vdout0_21ck59 FIND v(dout0_21) AT=600.05n

* CHECK dout0_22 Vdout0_22ck59 = 1.8 time = 600
.meas tran vdout0_22ck59 FIND v(dout0_22) AT=600.05n

* CHECK dout0_23 Vdout0_23ck59 = 0 time = 600
.meas tran vdout0_23ck59 FIND v(dout0_23) AT=600.05n

* CHECK dout0_24 Vdout0_24ck59 = 1.8 time = 600
.meas tran vdout0_24ck59 FIND v(dout0_24) AT=600.05n

* CHECK dout0_25 Vdout0_25ck59 = 1.8 time = 600
.meas tran vdout0_25ck59 FIND v(dout0_25) AT=600.05n

* CHECK dout0_26 Vdout0_26ck59 = 0 time = 600
.meas tran vdout0_26ck59 FIND v(dout0_26) AT=600.05n

* CHECK dout0_27 Vdout0_27ck59 = 0 time = 600
.meas tran vdout0_27ck59 FIND v(dout0_27) AT=600.05n

* CHECK dout0_28 Vdout0_28ck59 = 0 time = 600
.meas tran vdout0_28ck59 FIND v(dout0_28) AT=600.05n

* CHECK dout0_29 Vdout0_29ck59 = 1.8 time = 600
.meas tran vdout0_29ck59 FIND v(dout0_29) AT=600.05n

* CHECK dout0_30 Vdout0_30ck59 = 1.8 time = 600
.meas tran vdout0_30ck59 FIND v(dout0_30) AT=600.05n

* CHECK dout0_31 Vdout0_31ck59 = 0 time = 600
.meas tran vdout0_31ck59 FIND v(dout0_31) AT=600.05n

* CHECK dout0_32 Vdout0_32ck59 = 1.8 time = 600
.meas tran vdout0_32ck59 FIND v(dout0_32) AT=600.05n

* CHECK dout0_33 Vdout0_33ck59 = 0 time = 600
.meas tran vdout0_33ck59 FIND v(dout0_33) AT=600.05n

* CHECK dout0_34 Vdout0_34ck59 = 0 time = 600
.meas tran vdout0_34ck59 FIND v(dout0_34) AT=600.05n

* CHECK dout0_35 Vdout0_35ck59 = 1.8 time = 600
.meas tran vdout0_35ck59 FIND v(dout0_35) AT=600.05n

* CHECK dout0_36 Vdout0_36ck59 = 0 time = 600
.meas tran vdout0_36ck59 FIND v(dout0_36) AT=600.05n

* CHECK dout0_37 Vdout0_37ck59 = 0 time = 600
.meas tran vdout0_37ck59 FIND v(dout0_37) AT=600.05n

* CHECK dout0_38 Vdout0_38ck59 = 0 time = 600
.meas tran vdout0_38ck59 FIND v(dout0_38) AT=600.05n

* CHECK dout0_39 Vdout0_39ck59 = 1.8 time = 600
.meas tran vdout0_39ck59 FIND v(dout0_39) AT=600.05n

* CHECK dout0_40 Vdout0_40ck59 = 0 time = 600
.meas tran vdout0_40ck59 FIND v(dout0_40) AT=600.05n

* CHECK dout0_41 Vdout0_41ck59 = 1.8 time = 600
.meas tran vdout0_41ck59 FIND v(dout0_41) AT=600.05n

* CHECK dout0_42 Vdout0_42ck59 = 0 time = 600
.meas tran vdout0_42ck59 FIND v(dout0_42) AT=600.05n

* CHECK dout0_43 Vdout0_43ck59 = 1.8 time = 600
.meas tran vdout0_43ck59 FIND v(dout0_43) AT=600.05n

* CHECK dout0_44 Vdout0_44ck59 = 1.8 time = 600
.meas tran vdout0_44ck59 FIND v(dout0_44) AT=600.05n

* CHECK dout0_45 Vdout0_45ck59 = 1.8 time = 600
.meas tran vdout0_45ck59 FIND v(dout0_45) AT=600.05n

* CHECK dout0_46 Vdout0_46ck59 = 0 time = 600
.meas tran vdout0_46ck59 FIND v(dout0_46) AT=600.05n

* CHECK dout0_47 Vdout0_47ck59 = 0 time = 600
.meas tran vdout0_47ck59 FIND v(dout0_47) AT=600.05n

* CHECK dout0_48 Vdout0_48ck59 = 1.8 time = 600
.meas tran vdout0_48ck59 FIND v(dout0_48) AT=600.05n

* CHECK dout0_49 Vdout0_49ck59 = 0 time = 600
.meas tran vdout0_49ck59 FIND v(dout0_49) AT=600.05n

* CHECK dout0_50 Vdout0_50ck59 = 1.8 time = 600
.meas tran vdout0_50ck59 FIND v(dout0_50) AT=600.05n

* CHECK dout0_51 Vdout0_51ck59 = 1.8 time = 600
.meas tran vdout0_51ck59 FIND v(dout0_51) AT=600.05n

* CHECK dout0_52 Vdout0_52ck59 = 0 time = 600
.meas tran vdout0_52ck59 FIND v(dout0_52) AT=600.05n

* CHECK dout0_53 Vdout0_53ck59 = 1.8 time = 600
.meas tran vdout0_53ck59 FIND v(dout0_53) AT=600.05n

* CHECK dout0_54 Vdout0_54ck59 = 1.8 time = 600
.meas tran vdout0_54ck59 FIND v(dout0_54) AT=600.05n

* CHECK dout0_55 Vdout0_55ck59 = 1.8 time = 600
.meas tran vdout0_55ck59 FIND v(dout0_55) AT=600.05n

* CHECK dout0_56 Vdout0_56ck59 = 0 time = 600
.meas tran vdout0_56ck59 FIND v(dout0_56) AT=600.05n

* CHECK dout0_57 Vdout0_57ck59 = 1.8 time = 600
.meas tran vdout0_57ck59 FIND v(dout0_57) AT=600.05n

* CHECK dout0_58 Vdout0_58ck59 = 0 time = 600
.meas tran vdout0_58ck59 FIND v(dout0_58) AT=600.05n

* CHECK dout0_59 Vdout0_59ck59 = 1.8 time = 600
.meas tran vdout0_59ck59 FIND v(dout0_59) AT=600.05n

* CHECK dout0_60 Vdout0_60ck59 = 1.8 time = 600
.meas tran vdout0_60ck59 FIND v(dout0_60) AT=600.05n

* CHECK dout0_61 Vdout0_61ck59 = 0 time = 600
.meas tran vdout0_61ck59 FIND v(dout0_61) AT=600.05n

* CHECK dout0_62 Vdout0_62ck59 = 1.8 time = 600
.meas tran vdout0_62ck59 FIND v(dout0_62) AT=600.05n

* CHECK dout0_63 Vdout0_63ck59 = 1.8 time = 600
.meas tran vdout0_63ck59 FIND v(dout0_63) AT=600.05n

* CHECK dout0_64 Vdout0_64ck59 = 0 time = 600
.meas tran vdout0_64ck59 FIND v(dout0_64) AT=600.05n

* CHECK dout0_0 Vdout0_0ck60 = 0 time = 610
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=610.05n

* CHECK dout0_1 Vdout0_1ck60 = 0 time = 610
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=610.05n

* CHECK dout0_2 Vdout0_2ck60 = 0 time = 610
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=610.05n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 610
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=610.05n

* CHECK dout0_4 Vdout0_4ck60 = 1.8 time = 610
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=610.05n

* CHECK dout0_5 Vdout0_5ck60 = 1.8 time = 610
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=610.05n

* CHECK dout0_6 Vdout0_6ck60 = 1.8 time = 610
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=610.05n

* CHECK dout0_7 Vdout0_7ck60 = 0 time = 610
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=610.05n

* CHECK dout0_8 Vdout0_8ck60 = 0 time = 610
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=610.05n

* CHECK dout0_9 Vdout0_9ck60 = 0 time = 610
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=610.05n

* CHECK dout0_10 Vdout0_10ck60 = 1.8 time = 610
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=610.05n

* CHECK dout0_11 Vdout0_11ck60 = 0 time = 610
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=610.05n

* CHECK dout0_12 Vdout0_12ck60 = 0 time = 610
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=610.05n

* CHECK dout0_13 Vdout0_13ck60 = 0 time = 610
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=610.05n

* CHECK dout0_14 Vdout0_14ck60 = 0 time = 610
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=610.05n

* CHECK dout0_15 Vdout0_15ck60 = 0 time = 610
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=610.05n

* CHECK dout0_16 Vdout0_16ck60 = 1.8 time = 610
.meas tran vdout0_16ck60 FIND v(dout0_16) AT=610.05n

* CHECK dout0_17 Vdout0_17ck60 = 0 time = 610
.meas tran vdout0_17ck60 FIND v(dout0_17) AT=610.05n

* CHECK dout0_18 Vdout0_18ck60 = 0 time = 610
.meas tran vdout0_18ck60 FIND v(dout0_18) AT=610.05n

* CHECK dout0_19 Vdout0_19ck60 = 1.8 time = 610
.meas tran vdout0_19ck60 FIND v(dout0_19) AT=610.05n

* CHECK dout0_20 Vdout0_20ck60 = 1.8 time = 610
.meas tran vdout0_20ck60 FIND v(dout0_20) AT=610.05n

* CHECK dout0_21 Vdout0_21ck60 = 0 time = 610
.meas tran vdout0_21ck60 FIND v(dout0_21) AT=610.05n

* CHECK dout0_22 Vdout0_22ck60 = 0 time = 610
.meas tran vdout0_22ck60 FIND v(dout0_22) AT=610.05n

* CHECK dout0_23 Vdout0_23ck60 = 1.8 time = 610
.meas tran vdout0_23ck60 FIND v(dout0_23) AT=610.05n

* CHECK dout0_24 Vdout0_24ck60 = 1.8 time = 610
.meas tran vdout0_24ck60 FIND v(dout0_24) AT=610.05n

* CHECK dout0_25 Vdout0_25ck60 = 1.8 time = 610
.meas tran vdout0_25ck60 FIND v(dout0_25) AT=610.05n

* CHECK dout0_26 Vdout0_26ck60 = 1.8 time = 610
.meas tran vdout0_26ck60 FIND v(dout0_26) AT=610.05n

* CHECK dout0_27 Vdout0_27ck60 = 0 time = 610
.meas tran vdout0_27ck60 FIND v(dout0_27) AT=610.05n

* CHECK dout0_28 Vdout0_28ck60 = 0 time = 610
.meas tran vdout0_28ck60 FIND v(dout0_28) AT=610.05n

* CHECK dout0_29 Vdout0_29ck60 = 0 time = 610
.meas tran vdout0_29ck60 FIND v(dout0_29) AT=610.05n

* CHECK dout0_30 Vdout0_30ck60 = 1.8 time = 610
.meas tran vdout0_30ck60 FIND v(dout0_30) AT=610.05n

* CHECK dout0_31 Vdout0_31ck60 = 0 time = 610
.meas tran vdout0_31ck60 FIND v(dout0_31) AT=610.05n

* CHECK dout0_32 Vdout0_32ck60 = 0 time = 610
.meas tran vdout0_32ck60 FIND v(dout0_32) AT=610.05n

* CHECK dout0_33 Vdout0_33ck60 = 0 time = 610
.meas tran vdout0_33ck60 FIND v(dout0_33) AT=610.05n

* CHECK dout0_34 Vdout0_34ck60 = 0 time = 610
.meas tran vdout0_34ck60 FIND v(dout0_34) AT=610.05n

* CHECK dout0_35 Vdout0_35ck60 = 0 time = 610
.meas tran vdout0_35ck60 FIND v(dout0_35) AT=610.05n

* CHECK dout0_36 Vdout0_36ck60 = 1.8 time = 610
.meas tran vdout0_36ck60 FIND v(dout0_36) AT=610.05n

* CHECK dout0_37 Vdout0_37ck60 = 1.8 time = 610
.meas tran vdout0_37ck60 FIND v(dout0_37) AT=610.05n

* CHECK dout0_38 Vdout0_38ck60 = 1.8 time = 610
.meas tran vdout0_38ck60 FIND v(dout0_38) AT=610.05n

* CHECK dout0_39 Vdout0_39ck60 = 1.8 time = 610
.meas tran vdout0_39ck60 FIND v(dout0_39) AT=610.05n

* CHECK dout0_40 Vdout0_40ck60 = 1.8 time = 610
.meas tran vdout0_40ck60 FIND v(dout0_40) AT=610.05n

* CHECK dout0_41 Vdout0_41ck60 = 0 time = 610
.meas tran vdout0_41ck60 FIND v(dout0_41) AT=610.05n

* CHECK dout0_42 Vdout0_42ck60 = 0 time = 610
.meas tran vdout0_42ck60 FIND v(dout0_42) AT=610.05n

* CHECK dout0_43 Vdout0_43ck60 = 0 time = 610
.meas tran vdout0_43ck60 FIND v(dout0_43) AT=610.05n

* CHECK dout0_44 Vdout0_44ck60 = 0 time = 610
.meas tran vdout0_44ck60 FIND v(dout0_44) AT=610.05n

* CHECK dout0_45 Vdout0_45ck60 = 1.8 time = 610
.meas tran vdout0_45ck60 FIND v(dout0_45) AT=610.05n

* CHECK dout0_46 Vdout0_46ck60 = 1.8 time = 610
.meas tran vdout0_46ck60 FIND v(dout0_46) AT=610.05n

* CHECK dout0_47 Vdout0_47ck60 = 0 time = 610
.meas tran vdout0_47ck60 FIND v(dout0_47) AT=610.05n

* CHECK dout0_48 Vdout0_48ck60 = 1.8 time = 610
.meas tran vdout0_48ck60 FIND v(dout0_48) AT=610.05n

* CHECK dout0_49 Vdout0_49ck60 = 1.8 time = 610
.meas tran vdout0_49ck60 FIND v(dout0_49) AT=610.05n

* CHECK dout0_50 Vdout0_50ck60 = 1.8 time = 610
.meas tran vdout0_50ck60 FIND v(dout0_50) AT=610.05n

* CHECK dout0_51 Vdout0_51ck60 = 1.8 time = 610
.meas tran vdout0_51ck60 FIND v(dout0_51) AT=610.05n

* CHECK dout0_52 Vdout0_52ck60 = 1.8 time = 610
.meas tran vdout0_52ck60 FIND v(dout0_52) AT=610.05n

* CHECK dout0_53 Vdout0_53ck60 = 1.8 time = 610
.meas tran vdout0_53ck60 FIND v(dout0_53) AT=610.05n

* CHECK dout0_54 Vdout0_54ck60 = 1.8 time = 610
.meas tran vdout0_54ck60 FIND v(dout0_54) AT=610.05n

* CHECK dout0_55 Vdout0_55ck60 = 1.8 time = 610
.meas tran vdout0_55ck60 FIND v(dout0_55) AT=610.05n

* CHECK dout0_56 Vdout0_56ck60 = 0 time = 610
.meas tran vdout0_56ck60 FIND v(dout0_56) AT=610.05n

* CHECK dout0_57 Vdout0_57ck60 = 0 time = 610
.meas tran vdout0_57ck60 FIND v(dout0_57) AT=610.05n

* CHECK dout0_58 Vdout0_58ck60 = 1.8 time = 610
.meas tran vdout0_58ck60 FIND v(dout0_58) AT=610.05n

* CHECK dout0_59 Vdout0_59ck60 = 0 time = 610
.meas tran vdout0_59ck60 FIND v(dout0_59) AT=610.05n

* CHECK dout0_60 Vdout0_60ck60 = 0 time = 610
.meas tran vdout0_60ck60 FIND v(dout0_60) AT=610.05n

* CHECK dout0_61 Vdout0_61ck60 = 1.8 time = 610
.meas tran vdout0_61ck60 FIND v(dout0_61) AT=610.05n

* CHECK dout0_62 Vdout0_62ck60 = 1.8 time = 610
.meas tran vdout0_62ck60 FIND v(dout0_62) AT=610.05n

* CHECK dout0_63 Vdout0_63ck60 = 1.8 time = 610
.meas tran vdout0_63ck60 FIND v(dout0_63) AT=610.05n

* CHECK dout0_64 Vdout0_64ck60 = 0 time = 610
.meas tran vdout0_64ck60 FIND v(dout0_64) AT=610.05n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 630
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=630.05n

* CHECK dout0_1 Vdout0_1ck62 = 0 time = 630
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=630.05n

* CHECK dout0_2 Vdout0_2ck62 = 1.8 time = 630
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=630.05n

* CHECK dout0_3 Vdout0_3ck62 = 1.8 time = 630
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=630.05n

* CHECK dout0_4 Vdout0_4ck62 = 0 time = 630
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=630.05n

* CHECK dout0_5 Vdout0_5ck62 = 1.8 time = 630
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=630.05n

* CHECK dout0_6 Vdout0_6ck62 = 0 time = 630
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=630.05n

* CHECK dout0_7 Vdout0_7ck62 = 1.8 time = 630
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=630.05n

* CHECK dout0_8 Vdout0_8ck62 = 1.8 time = 630
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=630.05n

* CHECK dout0_9 Vdout0_9ck62 = 1.8 time = 630
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=630.05n

* CHECK dout0_10 Vdout0_10ck62 = 1.8 time = 630
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=630.05n

* CHECK dout0_11 Vdout0_11ck62 = 0 time = 630
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=630.05n

* CHECK dout0_12 Vdout0_12ck62 = 0 time = 630
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=630.05n

* CHECK dout0_13 Vdout0_13ck62 = 0 time = 630
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=630.05n

* CHECK dout0_14 Vdout0_14ck62 = 1.8 time = 630
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=630.05n

* CHECK dout0_15 Vdout0_15ck62 = 0 time = 630
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=630.05n

* CHECK dout0_16 Vdout0_16ck62 = 0 time = 630
.meas tran vdout0_16ck62 FIND v(dout0_16) AT=630.05n

* CHECK dout0_17 Vdout0_17ck62 = 1.8 time = 630
.meas tran vdout0_17ck62 FIND v(dout0_17) AT=630.05n

* CHECK dout0_18 Vdout0_18ck62 = 1.8 time = 630
.meas tran vdout0_18ck62 FIND v(dout0_18) AT=630.05n

* CHECK dout0_19 Vdout0_19ck62 = 0 time = 630
.meas tran vdout0_19ck62 FIND v(dout0_19) AT=630.05n

* CHECK dout0_20 Vdout0_20ck62 = 0 time = 630
.meas tran vdout0_20ck62 FIND v(dout0_20) AT=630.05n

* CHECK dout0_21 Vdout0_21ck62 = 0 time = 630
.meas tran vdout0_21ck62 FIND v(dout0_21) AT=630.05n

* CHECK dout0_22 Vdout0_22ck62 = 1.8 time = 630
.meas tran vdout0_22ck62 FIND v(dout0_22) AT=630.05n

* CHECK dout0_23 Vdout0_23ck62 = 1.8 time = 630
.meas tran vdout0_23ck62 FIND v(dout0_23) AT=630.05n

* CHECK dout0_24 Vdout0_24ck62 = 0 time = 630
.meas tran vdout0_24ck62 FIND v(dout0_24) AT=630.05n

* CHECK dout0_25 Vdout0_25ck62 = 0 time = 630
.meas tran vdout0_25ck62 FIND v(dout0_25) AT=630.05n

* CHECK dout0_26 Vdout0_26ck62 = 0 time = 630
.meas tran vdout0_26ck62 FIND v(dout0_26) AT=630.05n

* CHECK dout0_27 Vdout0_27ck62 = 0 time = 630
.meas tran vdout0_27ck62 FIND v(dout0_27) AT=630.05n

* CHECK dout0_28 Vdout0_28ck62 = 1.8 time = 630
.meas tran vdout0_28ck62 FIND v(dout0_28) AT=630.05n

* CHECK dout0_29 Vdout0_29ck62 = 1.8 time = 630
.meas tran vdout0_29ck62 FIND v(dout0_29) AT=630.05n

* CHECK dout0_30 Vdout0_30ck62 = 1.8 time = 630
.meas tran vdout0_30ck62 FIND v(dout0_30) AT=630.05n

* CHECK dout0_31 Vdout0_31ck62 = 1.8 time = 630
.meas tran vdout0_31ck62 FIND v(dout0_31) AT=630.05n

* CHECK dout0_32 Vdout0_32ck62 = 1.8 time = 630
.meas tran vdout0_32ck62 FIND v(dout0_32) AT=630.05n

* CHECK dout0_33 Vdout0_33ck62 = 0 time = 630
.meas tran vdout0_33ck62 FIND v(dout0_33) AT=630.05n

* CHECK dout0_34 Vdout0_34ck62 = 1.8 time = 630
.meas tran vdout0_34ck62 FIND v(dout0_34) AT=630.05n

* CHECK dout0_35 Vdout0_35ck62 = 0 time = 630
.meas tran vdout0_35ck62 FIND v(dout0_35) AT=630.05n

* CHECK dout0_36 Vdout0_36ck62 = 0 time = 630
.meas tran vdout0_36ck62 FIND v(dout0_36) AT=630.05n

* CHECK dout0_37 Vdout0_37ck62 = 0 time = 630
.meas tran vdout0_37ck62 FIND v(dout0_37) AT=630.05n

* CHECK dout0_38 Vdout0_38ck62 = 1.8 time = 630
.meas tran vdout0_38ck62 FIND v(dout0_38) AT=630.05n

* CHECK dout0_39 Vdout0_39ck62 = 1.8 time = 630
.meas tran vdout0_39ck62 FIND v(dout0_39) AT=630.05n

* CHECK dout0_40 Vdout0_40ck62 = 0 time = 630
.meas tran vdout0_40ck62 FIND v(dout0_40) AT=630.05n

* CHECK dout0_41 Vdout0_41ck62 = 0 time = 630
.meas tran vdout0_41ck62 FIND v(dout0_41) AT=630.05n

* CHECK dout0_42 Vdout0_42ck62 = 1.8 time = 630
.meas tran vdout0_42ck62 FIND v(dout0_42) AT=630.05n

* CHECK dout0_43 Vdout0_43ck62 = 1.8 time = 630
.meas tran vdout0_43ck62 FIND v(dout0_43) AT=630.05n

* CHECK dout0_44 Vdout0_44ck62 = 1.8 time = 630
.meas tran vdout0_44ck62 FIND v(dout0_44) AT=630.05n

* CHECK dout0_45 Vdout0_45ck62 = 0 time = 630
.meas tran vdout0_45ck62 FIND v(dout0_45) AT=630.05n

* CHECK dout0_46 Vdout0_46ck62 = 1.8 time = 630
.meas tran vdout0_46ck62 FIND v(dout0_46) AT=630.05n

* CHECK dout0_47 Vdout0_47ck62 = 1.8 time = 630
.meas tran vdout0_47ck62 FIND v(dout0_47) AT=630.05n

* CHECK dout0_48 Vdout0_48ck62 = 1.8 time = 630
.meas tran vdout0_48ck62 FIND v(dout0_48) AT=630.05n

* CHECK dout0_49 Vdout0_49ck62 = 0 time = 630
.meas tran vdout0_49ck62 FIND v(dout0_49) AT=630.05n

* CHECK dout0_50 Vdout0_50ck62 = 0 time = 630
.meas tran vdout0_50ck62 FIND v(dout0_50) AT=630.05n

* CHECK dout0_51 Vdout0_51ck62 = 0 time = 630
.meas tran vdout0_51ck62 FIND v(dout0_51) AT=630.05n

* CHECK dout0_52 Vdout0_52ck62 = 1.8 time = 630
.meas tran vdout0_52ck62 FIND v(dout0_52) AT=630.05n

* CHECK dout0_53 Vdout0_53ck62 = 1.8 time = 630
.meas tran vdout0_53ck62 FIND v(dout0_53) AT=630.05n

* CHECK dout0_54 Vdout0_54ck62 = 1.8 time = 630
.meas tran vdout0_54ck62 FIND v(dout0_54) AT=630.05n

* CHECK dout0_55 Vdout0_55ck62 = 0 time = 630
.meas tran vdout0_55ck62 FIND v(dout0_55) AT=630.05n

* CHECK dout0_56 Vdout0_56ck62 = 1.8 time = 630
.meas tran vdout0_56ck62 FIND v(dout0_56) AT=630.05n

* CHECK dout0_57 Vdout0_57ck62 = 1.8 time = 630
.meas tran vdout0_57ck62 FIND v(dout0_57) AT=630.05n

* CHECK dout0_58 Vdout0_58ck62 = 0 time = 630
.meas tran vdout0_58ck62 FIND v(dout0_58) AT=630.05n

* CHECK dout0_59 Vdout0_59ck62 = 1.8 time = 630
.meas tran vdout0_59ck62 FIND v(dout0_59) AT=630.05n

* CHECK dout0_60 Vdout0_60ck62 = 1.8 time = 630
.meas tran vdout0_60ck62 FIND v(dout0_60) AT=630.05n

* CHECK dout0_61 Vdout0_61ck62 = 1.8 time = 630
.meas tran vdout0_61ck62 FIND v(dout0_61) AT=630.05n

* CHECK dout0_62 Vdout0_62ck62 = 1.8 time = 630
.meas tran vdout0_62ck62 FIND v(dout0_62) AT=630.05n

* CHECK dout0_63 Vdout0_63ck62 = 0 time = 630
.meas tran vdout0_63ck62 FIND v(dout0_63) AT=630.05n

* CHECK dout0_64 Vdout0_64ck62 = 0 time = 630
.meas tran vdout0_64ck62 FIND v(dout0_64) AT=630.05n

* CHECK dout0_0 Vdout0_0ck63 = 1.8 time = 640
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=640.05n

* CHECK dout0_1 Vdout0_1ck63 = 1.8 time = 640
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=640.05n

* CHECK dout0_2 Vdout0_2ck63 = 0 time = 640
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=640.05n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 640
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=640.05n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 640
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=640.05n

* CHECK dout0_5 Vdout0_5ck63 = 1.8 time = 640
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=640.05n

* CHECK dout0_6 Vdout0_6ck63 = 1.8 time = 640
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=640.05n

* CHECK dout0_7 Vdout0_7ck63 = 0 time = 640
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=640.05n

* CHECK dout0_8 Vdout0_8ck63 = 1.8 time = 640
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=640.05n

* CHECK dout0_9 Vdout0_9ck63 = 1.8 time = 640
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=640.05n

* CHECK dout0_10 Vdout0_10ck63 = 1.8 time = 640
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=640.05n

* CHECK dout0_11 Vdout0_11ck63 = 0 time = 640
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=640.05n

* CHECK dout0_12 Vdout0_12ck63 = 0 time = 640
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=640.05n

* CHECK dout0_13 Vdout0_13ck63 = 0 time = 640
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=640.05n

* CHECK dout0_14 Vdout0_14ck63 = 0 time = 640
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=640.05n

* CHECK dout0_15 Vdout0_15ck63 = 1.8 time = 640
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=640.05n

* CHECK dout0_16 Vdout0_16ck63 = 0 time = 640
.meas tran vdout0_16ck63 FIND v(dout0_16) AT=640.05n

* CHECK dout0_17 Vdout0_17ck63 = 1.8 time = 640
.meas tran vdout0_17ck63 FIND v(dout0_17) AT=640.05n

* CHECK dout0_18 Vdout0_18ck63 = 0 time = 640
.meas tran vdout0_18ck63 FIND v(dout0_18) AT=640.05n

* CHECK dout0_19 Vdout0_19ck63 = 0 time = 640
.meas tran vdout0_19ck63 FIND v(dout0_19) AT=640.05n

* CHECK dout0_20 Vdout0_20ck63 = 1.8 time = 640
.meas tran vdout0_20ck63 FIND v(dout0_20) AT=640.05n

* CHECK dout0_21 Vdout0_21ck63 = 1.8 time = 640
.meas tran vdout0_21ck63 FIND v(dout0_21) AT=640.05n

* CHECK dout0_22 Vdout0_22ck63 = 0 time = 640
.meas tran vdout0_22ck63 FIND v(dout0_22) AT=640.05n

* CHECK dout0_23 Vdout0_23ck63 = 1.8 time = 640
.meas tran vdout0_23ck63 FIND v(dout0_23) AT=640.05n

* CHECK dout0_24 Vdout0_24ck63 = 1.8 time = 640
.meas tran vdout0_24ck63 FIND v(dout0_24) AT=640.05n

* CHECK dout0_25 Vdout0_25ck63 = 0 time = 640
.meas tran vdout0_25ck63 FIND v(dout0_25) AT=640.05n

* CHECK dout0_26 Vdout0_26ck63 = 1.8 time = 640
.meas tran vdout0_26ck63 FIND v(dout0_26) AT=640.05n

* CHECK dout0_27 Vdout0_27ck63 = 0 time = 640
.meas tran vdout0_27ck63 FIND v(dout0_27) AT=640.05n

* CHECK dout0_28 Vdout0_28ck63 = 0 time = 640
.meas tran vdout0_28ck63 FIND v(dout0_28) AT=640.05n

* CHECK dout0_29 Vdout0_29ck63 = 0 time = 640
.meas tran vdout0_29ck63 FIND v(dout0_29) AT=640.05n

* CHECK dout0_30 Vdout0_30ck63 = 0 time = 640
.meas tran vdout0_30ck63 FIND v(dout0_30) AT=640.05n

* CHECK dout0_31 Vdout0_31ck63 = 0 time = 640
.meas tran vdout0_31ck63 FIND v(dout0_31) AT=640.05n

* CHECK dout0_32 Vdout0_32ck63 = 1.8 time = 640
.meas tran vdout0_32ck63 FIND v(dout0_32) AT=640.05n

* CHECK dout0_33 Vdout0_33ck63 = 1.8 time = 640
.meas tran vdout0_33ck63 FIND v(dout0_33) AT=640.05n

* CHECK dout0_34 Vdout0_34ck63 = 0 time = 640
.meas tran vdout0_34ck63 FIND v(dout0_34) AT=640.05n

* CHECK dout0_35 Vdout0_35ck63 = 1.8 time = 640
.meas tran vdout0_35ck63 FIND v(dout0_35) AT=640.05n

* CHECK dout0_36 Vdout0_36ck63 = 1.8 time = 640
.meas tran vdout0_36ck63 FIND v(dout0_36) AT=640.05n

* CHECK dout0_37 Vdout0_37ck63 = 0 time = 640
.meas tran vdout0_37ck63 FIND v(dout0_37) AT=640.05n

* CHECK dout0_38 Vdout0_38ck63 = 0 time = 640
.meas tran vdout0_38ck63 FIND v(dout0_38) AT=640.05n

* CHECK dout0_39 Vdout0_39ck63 = 0 time = 640
.meas tran vdout0_39ck63 FIND v(dout0_39) AT=640.05n

* CHECK dout0_40 Vdout0_40ck63 = 0 time = 640
.meas tran vdout0_40ck63 FIND v(dout0_40) AT=640.05n

* CHECK dout0_41 Vdout0_41ck63 = 0 time = 640
.meas tran vdout0_41ck63 FIND v(dout0_41) AT=640.05n

* CHECK dout0_42 Vdout0_42ck63 = 1.8 time = 640
.meas tran vdout0_42ck63 FIND v(dout0_42) AT=640.05n

* CHECK dout0_43 Vdout0_43ck63 = 1.8 time = 640
.meas tran vdout0_43ck63 FIND v(dout0_43) AT=640.05n

* CHECK dout0_44 Vdout0_44ck63 = 1.8 time = 640
.meas tran vdout0_44ck63 FIND v(dout0_44) AT=640.05n

* CHECK dout0_45 Vdout0_45ck63 = 0 time = 640
.meas tran vdout0_45ck63 FIND v(dout0_45) AT=640.05n

* CHECK dout0_46 Vdout0_46ck63 = 0 time = 640
.meas tran vdout0_46ck63 FIND v(dout0_46) AT=640.05n

* CHECK dout0_47 Vdout0_47ck63 = 1.8 time = 640
.meas tran vdout0_47ck63 FIND v(dout0_47) AT=640.05n

* CHECK dout0_48 Vdout0_48ck63 = 1.8 time = 640
.meas tran vdout0_48ck63 FIND v(dout0_48) AT=640.05n

* CHECK dout0_49 Vdout0_49ck63 = 0 time = 640
.meas tran vdout0_49ck63 FIND v(dout0_49) AT=640.05n

* CHECK dout0_50 Vdout0_50ck63 = 1.8 time = 640
.meas tran vdout0_50ck63 FIND v(dout0_50) AT=640.05n

* CHECK dout0_51 Vdout0_51ck63 = 1.8 time = 640
.meas tran vdout0_51ck63 FIND v(dout0_51) AT=640.05n

* CHECK dout0_52 Vdout0_52ck63 = 0 time = 640
.meas tran vdout0_52ck63 FIND v(dout0_52) AT=640.05n

* CHECK dout0_53 Vdout0_53ck63 = 0 time = 640
.meas tran vdout0_53ck63 FIND v(dout0_53) AT=640.05n

* CHECK dout0_54 Vdout0_54ck63 = 0 time = 640
.meas tran vdout0_54ck63 FIND v(dout0_54) AT=640.05n

* CHECK dout0_55 Vdout0_55ck63 = 0 time = 640
.meas tran vdout0_55ck63 FIND v(dout0_55) AT=640.05n

* CHECK dout0_56 Vdout0_56ck63 = 1.8 time = 640
.meas tran vdout0_56ck63 FIND v(dout0_56) AT=640.05n

* CHECK dout0_57 Vdout0_57ck63 = 1.8 time = 640
.meas tran vdout0_57ck63 FIND v(dout0_57) AT=640.05n

* CHECK dout0_58 Vdout0_58ck63 = 1.8 time = 640
.meas tran vdout0_58ck63 FIND v(dout0_58) AT=640.05n

* CHECK dout0_59 Vdout0_59ck63 = 0 time = 640
.meas tran vdout0_59ck63 FIND v(dout0_59) AT=640.05n

* CHECK dout0_60 Vdout0_60ck63 = 1.8 time = 640
.meas tran vdout0_60ck63 FIND v(dout0_60) AT=640.05n

* CHECK dout0_61 Vdout0_61ck63 = 0 time = 640
.meas tran vdout0_61ck63 FIND v(dout0_61) AT=640.05n

* CHECK dout0_62 Vdout0_62ck63 = 1.8 time = 640
.meas tran vdout0_62ck63 FIND v(dout0_62) AT=640.05n

* CHECK dout0_63 Vdout0_63ck63 = 0 time = 640
.meas tran vdout0_63ck63 FIND v(dout0_63) AT=640.05n

* CHECK dout0_64 Vdout0_64ck63 = 0 time = 640
.meas tran vdout0_64ck63 FIND v(dout0_64) AT=640.05n

* CHECK dout0_0 Vdout0_0ck64 = 0 time = 650
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=650.05n

* CHECK dout0_1 Vdout0_1ck64 = 1.8 time = 650
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=650.05n

* CHECK dout0_2 Vdout0_2ck64 = 1.8 time = 650
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=650.05n

* CHECK dout0_3 Vdout0_3ck64 = 0 time = 650
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=650.05n

* CHECK dout0_4 Vdout0_4ck64 = 1.8 time = 650
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=650.05n

* CHECK dout0_5 Vdout0_5ck64 = 1.8 time = 650
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=650.05n

* CHECK dout0_6 Vdout0_6ck64 = 0 time = 650
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=650.05n

* CHECK dout0_7 Vdout0_7ck64 = 1.8 time = 650
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=650.05n

* CHECK dout0_8 Vdout0_8ck64 = 1.8 time = 650
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=650.05n

* CHECK dout0_9 Vdout0_9ck64 = 1.8 time = 650
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=650.05n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 650
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=650.05n

* CHECK dout0_11 Vdout0_11ck64 = 0 time = 650
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=650.05n

* CHECK dout0_12 Vdout0_12ck64 = 0 time = 650
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=650.05n

* CHECK dout0_13 Vdout0_13ck64 = 0 time = 650
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=650.05n

* CHECK dout0_14 Vdout0_14ck64 = 0 time = 650
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=650.05n

* CHECK dout0_15 Vdout0_15ck64 = 0 time = 650
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=650.05n

* CHECK dout0_16 Vdout0_16ck64 = 1.8 time = 650
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=650.05n

* CHECK dout0_17 Vdout0_17ck64 = 0 time = 650
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=650.05n

* CHECK dout0_18 Vdout0_18ck64 = 1.8 time = 650
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=650.05n

* CHECK dout0_19 Vdout0_19ck64 = 1.8 time = 650
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=650.05n

* CHECK dout0_20 Vdout0_20ck64 = 1.8 time = 650
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=650.05n

* CHECK dout0_21 Vdout0_21ck64 = 0 time = 650
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=650.05n

* CHECK dout0_22 Vdout0_22ck64 = 0 time = 650
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=650.05n

* CHECK dout0_23 Vdout0_23ck64 = 0 time = 650
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=650.05n

* CHECK dout0_24 Vdout0_24ck64 = 0 time = 650
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=650.05n

* CHECK dout0_25 Vdout0_25ck64 = 0 time = 650
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=650.05n

* CHECK dout0_26 Vdout0_26ck64 = 1.8 time = 650
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=650.05n

* CHECK dout0_27 Vdout0_27ck64 = 1.8 time = 650
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=650.05n

* CHECK dout0_28 Vdout0_28ck64 = 0 time = 650
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=650.05n

* CHECK dout0_29 Vdout0_29ck64 = 0 time = 650
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=650.05n

* CHECK dout0_30 Vdout0_30ck64 = 0 time = 650
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=650.05n

* CHECK dout0_31 Vdout0_31ck64 = 1.8 time = 650
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=650.05n

* CHECK dout0_32 Vdout0_32ck64 = 1.8 time = 650
.meas tran vdout0_32ck64 FIND v(dout0_32) AT=650.05n

* CHECK dout0_33 Vdout0_33ck64 = 1.8 time = 650
.meas tran vdout0_33ck64 FIND v(dout0_33) AT=650.05n

* CHECK dout0_34 Vdout0_34ck64 = 1.8 time = 650
.meas tran vdout0_34ck64 FIND v(dout0_34) AT=650.05n

* CHECK dout0_35 Vdout0_35ck64 = 1.8 time = 650
.meas tran vdout0_35ck64 FIND v(dout0_35) AT=650.05n

* CHECK dout0_36 Vdout0_36ck64 = 1.8 time = 650
.meas tran vdout0_36ck64 FIND v(dout0_36) AT=650.05n

* CHECK dout0_37 Vdout0_37ck64 = 1.8 time = 650
.meas tran vdout0_37ck64 FIND v(dout0_37) AT=650.05n

* CHECK dout0_38 Vdout0_38ck64 = 1.8 time = 650
.meas tran vdout0_38ck64 FIND v(dout0_38) AT=650.05n

* CHECK dout0_39 Vdout0_39ck64 = 1.8 time = 650
.meas tran vdout0_39ck64 FIND v(dout0_39) AT=650.05n

* CHECK dout0_40 Vdout0_40ck64 = 0 time = 650
.meas tran vdout0_40ck64 FIND v(dout0_40) AT=650.05n

* CHECK dout0_41 Vdout0_41ck64 = 0 time = 650
.meas tran vdout0_41ck64 FIND v(dout0_41) AT=650.05n

* CHECK dout0_42 Vdout0_42ck64 = 0 time = 650
.meas tran vdout0_42ck64 FIND v(dout0_42) AT=650.05n

* CHECK dout0_43 Vdout0_43ck64 = 0 time = 650
.meas tran vdout0_43ck64 FIND v(dout0_43) AT=650.05n

* CHECK dout0_44 Vdout0_44ck64 = 1.8 time = 650
.meas tran vdout0_44ck64 FIND v(dout0_44) AT=650.05n

* CHECK dout0_45 Vdout0_45ck64 = 1.8 time = 650
.meas tran vdout0_45ck64 FIND v(dout0_45) AT=650.05n

* CHECK dout0_46 Vdout0_46ck64 = 0 time = 650
.meas tran vdout0_46ck64 FIND v(dout0_46) AT=650.05n

* CHECK dout0_47 Vdout0_47ck64 = 1.8 time = 650
.meas tran vdout0_47ck64 FIND v(dout0_47) AT=650.05n

* CHECK dout0_48 Vdout0_48ck64 = 1.8 time = 650
.meas tran vdout0_48ck64 FIND v(dout0_48) AT=650.05n

* CHECK dout0_49 Vdout0_49ck64 = 1.8 time = 650
.meas tran vdout0_49ck64 FIND v(dout0_49) AT=650.05n

* CHECK dout0_50 Vdout0_50ck64 = 0 time = 650
.meas tran vdout0_50ck64 FIND v(dout0_50) AT=650.05n

* CHECK dout0_51 Vdout0_51ck64 = 0 time = 650
.meas tran vdout0_51ck64 FIND v(dout0_51) AT=650.05n

* CHECK dout0_52 Vdout0_52ck64 = 0 time = 650
.meas tran vdout0_52ck64 FIND v(dout0_52) AT=650.05n

* CHECK dout0_53 Vdout0_53ck64 = 1.8 time = 650
.meas tran vdout0_53ck64 FIND v(dout0_53) AT=650.05n

* CHECK dout0_54 Vdout0_54ck64 = 0 time = 650
.meas tran vdout0_54ck64 FIND v(dout0_54) AT=650.05n

* CHECK dout0_55 Vdout0_55ck64 = 0 time = 650
.meas tran vdout0_55ck64 FIND v(dout0_55) AT=650.05n

* CHECK dout0_56 Vdout0_56ck64 = 0 time = 650
.meas tran vdout0_56ck64 FIND v(dout0_56) AT=650.05n

* CHECK dout0_57 Vdout0_57ck64 = 1.8 time = 650
.meas tran vdout0_57ck64 FIND v(dout0_57) AT=650.05n

* CHECK dout0_58 Vdout0_58ck64 = 0 time = 650
.meas tran vdout0_58ck64 FIND v(dout0_58) AT=650.05n

* CHECK dout0_59 Vdout0_59ck64 = 1.8 time = 650
.meas tran vdout0_59ck64 FIND v(dout0_59) AT=650.05n

* CHECK dout0_60 Vdout0_60ck64 = 0 time = 650
.meas tran vdout0_60ck64 FIND v(dout0_60) AT=650.05n

* CHECK dout0_61 Vdout0_61ck64 = 0 time = 650
.meas tran vdout0_61ck64 FIND v(dout0_61) AT=650.05n

* CHECK dout0_62 Vdout0_62ck64 = 0 time = 650
.meas tran vdout0_62ck64 FIND v(dout0_62) AT=650.05n

* CHECK dout0_63 Vdout0_63ck64 = 1.8 time = 650
.meas tran vdout0_63ck64 FIND v(dout0_63) AT=650.05n

* CHECK dout0_64 Vdout0_64ck64 = 0 time = 650
.meas tran vdout0_64ck64 FIND v(dout0_64) AT=650.05n

* CHECK dout0_0 Vdout0_0ck65 = 1.8 time = 660
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=660.05n

* CHECK dout0_1 Vdout0_1ck65 = 1.8 time = 660
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=660.05n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 660
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=660.05n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 660
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=660.05n

* CHECK dout0_4 Vdout0_4ck65 = 1.8 time = 660
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=660.05n

* CHECK dout0_5 Vdout0_5ck65 = 1.8 time = 660
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=660.05n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 660
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=660.05n

* CHECK dout0_7 Vdout0_7ck65 = 0 time = 660
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=660.05n

* CHECK dout0_8 Vdout0_8ck65 = 1.8 time = 660
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=660.05n

* CHECK dout0_9 Vdout0_9ck65 = 1.8 time = 660
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=660.05n

* CHECK dout0_10 Vdout0_10ck65 = 0 time = 660
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=660.05n

* CHECK dout0_11 Vdout0_11ck65 = 1.8 time = 660
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=660.05n

* CHECK dout0_12 Vdout0_12ck65 = 0 time = 660
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=660.05n

* CHECK dout0_13 Vdout0_13ck65 = 1.8 time = 660
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=660.05n

* CHECK dout0_14 Vdout0_14ck65 = 1.8 time = 660
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=660.05n

* CHECK dout0_15 Vdout0_15ck65 = 1.8 time = 660
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=660.05n

* CHECK dout0_16 Vdout0_16ck65 = 1.8 time = 660
.meas tran vdout0_16ck65 FIND v(dout0_16) AT=660.05n

* CHECK dout0_17 Vdout0_17ck65 = 0 time = 660
.meas tran vdout0_17ck65 FIND v(dout0_17) AT=660.05n

* CHECK dout0_18 Vdout0_18ck65 = 0 time = 660
.meas tran vdout0_18ck65 FIND v(dout0_18) AT=660.05n

* CHECK dout0_19 Vdout0_19ck65 = 0 time = 660
.meas tran vdout0_19ck65 FIND v(dout0_19) AT=660.05n

* CHECK dout0_20 Vdout0_20ck65 = 1.8 time = 660
.meas tran vdout0_20ck65 FIND v(dout0_20) AT=660.05n

* CHECK dout0_21 Vdout0_21ck65 = 1.8 time = 660
.meas tran vdout0_21ck65 FIND v(dout0_21) AT=660.05n

* CHECK dout0_22 Vdout0_22ck65 = 1.8 time = 660
.meas tran vdout0_22ck65 FIND v(dout0_22) AT=660.05n

* CHECK dout0_23 Vdout0_23ck65 = 0 time = 660
.meas tran vdout0_23ck65 FIND v(dout0_23) AT=660.05n

* CHECK dout0_24 Vdout0_24ck65 = 1.8 time = 660
.meas tran vdout0_24ck65 FIND v(dout0_24) AT=660.05n

* CHECK dout0_25 Vdout0_25ck65 = 1.8 time = 660
.meas tran vdout0_25ck65 FIND v(dout0_25) AT=660.05n

* CHECK dout0_26 Vdout0_26ck65 = 0 time = 660
.meas tran vdout0_26ck65 FIND v(dout0_26) AT=660.05n

* CHECK dout0_27 Vdout0_27ck65 = 0 time = 660
.meas tran vdout0_27ck65 FIND v(dout0_27) AT=660.05n

* CHECK dout0_28 Vdout0_28ck65 = 0 time = 660
.meas tran vdout0_28ck65 FIND v(dout0_28) AT=660.05n

* CHECK dout0_29 Vdout0_29ck65 = 1.8 time = 660
.meas tran vdout0_29ck65 FIND v(dout0_29) AT=660.05n

* CHECK dout0_30 Vdout0_30ck65 = 1.8 time = 660
.meas tran vdout0_30ck65 FIND v(dout0_30) AT=660.05n

* CHECK dout0_31 Vdout0_31ck65 = 0 time = 660
.meas tran vdout0_31ck65 FIND v(dout0_31) AT=660.05n

* CHECK dout0_32 Vdout0_32ck65 = 1.8 time = 660
.meas tran vdout0_32ck65 FIND v(dout0_32) AT=660.05n

* CHECK dout0_33 Vdout0_33ck65 = 0 time = 660
.meas tran vdout0_33ck65 FIND v(dout0_33) AT=660.05n

* CHECK dout0_34 Vdout0_34ck65 = 0 time = 660
.meas tran vdout0_34ck65 FIND v(dout0_34) AT=660.05n

* CHECK dout0_35 Vdout0_35ck65 = 1.8 time = 660
.meas tran vdout0_35ck65 FIND v(dout0_35) AT=660.05n

* CHECK dout0_36 Vdout0_36ck65 = 0 time = 660
.meas tran vdout0_36ck65 FIND v(dout0_36) AT=660.05n

* CHECK dout0_37 Vdout0_37ck65 = 0 time = 660
.meas tran vdout0_37ck65 FIND v(dout0_37) AT=660.05n

* CHECK dout0_38 Vdout0_38ck65 = 0 time = 660
.meas tran vdout0_38ck65 FIND v(dout0_38) AT=660.05n

* CHECK dout0_39 Vdout0_39ck65 = 1.8 time = 660
.meas tran vdout0_39ck65 FIND v(dout0_39) AT=660.05n

* CHECK dout0_40 Vdout0_40ck65 = 0 time = 660
.meas tran vdout0_40ck65 FIND v(dout0_40) AT=660.05n

* CHECK dout0_41 Vdout0_41ck65 = 1.8 time = 660
.meas tran vdout0_41ck65 FIND v(dout0_41) AT=660.05n

* CHECK dout0_42 Vdout0_42ck65 = 0 time = 660
.meas tran vdout0_42ck65 FIND v(dout0_42) AT=660.05n

* CHECK dout0_43 Vdout0_43ck65 = 1.8 time = 660
.meas tran vdout0_43ck65 FIND v(dout0_43) AT=660.05n

* CHECK dout0_44 Vdout0_44ck65 = 1.8 time = 660
.meas tran vdout0_44ck65 FIND v(dout0_44) AT=660.05n

* CHECK dout0_45 Vdout0_45ck65 = 1.8 time = 660
.meas tran vdout0_45ck65 FIND v(dout0_45) AT=660.05n

* CHECK dout0_46 Vdout0_46ck65 = 0 time = 660
.meas tran vdout0_46ck65 FIND v(dout0_46) AT=660.05n

* CHECK dout0_47 Vdout0_47ck65 = 0 time = 660
.meas tran vdout0_47ck65 FIND v(dout0_47) AT=660.05n

* CHECK dout0_48 Vdout0_48ck65 = 1.8 time = 660
.meas tran vdout0_48ck65 FIND v(dout0_48) AT=660.05n

* CHECK dout0_49 Vdout0_49ck65 = 0 time = 660
.meas tran vdout0_49ck65 FIND v(dout0_49) AT=660.05n

* CHECK dout0_50 Vdout0_50ck65 = 1.8 time = 660
.meas tran vdout0_50ck65 FIND v(dout0_50) AT=660.05n

* CHECK dout0_51 Vdout0_51ck65 = 1.8 time = 660
.meas tran vdout0_51ck65 FIND v(dout0_51) AT=660.05n

* CHECK dout0_52 Vdout0_52ck65 = 0 time = 660
.meas tran vdout0_52ck65 FIND v(dout0_52) AT=660.05n

* CHECK dout0_53 Vdout0_53ck65 = 1.8 time = 660
.meas tran vdout0_53ck65 FIND v(dout0_53) AT=660.05n

* CHECK dout0_54 Vdout0_54ck65 = 1.8 time = 660
.meas tran vdout0_54ck65 FIND v(dout0_54) AT=660.05n

* CHECK dout0_55 Vdout0_55ck65 = 1.8 time = 660
.meas tran vdout0_55ck65 FIND v(dout0_55) AT=660.05n

* CHECK dout0_56 Vdout0_56ck65 = 0 time = 660
.meas tran vdout0_56ck65 FIND v(dout0_56) AT=660.05n

* CHECK dout0_57 Vdout0_57ck65 = 1.8 time = 660
.meas tran vdout0_57ck65 FIND v(dout0_57) AT=660.05n

* CHECK dout0_58 Vdout0_58ck65 = 0 time = 660
.meas tran vdout0_58ck65 FIND v(dout0_58) AT=660.05n

* CHECK dout0_59 Vdout0_59ck65 = 1.8 time = 660
.meas tran vdout0_59ck65 FIND v(dout0_59) AT=660.05n

* CHECK dout0_60 Vdout0_60ck65 = 1.8 time = 660
.meas tran vdout0_60ck65 FIND v(dout0_60) AT=660.05n

* CHECK dout0_61 Vdout0_61ck65 = 0 time = 660
.meas tran vdout0_61ck65 FIND v(dout0_61) AT=660.05n

* CHECK dout0_62 Vdout0_62ck65 = 1.8 time = 660
.meas tran vdout0_62ck65 FIND v(dout0_62) AT=660.05n

* CHECK dout0_63 Vdout0_63ck65 = 1.8 time = 660
.meas tran vdout0_63ck65 FIND v(dout0_63) AT=660.05n

* CHECK dout0_64 Vdout0_64ck65 = 0 time = 660
.meas tran vdout0_64ck65 FIND v(dout0_64) AT=660.05n

* CHECK dout0_0 Vdout0_0ck68 = 0 time = 690
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=690.05n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 690
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=690.05n

* CHECK dout0_2 Vdout0_2ck68 = 0 time = 690
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=690.05n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 690
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=690.05n

* CHECK dout0_4 Vdout0_4ck68 = 1.8 time = 690
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=690.05n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 690
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=690.05n

* CHECK dout0_6 Vdout0_6ck68 = 1.8 time = 690
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=690.05n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 690
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=690.05n

* CHECK dout0_8 Vdout0_8ck68 = 0 time = 690
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=690.05n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 690
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=690.05n

* CHECK dout0_10 Vdout0_10ck68 = 1.8 time = 690
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=690.05n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 690
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=690.05n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 690
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=690.05n

* CHECK dout0_13 Vdout0_13ck68 = 0 time = 690
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=690.05n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 690
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=690.05n

* CHECK dout0_15 Vdout0_15ck68 = 0 time = 690
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=690.05n

* CHECK dout0_16 Vdout0_16ck68 = 1.8 time = 690
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=690.05n

* CHECK dout0_17 Vdout0_17ck68 = 0 time = 690
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=690.05n

* CHECK dout0_18 Vdout0_18ck68 = 0 time = 690
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=690.05n

* CHECK dout0_19 Vdout0_19ck68 = 1.8 time = 690
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=690.05n

* CHECK dout0_20 Vdout0_20ck68 = 1.8 time = 690
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=690.05n

* CHECK dout0_21 Vdout0_21ck68 = 0 time = 690
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=690.05n

* CHECK dout0_22 Vdout0_22ck68 = 0 time = 690
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=690.05n

* CHECK dout0_23 Vdout0_23ck68 = 1.8 time = 690
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=690.05n

* CHECK dout0_24 Vdout0_24ck68 = 1.8 time = 690
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=690.05n

* CHECK dout0_25 Vdout0_25ck68 = 1.8 time = 690
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=690.05n

* CHECK dout0_26 Vdout0_26ck68 = 1.8 time = 690
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=690.05n

* CHECK dout0_27 Vdout0_27ck68 = 0 time = 690
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=690.05n

* CHECK dout0_28 Vdout0_28ck68 = 0 time = 690
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=690.05n

* CHECK dout0_29 Vdout0_29ck68 = 0 time = 690
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=690.05n

* CHECK dout0_30 Vdout0_30ck68 = 1.8 time = 690
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=690.05n

* CHECK dout0_31 Vdout0_31ck68 = 0 time = 690
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=690.05n

* CHECK dout0_32 Vdout0_32ck68 = 0 time = 690
.meas tran vdout0_32ck68 FIND v(dout0_32) AT=690.05n

* CHECK dout0_33 Vdout0_33ck68 = 0 time = 690
.meas tran vdout0_33ck68 FIND v(dout0_33) AT=690.05n

* CHECK dout0_34 Vdout0_34ck68 = 0 time = 690
.meas tran vdout0_34ck68 FIND v(dout0_34) AT=690.05n

* CHECK dout0_35 Vdout0_35ck68 = 0 time = 690
.meas tran vdout0_35ck68 FIND v(dout0_35) AT=690.05n

* CHECK dout0_36 Vdout0_36ck68 = 1.8 time = 690
.meas tran vdout0_36ck68 FIND v(dout0_36) AT=690.05n

* CHECK dout0_37 Vdout0_37ck68 = 1.8 time = 690
.meas tran vdout0_37ck68 FIND v(dout0_37) AT=690.05n

* CHECK dout0_38 Vdout0_38ck68 = 1.8 time = 690
.meas tran vdout0_38ck68 FIND v(dout0_38) AT=690.05n

* CHECK dout0_39 Vdout0_39ck68 = 1.8 time = 690
.meas tran vdout0_39ck68 FIND v(dout0_39) AT=690.05n

* CHECK dout0_40 Vdout0_40ck68 = 1.8 time = 690
.meas tran vdout0_40ck68 FIND v(dout0_40) AT=690.05n

* CHECK dout0_41 Vdout0_41ck68 = 0 time = 690
.meas tran vdout0_41ck68 FIND v(dout0_41) AT=690.05n

* CHECK dout0_42 Vdout0_42ck68 = 0 time = 690
.meas tran vdout0_42ck68 FIND v(dout0_42) AT=690.05n

* CHECK dout0_43 Vdout0_43ck68 = 0 time = 690
.meas tran vdout0_43ck68 FIND v(dout0_43) AT=690.05n

* CHECK dout0_44 Vdout0_44ck68 = 0 time = 690
.meas tran vdout0_44ck68 FIND v(dout0_44) AT=690.05n

* CHECK dout0_45 Vdout0_45ck68 = 1.8 time = 690
.meas tran vdout0_45ck68 FIND v(dout0_45) AT=690.05n

* CHECK dout0_46 Vdout0_46ck68 = 1.8 time = 690
.meas tran vdout0_46ck68 FIND v(dout0_46) AT=690.05n

* CHECK dout0_47 Vdout0_47ck68 = 0 time = 690
.meas tran vdout0_47ck68 FIND v(dout0_47) AT=690.05n

* CHECK dout0_48 Vdout0_48ck68 = 1.8 time = 690
.meas tran vdout0_48ck68 FIND v(dout0_48) AT=690.05n

* CHECK dout0_49 Vdout0_49ck68 = 1.8 time = 690
.meas tran vdout0_49ck68 FIND v(dout0_49) AT=690.05n

* CHECK dout0_50 Vdout0_50ck68 = 1.8 time = 690
.meas tran vdout0_50ck68 FIND v(dout0_50) AT=690.05n

* CHECK dout0_51 Vdout0_51ck68 = 1.8 time = 690
.meas tran vdout0_51ck68 FIND v(dout0_51) AT=690.05n

* CHECK dout0_52 Vdout0_52ck68 = 1.8 time = 690
.meas tran vdout0_52ck68 FIND v(dout0_52) AT=690.05n

* CHECK dout0_53 Vdout0_53ck68 = 1.8 time = 690
.meas tran vdout0_53ck68 FIND v(dout0_53) AT=690.05n

* CHECK dout0_54 Vdout0_54ck68 = 1.8 time = 690
.meas tran vdout0_54ck68 FIND v(dout0_54) AT=690.05n

* CHECK dout0_55 Vdout0_55ck68 = 1.8 time = 690
.meas tran vdout0_55ck68 FIND v(dout0_55) AT=690.05n

* CHECK dout0_56 Vdout0_56ck68 = 0 time = 690
.meas tran vdout0_56ck68 FIND v(dout0_56) AT=690.05n

* CHECK dout0_57 Vdout0_57ck68 = 0 time = 690
.meas tran vdout0_57ck68 FIND v(dout0_57) AT=690.05n

* CHECK dout0_58 Vdout0_58ck68 = 1.8 time = 690
.meas tran vdout0_58ck68 FIND v(dout0_58) AT=690.05n

* CHECK dout0_59 Vdout0_59ck68 = 0 time = 690
.meas tran vdout0_59ck68 FIND v(dout0_59) AT=690.05n

* CHECK dout0_60 Vdout0_60ck68 = 0 time = 690
.meas tran vdout0_60ck68 FIND v(dout0_60) AT=690.05n

* CHECK dout0_61 Vdout0_61ck68 = 1.8 time = 690
.meas tran vdout0_61ck68 FIND v(dout0_61) AT=690.05n

* CHECK dout0_62 Vdout0_62ck68 = 1.8 time = 690
.meas tran vdout0_62ck68 FIND v(dout0_62) AT=690.05n

* CHECK dout0_63 Vdout0_63ck68 = 1.8 time = 690
.meas tran vdout0_63ck68 FIND v(dout0_63) AT=690.05n

* CHECK dout0_64 Vdout0_64ck68 = 0 time = 690
.meas tran vdout0_64ck68 FIND v(dout0_64) AT=690.05n

* CHECK dout0_0 Vdout0_0ck71 = 0 time = 720
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=720.05n

* CHECK dout0_1 Vdout0_1ck71 = 0 time = 720
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=720.05n

* CHECK dout0_2 Vdout0_2ck71 = 1.8 time = 720
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=720.05n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 720
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=720.05n

* CHECK dout0_4 Vdout0_4ck71 = 0 time = 720
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=720.05n

* CHECK dout0_5 Vdout0_5ck71 = 0 time = 720
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=720.05n

* CHECK dout0_6 Vdout0_6ck71 = 1.8 time = 720
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=720.05n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 720
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=720.05n

* CHECK dout0_8 Vdout0_8ck71 = 1.8 time = 720
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=720.05n

* CHECK dout0_9 Vdout0_9ck71 = 1.8 time = 720
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=720.05n

* CHECK dout0_10 Vdout0_10ck71 = 1.8 time = 720
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=720.05n

* CHECK dout0_11 Vdout0_11ck71 = 0 time = 720
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=720.05n

* CHECK dout0_12 Vdout0_12ck71 = 0 time = 720
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=720.05n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 720
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=720.05n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 720
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=720.05n

* CHECK dout0_15 Vdout0_15ck71 = 1.8 time = 720
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=720.05n

* CHECK dout0_16 Vdout0_16ck71 = 1.8 time = 720
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=720.05n

* CHECK dout0_17 Vdout0_17ck71 = 0 time = 720
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=720.05n

* CHECK dout0_18 Vdout0_18ck71 = 1.8 time = 720
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=720.05n

* CHECK dout0_19 Vdout0_19ck71 = 1.8 time = 720
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=720.05n

* CHECK dout0_20 Vdout0_20ck71 = 0 time = 720
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=720.05n

* CHECK dout0_21 Vdout0_21ck71 = 0 time = 720
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=720.05n

* CHECK dout0_22 Vdout0_22ck71 = 0 time = 720
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=720.05n

* CHECK dout0_23 Vdout0_23ck71 = 1.8 time = 720
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=720.05n

* CHECK dout0_24 Vdout0_24ck71 = 0 time = 720
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=720.05n

* CHECK dout0_25 Vdout0_25ck71 = 1.8 time = 720
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=720.05n

* CHECK dout0_26 Vdout0_26ck71 = 1.8 time = 720
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=720.05n

* CHECK dout0_27 Vdout0_27ck71 = 1.8 time = 720
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=720.05n

* CHECK dout0_28 Vdout0_28ck71 = 0 time = 720
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=720.05n

* CHECK dout0_29 Vdout0_29ck71 = 0 time = 720
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=720.05n

* CHECK dout0_30 Vdout0_30ck71 = 0 time = 720
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=720.05n

* CHECK dout0_31 Vdout0_31ck71 = 1.8 time = 720
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=720.05n

* CHECK dout0_32 Vdout0_32ck71 = 1.8 time = 720
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=720.05n

* CHECK dout0_33 Vdout0_33ck71 = 1.8 time = 720
.meas tran vdout0_33ck71 FIND v(dout0_33) AT=720.05n

* CHECK dout0_34 Vdout0_34ck71 = 1.8 time = 720
.meas tran vdout0_34ck71 FIND v(dout0_34) AT=720.05n

* CHECK dout0_35 Vdout0_35ck71 = 1.8 time = 720
.meas tran vdout0_35ck71 FIND v(dout0_35) AT=720.05n

* CHECK dout0_36 Vdout0_36ck71 = 1.8 time = 720
.meas tran vdout0_36ck71 FIND v(dout0_36) AT=720.05n

* CHECK dout0_37 Vdout0_37ck71 = 0 time = 720
.meas tran vdout0_37ck71 FIND v(dout0_37) AT=720.05n

* CHECK dout0_38 Vdout0_38ck71 = 1.8 time = 720
.meas tran vdout0_38ck71 FIND v(dout0_38) AT=720.05n

* CHECK dout0_39 Vdout0_39ck71 = 1.8 time = 720
.meas tran vdout0_39ck71 FIND v(dout0_39) AT=720.05n

* CHECK dout0_40 Vdout0_40ck71 = 0 time = 720
.meas tran vdout0_40ck71 FIND v(dout0_40) AT=720.05n

* CHECK dout0_41 Vdout0_41ck71 = 1.8 time = 720
.meas tran vdout0_41ck71 FIND v(dout0_41) AT=720.05n

* CHECK dout0_42 Vdout0_42ck71 = 0 time = 720
.meas tran vdout0_42ck71 FIND v(dout0_42) AT=720.05n

* CHECK dout0_43 Vdout0_43ck71 = 0 time = 720
.meas tran vdout0_43ck71 FIND v(dout0_43) AT=720.05n

* CHECK dout0_44 Vdout0_44ck71 = 1.8 time = 720
.meas tran vdout0_44ck71 FIND v(dout0_44) AT=720.05n

* CHECK dout0_45 Vdout0_45ck71 = 0 time = 720
.meas tran vdout0_45ck71 FIND v(dout0_45) AT=720.05n

* CHECK dout0_46 Vdout0_46ck71 = 1.8 time = 720
.meas tran vdout0_46ck71 FIND v(dout0_46) AT=720.05n

* CHECK dout0_47 Vdout0_47ck71 = 0 time = 720
.meas tran vdout0_47ck71 FIND v(dout0_47) AT=720.05n

* CHECK dout0_48 Vdout0_48ck71 = 0 time = 720
.meas tran vdout0_48ck71 FIND v(dout0_48) AT=720.05n

* CHECK dout0_49 Vdout0_49ck71 = 1.8 time = 720
.meas tran vdout0_49ck71 FIND v(dout0_49) AT=720.05n

* CHECK dout0_50 Vdout0_50ck71 = 0 time = 720
.meas tran vdout0_50ck71 FIND v(dout0_50) AT=720.05n

* CHECK dout0_51 Vdout0_51ck71 = 1.8 time = 720
.meas tran vdout0_51ck71 FIND v(dout0_51) AT=720.05n

* CHECK dout0_52 Vdout0_52ck71 = 1.8 time = 720
.meas tran vdout0_52ck71 FIND v(dout0_52) AT=720.05n

* CHECK dout0_53 Vdout0_53ck71 = 1.8 time = 720
.meas tran vdout0_53ck71 FIND v(dout0_53) AT=720.05n

* CHECK dout0_54 Vdout0_54ck71 = 1.8 time = 720
.meas tran vdout0_54ck71 FIND v(dout0_54) AT=720.05n

* CHECK dout0_55 Vdout0_55ck71 = 0 time = 720
.meas tran vdout0_55ck71 FIND v(dout0_55) AT=720.05n

* CHECK dout0_56 Vdout0_56ck71 = 1.8 time = 720
.meas tran vdout0_56ck71 FIND v(dout0_56) AT=720.05n

* CHECK dout0_57 Vdout0_57ck71 = 1.8 time = 720
.meas tran vdout0_57ck71 FIND v(dout0_57) AT=720.05n

* CHECK dout0_58 Vdout0_58ck71 = 0 time = 720
.meas tran vdout0_58ck71 FIND v(dout0_58) AT=720.05n

* CHECK dout0_59 Vdout0_59ck71 = 1.8 time = 720
.meas tran vdout0_59ck71 FIND v(dout0_59) AT=720.05n

* CHECK dout0_60 Vdout0_60ck71 = 1.8 time = 720
.meas tran vdout0_60ck71 FIND v(dout0_60) AT=720.05n

* CHECK dout0_61 Vdout0_61ck71 = 1.8 time = 720
.meas tran vdout0_61ck71 FIND v(dout0_61) AT=720.05n

* CHECK dout0_62 Vdout0_62ck71 = 0 time = 720
.meas tran vdout0_62ck71 FIND v(dout0_62) AT=720.05n

* CHECK dout0_63 Vdout0_63ck71 = 1.8 time = 720
.meas tran vdout0_63ck71 FIND v(dout0_63) AT=720.05n

* CHECK dout0_64 Vdout0_64ck71 = 0 time = 720
.meas tran vdout0_64ck71 FIND v(dout0_64) AT=720.05n

* CHECK dout0_0 Vdout0_0ck73 = 0 time = 740
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=740.05n

* CHECK dout0_1 Vdout0_1ck73 = 0 time = 740
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=740.05n

* CHECK dout0_2 Vdout0_2ck73 = 1.8 time = 740
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=740.05n

* CHECK dout0_3 Vdout0_3ck73 = 0 time = 740
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=740.05n

* CHECK dout0_4 Vdout0_4ck73 = 0 time = 740
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=740.05n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 740
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=740.05n

* CHECK dout0_6 Vdout0_6ck73 = 0 time = 740
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=740.05n

* CHECK dout0_7 Vdout0_7ck73 = 1.8 time = 740
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=740.05n

* CHECK dout0_8 Vdout0_8ck73 = 0 time = 740
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=740.05n

* CHECK dout0_9 Vdout0_9ck73 = 0 time = 740
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=740.05n

* CHECK dout0_10 Vdout0_10ck73 = 1.8 time = 740
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=740.05n

* CHECK dout0_11 Vdout0_11ck73 = 1.8 time = 740
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=740.05n

* CHECK dout0_12 Vdout0_12ck73 = 1.8 time = 740
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=740.05n

* CHECK dout0_13 Vdout0_13ck73 = 0 time = 740
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=740.05n

* CHECK dout0_14 Vdout0_14ck73 = 1.8 time = 740
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=740.05n

* CHECK dout0_15 Vdout0_15ck73 = 1.8 time = 740
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=740.05n

* CHECK dout0_16 Vdout0_16ck73 = 0 time = 740
.meas tran vdout0_16ck73 FIND v(dout0_16) AT=740.05n

* CHECK dout0_17 Vdout0_17ck73 = 0 time = 740
.meas tran vdout0_17ck73 FIND v(dout0_17) AT=740.05n

* CHECK dout0_18 Vdout0_18ck73 = 0 time = 740
.meas tran vdout0_18ck73 FIND v(dout0_18) AT=740.05n

* CHECK dout0_19 Vdout0_19ck73 = 1.8 time = 740
.meas tran vdout0_19ck73 FIND v(dout0_19) AT=740.05n

* CHECK dout0_20 Vdout0_20ck73 = 0 time = 740
.meas tran vdout0_20ck73 FIND v(dout0_20) AT=740.05n

* CHECK dout0_21 Vdout0_21ck73 = 1.8 time = 740
.meas tran vdout0_21ck73 FIND v(dout0_21) AT=740.05n

* CHECK dout0_22 Vdout0_22ck73 = 0 time = 740
.meas tran vdout0_22ck73 FIND v(dout0_22) AT=740.05n

* CHECK dout0_23 Vdout0_23ck73 = 1.8 time = 740
.meas tran vdout0_23ck73 FIND v(dout0_23) AT=740.05n

* CHECK dout0_24 Vdout0_24ck73 = 1.8 time = 740
.meas tran vdout0_24ck73 FIND v(dout0_24) AT=740.05n

* CHECK dout0_25 Vdout0_25ck73 = 1.8 time = 740
.meas tran vdout0_25ck73 FIND v(dout0_25) AT=740.05n

* CHECK dout0_26 Vdout0_26ck73 = 0 time = 740
.meas tran vdout0_26ck73 FIND v(dout0_26) AT=740.05n

* CHECK dout0_27 Vdout0_27ck73 = 0 time = 740
.meas tran vdout0_27ck73 FIND v(dout0_27) AT=740.05n

* CHECK dout0_28 Vdout0_28ck73 = 1.8 time = 740
.meas tran vdout0_28ck73 FIND v(dout0_28) AT=740.05n

* CHECK dout0_29 Vdout0_29ck73 = 0 time = 740
.meas tran vdout0_29ck73 FIND v(dout0_29) AT=740.05n

* CHECK dout0_30 Vdout0_30ck73 = 1.8 time = 740
.meas tran vdout0_30ck73 FIND v(dout0_30) AT=740.05n

* CHECK dout0_31 Vdout0_31ck73 = 0 time = 740
.meas tran vdout0_31ck73 FIND v(dout0_31) AT=740.05n

* CHECK dout0_32 Vdout0_32ck73 = 1.8 time = 740
.meas tran vdout0_32ck73 FIND v(dout0_32) AT=740.05n

* CHECK dout0_33 Vdout0_33ck73 = 1.8 time = 740
.meas tran vdout0_33ck73 FIND v(dout0_33) AT=740.05n

* CHECK dout0_34 Vdout0_34ck73 = 1.8 time = 740
.meas tran vdout0_34ck73 FIND v(dout0_34) AT=740.05n

* CHECK dout0_35 Vdout0_35ck73 = 0 time = 740
.meas tran vdout0_35ck73 FIND v(dout0_35) AT=740.05n

* CHECK dout0_36 Vdout0_36ck73 = 0 time = 740
.meas tran vdout0_36ck73 FIND v(dout0_36) AT=740.05n

* CHECK dout0_37 Vdout0_37ck73 = 1.8 time = 740
.meas tran vdout0_37ck73 FIND v(dout0_37) AT=740.05n

* CHECK dout0_38 Vdout0_38ck73 = 0 time = 740
.meas tran vdout0_38ck73 FIND v(dout0_38) AT=740.05n

* CHECK dout0_39 Vdout0_39ck73 = 1.8 time = 740
.meas tran vdout0_39ck73 FIND v(dout0_39) AT=740.05n

* CHECK dout0_40 Vdout0_40ck73 = 0 time = 740
.meas tran vdout0_40ck73 FIND v(dout0_40) AT=740.05n

* CHECK dout0_41 Vdout0_41ck73 = 1.8 time = 740
.meas tran vdout0_41ck73 FIND v(dout0_41) AT=740.05n

* CHECK dout0_42 Vdout0_42ck73 = 0 time = 740
.meas tran vdout0_42ck73 FIND v(dout0_42) AT=740.05n

* CHECK dout0_43 Vdout0_43ck73 = 1.8 time = 740
.meas tran vdout0_43ck73 FIND v(dout0_43) AT=740.05n

* CHECK dout0_44 Vdout0_44ck73 = 1.8 time = 740
.meas tran vdout0_44ck73 FIND v(dout0_44) AT=740.05n

* CHECK dout0_45 Vdout0_45ck73 = 1.8 time = 740
.meas tran vdout0_45ck73 FIND v(dout0_45) AT=740.05n

* CHECK dout0_46 Vdout0_46ck73 = 0 time = 740
.meas tran vdout0_46ck73 FIND v(dout0_46) AT=740.05n

* CHECK dout0_47 Vdout0_47ck73 = 0 time = 740
.meas tran vdout0_47ck73 FIND v(dout0_47) AT=740.05n

* CHECK dout0_48 Vdout0_48ck73 = 1.8 time = 740
.meas tran vdout0_48ck73 FIND v(dout0_48) AT=740.05n

* CHECK dout0_49 Vdout0_49ck73 = 1.8 time = 740
.meas tran vdout0_49ck73 FIND v(dout0_49) AT=740.05n

* CHECK dout0_50 Vdout0_50ck73 = 1.8 time = 740
.meas tran vdout0_50ck73 FIND v(dout0_50) AT=740.05n

* CHECK dout0_51 Vdout0_51ck73 = 1.8 time = 740
.meas tran vdout0_51ck73 FIND v(dout0_51) AT=740.05n

* CHECK dout0_52 Vdout0_52ck73 = 1.8 time = 740
.meas tran vdout0_52ck73 FIND v(dout0_52) AT=740.05n

* CHECK dout0_53 Vdout0_53ck73 = 1.8 time = 740
.meas tran vdout0_53ck73 FIND v(dout0_53) AT=740.05n

* CHECK dout0_54 Vdout0_54ck73 = 0 time = 740
.meas tran vdout0_54ck73 FIND v(dout0_54) AT=740.05n

* CHECK dout0_55 Vdout0_55ck73 = 0 time = 740
.meas tran vdout0_55ck73 FIND v(dout0_55) AT=740.05n

* CHECK dout0_56 Vdout0_56ck73 = 0 time = 740
.meas tran vdout0_56ck73 FIND v(dout0_56) AT=740.05n

* CHECK dout0_57 Vdout0_57ck73 = 0 time = 740
.meas tran vdout0_57ck73 FIND v(dout0_57) AT=740.05n

* CHECK dout0_58 Vdout0_58ck73 = 0 time = 740
.meas tran vdout0_58ck73 FIND v(dout0_58) AT=740.05n

* CHECK dout0_59 Vdout0_59ck73 = 1.8 time = 740
.meas tran vdout0_59ck73 FIND v(dout0_59) AT=740.05n

* CHECK dout0_60 Vdout0_60ck73 = 0 time = 740
.meas tran vdout0_60ck73 FIND v(dout0_60) AT=740.05n

* CHECK dout0_61 Vdout0_61ck73 = 0 time = 740
.meas tran vdout0_61ck73 FIND v(dout0_61) AT=740.05n

* CHECK dout0_62 Vdout0_62ck73 = 1.8 time = 740
.meas tran vdout0_62ck73 FIND v(dout0_62) AT=740.05n

* CHECK dout0_63 Vdout0_63ck73 = 0 time = 740
.meas tran vdout0_63ck73 FIND v(dout0_63) AT=740.05n

* CHECK dout0_64 Vdout0_64ck73 = 0 time = 740
.meas tran vdout0_64ck73 FIND v(dout0_64) AT=740.05n

* CHECK dout0_0 Vdout0_0ck76 = 1.8 time = 770
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=770.05n

* CHECK dout0_1 Vdout0_1ck76 = 1.8 time = 770
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=770.05n

* CHECK dout0_2 Vdout0_2ck76 = 0 time = 770
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=770.05n

* CHECK dout0_3 Vdout0_3ck76 = 0 time = 770
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=770.05n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 770
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=770.05n

* CHECK dout0_5 Vdout0_5ck76 = 1.8 time = 770
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=770.05n

* CHECK dout0_6 Vdout0_6ck76 = 1.8 time = 770
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=770.05n

* CHECK dout0_7 Vdout0_7ck76 = 0 time = 770
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=770.05n

* CHECK dout0_8 Vdout0_8ck76 = 0 time = 770
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=770.05n

* CHECK dout0_9 Vdout0_9ck76 = 0 time = 770
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=770.05n

* CHECK dout0_10 Vdout0_10ck76 = 1.8 time = 770
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=770.05n

* CHECK dout0_11 Vdout0_11ck76 = 1.8 time = 770
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=770.05n

* CHECK dout0_12 Vdout0_12ck76 = 1.8 time = 770
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=770.05n

* CHECK dout0_13 Vdout0_13ck76 = 0 time = 770
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=770.05n

* CHECK dout0_14 Vdout0_14ck76 = 0 time = 770
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=770.05n

* CHECK dout0_15 Vdout0_15ck76 = 1.8 time = 770
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=770.05n

* CHECK dout0_16 Vdout0_16ck76 = 0 time = 770
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=770.05n

* CHECK dout0_17 Vdout0_17ck76 = 1.8 time = 770
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=770.05n

* CHECK dout0_18 Vdout0_18ck76 = 0 time = 770
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=770.05n

* CHECK dout0_19 Vdout0_19ck76 = 1.8 time = 770
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=770.05n

* CHECK dout0_20 Vdout0_20ck76 = 0 time = 770
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=770.05n

* CHECK dout0_21 Vdout0_21ck76 = 0 time = 770
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=770.05n

* CHECK dout0_22 Vdout0_22ck76 = 0 time = 770
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=770.05n

* CHECK dout0_23 Vdout0_23ck76 = 1.8 time = 770
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=770.05n

* CHECK dout0_24 Vdout0_24ck76 = 1.8 time = 770
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=770.05n

* CHECK dout0_25 Vdout0_25ck76 = 0 time = 770
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=770.05n

* CHECK dout0_26 Vdout0_26ck76 = 0 time = 770
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=770.05n

* CHECK dout0_27 Vdout0_27ck76 = 1.8 time = 770
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=770.05n

* CHECK dout0_28 Vdout0_28ck76 = 1.8 time = 770
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=770.05n

* CHECK dout0_29 Vdout0_29ck76 = 1.8 time = 770
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=770.05n

* CHECK dout0_30 Vdout0_30ck76 = 1.8 time = 770
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=770.05n

* CHECK dout0_31 Vdout0_31ck76 = 0 time = 770
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=770.05n

* CHECK dout0_32 Vdout0_32ck76 = 0 time = 770
.meas tran vdout0_32ck76 FIND v(dout0_32) AT=770.05n

* CHECK dout0_33 Vdout0_33ck76 = 1.8 time = 770
.meas tran vdout0_33ck76 FIND v(dout0_33) AT=770.05n

* CHECK dout0_34 Vdout0_34ck76 = 0 time = 770
.meas tran vdout0_34ck76 FIND v(dout0_34) AT=770.05n

* CHECK dout0_35 Vdout0_35ck76 = 0 time = 770
.meas tran vdout0_35ck76 FIND v(dout0_35) AT=770.05n

* CHECK dout0_36 Vdout0_36ck76 = 1.8 time = 770
.meas tran vdout0_36ck76 FIND v(dout0_36) AT=770.05n

* CHECK dout0_37 Vdout0_37ck76 = 0 time = 770
.meas tran vdout0_37ck76 FIND v(dout0_37) AT=770.05n

* CHECK dout0_38 Vdout0_38ck76 = 1.8 time = 770
.meas tran vdout0_38ck76 FIND v(dout0_38) AT=770.05n

* CHECK dout0_39 Vdout0_39ck76 = 1.8 time = 770
.meas tran vdout0_39ck76 FIND v(dout0_39) AT=770.05n

* CHECK dout0_40 Vdout0_40ck76 = 0 time = 770
.meas tran vdout0_40ck76 FIND v(dout0_40) AT=770.05n

* CHECK dout0_41 Vdout0_41ck76 = 1.8 time = 770
.meas tran vdout0_41ck76 FIND v(dout0_41) AT=770.05n

* CHECK dout0_42 Vdout0_42ck76 = 1.8 time = 770
.meas tran vdout0_42ck76 FIND v(dout0_42) AT=770.05n

* CHECK dout0_43 Vdout0_43ck76 = 1.8 time = 770
.meas tran vdout0_43ck76 FIND v(dout0_43) AT=770.05n

* CHECK dout0_44 Vdout0_44ck76 = 1.8 time = 770
.meas tran vdout0_44ck76 FIND v(dout0_44) AT=770.05n

* CHECK dout0_45 Vdout0_45ck76 = 1.8 time = 770
.meas tran vdout0_45ck76 FIND v(dout0_45) AT=770.05n

* CHECK dout0_46 Vdout0_46ck76 = 0 time = 770
.meas tran vdout0_46ck76 FIND v(dout0_46) AT=770.05n

* CHECK dout0_47 Vdout0_47ck76 = 1.8 time = 770
.meas tran vdout0_47ck76 FIND v(dout0_47) AT=770.05n

* CHECK dout0_48 Vdout0_48ck76 = 1.8 time = 770
.meas tran vdout0_48ck76 FIND v(dout0_48) AT=770.05n

* CHECK dout0_49 Vdout0_49ck76 = 1.8 time = 770
.meas tran vdout0_49ck76 FIND v(dout0_49) AT=770.05n

* CHECK dout0_50 Vdout0_50ck76 = 1.8 time = 770
.meas tran vdout0_50ck76 FIND v(dout0_50) AT=770.05n

* CHECK dout0_51 Vdout0_51ck76 = 0 time = 770
.meas tran vdout0_51ck76 FIND v(dout0_51) AT=770.05n

* CHECK dout0_52 Vdout0_52ck76 = 0 time = 770
.meas tran vdout0_52ck76 FIND v(dout0_52) AT=770.05n

* CHECK dout0_53 Vdout0_53ck76 = 1.8 time = 770
.meas tran vdout0_53ck76 FIND v(dout0_53) AT=770.05n

* CHECK dout0_54 Vdout0_54ck76 = 1.8 time = 770
.meas tran vdout0_54ck76 FIND v(dout0_54) AT=770.05n

* CHECK dout0_55 Vdout0_55ck76 = 0 time = 770
.meas tran vdout0_55ck76 FIND v(dout0_55) AT=770.05n

* CHECK dout0_56 Vdout0_56ck76 = 0 time = 770
.meas tran vdout0_56ck76 FIND v(dout0_56) AT=770.05n

* CHECK dout0_57 Vdout0_57ck76 = 1.8 time = 770
.meas tran vdout0_57ck76 FIND v(dout0_57) AT=770.05n

* CHECK dout0_58 Vdout0_58ck76 = 1.8 time = 770
.meas tran vdout0_58ck76 FIND v(dout0_58) AT=770.05n

* CHECK dout0_59 Vdout0_59ck76 = 0 time = 770
.meas tran vdout0_59ck76 FIND v(dout0_59) AT=770.05n

* CHECK dout0_60 Vdout0_60ck76 = 1.8 time = 770
.meas tran vdout0_60ck76 FIND v(dout0_60) AT=770.05n

* CHECK dout0_61 Vdout0_61ck76 = 0 time = 770
.meas tran vdout0_61ck76 FIND v(dout0_61) AT=770.05n

* CHECK dout0_62 Vdout0_62ck76 = 0 time = 770
.meas tran vdout0_62ck76 FIND v(dout0_62) AT=770.05n

* CHECK dout0_63 Vdout0_63ck76 = 0 time = 770
.meas tran vdout0_63ck76 FIND v(dout0_63) AT=770.05n

* CHECK dout0_64 Vdout0_64ck76 = 0 time = 770
.meas tran vdout0_64ck76 FIND v(dout0_64) AT=770.05n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 800
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=800.05n

* CHECK dout0_1 Vdout0_1ck79 = 1.8 time = 800
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=800.05n

* CHECK dout0_2 Vdout0_2ck79 = 0 time = 800
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=800.05n

* CHECK dout0_3 Vdout0_3ck79 = 1.8 time = 800
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=800.05n

* CHECK dout0_4 Vdout0_4ck79 = 1.8 time = 800
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=800.05n

* CHECK dout0_5 Vdout0_5ck79 = 1.8 time = 800
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=800.05n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 800
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=800.05n

* CHECK dout0_7 Vdout0_7ck79 = 1.8 time = 800
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=800.05n

* CHECK dout0_8 Vdout0_8ck79 = 1.8 time = 800
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=800.05n

* CHECK dout0_9 Vdout0_9ck79 = 1.8 time = 800
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=800.05n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 800
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=800.05n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 800
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=800.05n

* CHECK dout0_12 Vdout0_12ck79 = 0 time = 800
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=800.05n

* CHECK dout0_13 Vdout0_13ck79 = 1.8 time = 800
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=800.05n

* CHECK dout0_14 Vdout0_14ck79 = 1.8 time = 800
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=800.05n

* CHECK dout0_15 Vdout0_15ck79 = 1.8 time = 800
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=800.05n

* CHECK dout0_16 Vdout0_16ck79 = 1.8 time = 800
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=800.05n

* CHECK dout0_17 Vdout0_17ck79 = 0 time = 800
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=800.05n

* CHECK dout0_18 Vdout0_18ck79 = 1.8 time = 800
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=800.05n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 800
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=800.05n

* CHECK dout0_20 Vdout0_20ck79 = 0 time = 800
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=800.05n

* CHECK dout0_21 Vdout0_21ck79 = 1.8 time = 800
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=800.05n

* CHECK dout0_22 Vdout0_22ck79 = 1.8 time = 800
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=800.05n

* CHECK dout0_23 Vdout0_23ck79 = 0 time = 800
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=800.05n

* CHECK dout0_24 Vdout0_24ck79 = 0 time = 800
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=800.05n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 800
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=800.05n

* CHECK dout0_26 Vdout0_26ck79 = 1.8 time = 800
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=800.05n

* CHECK dout0_27 Vdout0_27ck79 = 1.8 time = 800
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=800.05n

* CHECK dout0_28 Vdout0_28ck79 = 0 time = 800
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=800.05n

* CHECK dout0_29 Vdout0_29ck79 = 1.8 time = 800
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=800.05n

* CHECK dout0_30 Vdout0_30ck79 = 0 time = 800
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=800.05n

* CHECK dout0_31 Vdout0_31ck79 = 0 time = 800
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=800.05n

* CHECK dout0_32 Vdout0_32ck79 = 0 time = 800
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=800.05n

* CHECK dout0_33 Vdout0_33ck79 = 1.8 time = 800
.meas tran vdout0_33ck79 FIND v(dout0_33) AT=800.05n

* CHECK dout0_34 Vdout0_34ck79 = 1.8 time = 800
.meas tran vdout0_34ck79 FIND v(dout0_34) AT=800.05n

* CHECK dout0_35 Vdout0_35ck79 = 0 time = 800
.meas tran vdout0_35ck79 FIND v(dout0_35) AT=800.05n

* CHECK dout0_36 Vdout0_36ck79 = 0 time = 800
.meas tran vdout0_36ck79 FIND v(dout0_36) AT=800.05n

* CHECK dout0_37 Vdout0_37ck79 = 1.8 time = 800
.meas tran vdout0_37ck79 FIND v(dout0_37) AT=800.05n

* CHECK dout0_38 Vdout0_38ck79 = 1.8 time = 800
.meas tran vdout0_38ck79 FIND v(dout0_38) AT=800.05n

* CHECK dout0_39 Vdout0_39ck79 = 0 time = 800
.meas tran vdout0_39ck79 FIND v(dout0_39) AT=800.05n

* CHECK dout0_40 Vdout0_40ck79 = 1.8 time = 800
.meas tran vdout0_40ck79 FIND v(dout0_40) AT=800.05n

* CHECK dout0_41 Vdout0_41ck79 = 0 time = 800
.meas tran vdout0_41ck79 FIND v(dout0_41) AT=800.05n

* CHECK dout0_42 Vdout0_42ck79 = 1.8 time = 800
.meas tran vdout0_42ck79 FIND v(dout0_42) AT=800.05n

* CHECK dout0_43 Vdout0_43ck79 = 0 time = 800
.meas tran vdout0_43ck79 FIND v(dout0_43) AT=800.05n

* CHECK dout0_44 Vdout0_44ck79 = 1.8 time = 800
.meas tran vdout0_44ck79 FIND v(dout0_44) AT=800.05n

* CHECK dout0_45 Vdout0_45ck79 = 0 time = 800
.meas tran vdout0_45ck79 FIND v(dout0_45) AT=800.05n

* CHECK dout0_46 Vdout0_46ck79 = 1.8 time = 800
.meas tran vdout0_46ck79 FIND v(dout0_46) AT=800.05n

* CHECK dout0_47 Vdout0_47ck79 = 1.8 time = 800
.meas tran vdout0_47ck79 FIND v(dout0_47) AT=800.05n

* CHECK dout0_48 Vdout0_48ck79 = 1.8 time = 800
.meas tran vdout0_48ck79 FIND v(dout0_48) AT=800.05n

* CHECK dout0_49 Vdout0_49ck79 = 0 time = 800
.meas tran vdout0_49ck79 FIND v(dout0_49) AT=800.05n

* CHECK dout0_50 Vdout0_50ck79 = 0 time = 800
.meas tran vdout0_50ck79 FIND v(dout0_50) AT=800.05n

* CHECK dout0_51 Vdout0_51ck79 = 0 time = 800
.meas tran vdout0_51ck79 FIND v(dout0_51) AT=800.05n

* CHECK dout0_52 Vdout0_52ck79 = 0 time = 800
.meas tran vdout0_52ck79 FIND v(dout0_52) AT=800.05n

* CHECK dout0_53 Vdout0_53ck79 = 1.8 time = 800
.meas tran vdout0_53ck79 FIND v(dout0_53) AT=800.05n

* CHECK dout0_54 Vdout0_54ck79 = 1.8 time = 800
.meas tran vdout0_54ck79 FIND v(dout0_54) AT=800.05n

* CHECK dout0_55 Vdout0_55ck79 = 0 time = 800
.meas tran vdout0_55ck79 FIND v(dout0_55) AT=800.05n

* CHECK dout0_56 Vdout0_56ck79 = 0 time = 800
.meas tran vdout0_56ck79 FIND v(dout0_56) AT=800.05n

* CHECK dout0_57 Vdout0_57ck79 = 0 time = 800
.meas tran vdout0_57ck79 FIND v(dout0_57) AT=800.05n

* CHECK dout0_58 Vdout0_58ck79 = 0 time = 800
.meas tran vdout0_58ck79 FIND v(dout0_58) AT=800.05n

* CHECK dout0_59 Vdout0_59ck79 = 1.8 time = 800
.meas tran vdout0_59ck79 FIND v(dout0_59) AT=800.05n

* CHECK dout0_60 Vdout0_60ck79 = 1.8 time = 800
.meas tran vdout0_60ck79 FIND v(dout0_60) AT=800.05n

* CHECK dout0_61 Vdout0_61ck79 = 0 time = 800
.meas tran vdout0_61ck79 FIND v(dout0_61) AT=800.05n

* CHECK dout0_62 Vdout0_62ck79 = 1.8 time = 800
.meas tran vdout0_62ck79 FIND v(dout0_62) AT=800.05n

* CHECK dout0_63 Vdout0_63ck79 = 0 time = 800
.meas tran vdout0_63ck79 FIND v(dout0_63) AT=800.05n

* CHECK dout0_64 Vdout0_64ck79 = 0 time = 800
.meas tran vdout0_64ck79 FIND v(dout0_64) AT=800.05n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 820
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=820.05n

* CHECK dout0_1 Vdout0_1ck81 = 1.8 time = 820
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=820.05n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 820
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=820.05n

* CHECK dout0_3 Vdout0_3ck81 = 1.8 time = 820
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=820.05n

* CHECK dout0_4 Vdout0_4ck81 = 1.8 time = 820
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=820.05n

* CHECK dout0_5 Vdout0_5ck81 = 1.8 time = 820
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=820.05n

* CHECK dout0_6 Vdout0_6ck81 = 0 time = 820
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=820.05n

* CHECK dout0_7 Vdout0_7ck81 = 1.8 time = 820
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=820.05n

* CHECK dout0_8 Vdout0_8ck81 = 1.8 time = 820
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=820.05n

* CHECK dout0_9 Vdout0_9ck81 = 1.8 time = 820
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=820.05n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 820
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=820.05n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 820
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=820.05n

* CHECK dout0_12 Vdout0_12ck81 = 0 time = 820
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=820.05n

* CHECK dout0_13 Vdout0_13ck81 = 1.8 time = 820
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=820.05n

* CHECK dout0_14 Vdout0_14ck81 = 1.8 time = 820
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=820.05n

* CHECK dout0_15 Vdout0_15ck81 = 1.8 time = 820
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=820.05n

* CHECK dout0_16 Vdout0_16ck81 = 1.8 time = 820
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=820.05n

* CHECK dout0_17 Vdout0_17ck81 = 0 time = 820
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=820.05n

* CHECK dout0_18 Vdout0_18ck81 = 1.8 time = 820
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=820.05n

* CHECK dout0_19 Vdout0_19ck81 = 0 time = 820
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=820.05n

* CHECK dout0_20 Vdout0_20ck81 = 0 time = 820
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=820.05n

* CHECK dout0_21 Vdout0_21ck81 = 1.8 time = 820
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=820.05n

* CHECK dout0_22 Vdout0_22ck81 = 1.8 time = 820
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=820.05n

* CHECK dout0_23 Vdout0_23ck81 = 0 time = 820
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=820.05n

* CHECK dout0_24 Vdout0_24ck81 = 0 time = 820
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=820.05n

* CHECK dout0_25 Vdout0_25ck81 = 0 time = 820
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=820.05n

* CHECK dout0_26 Vdout0_26ck81 = 1.8 time = 820
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=820.05n

* CHECK dout0_27 Vdout0_27ck81 = 1.8 time = 820
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=820.05n

* CHECK dout0_28 Vdout0_28ck81 = 0 time = 820
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=820.05n

* CHECK dout0_29 Vdout0_29ck81 = 1.8 time = 820
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=820.05n

* CHECK dout0_30 Vdout0_30ck81 = 0 time = 820
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=820.05n

* CHECK dout0_31 Vdout0_31ck81 = 0 time = 820
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=820.05n

* CHECK dout0_32 Vdout0_32ck81 = 0 time = 820
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=820.05n

* CHECK dout0_33 Vdout0_33ck81 = 1.8 time = 820
.meas tran vdout0_33ck81 FIND v(dout0_33) AT=820.05n

* CHECK dout0_34 Vdout0_34ck81 = 1.8 time = 820
.meas tran vdout0_34ck81 FIND v(dout0_34) AT=820.05n

* CHECK dout0_35 Vdout0_35ck81 = 0 time = 820
.meas tran vdout0_35ck81 FIND v(dout0_35) AT=820.05n

* CHECK dout0_36 Vdout0_36ck81 = 0 time = 820
.meas tran vdout0_36ck81 FIND v(dout0_36) AT=820.05n

* CHECK dout0_37 Vdout0_37ck81 = 1.8 time = 820
.meas tran vdout0_37ck81 FIND v(dout0_37) AT=820.05n

* CHECK dout0_38 Vdout0_38ck81 = 1.8 time = 820
.meas tran vdout0_38ck81 FIND v(dout0_38) AT=820.05n

* CHECK dout0_39 Vdout0_39ck81 = 0 time = 820
.meas tran vdout0_39ck81 FIND v(dout0_39) AT=820.05n

* CHECK dout0_40 Vdout0_40ck81 = 1.8 time = 820
.meas tran vdout0_40ck81 FIND v(dout0_40) AT=820.05n

* CHECK dout0_41 Vdout0_41ck81 = 0 time = 820
.meas tran vdout0_41ck81 FIND v(dout0_41) AT=820.05n

* CHECK dout0_42 Vdout0_42ck81 = 1.8 time = 820
.meas tran vdout0_42ck81 FIND v(dout0_42) AT=820.05n

* CHECK dout0_43 Vdout0_43ck81 = 0 time = 820
.meas tran vdout0_43ck81 FIND v(dout0_43) AT=820.05n

* CHECK dout0_44 Vdout0_44ck81 = 1.8 time = 820
.meas tran vdout0_44ck81 FIND v(dout0_44) AT=820.05n

* CHECK dout0_45 Vdout0_45ck81 = 0 time = 820
.meas tran vdout0_45ck81 FIND v(dout0_45) AT=820.05n

* CHECK dout0_46 Vdout0_46ck81 = 1.8 time = 820
.meas tran vdout0_46ck81 FIND v(dout0_46) AT=820.05n

* CHECK dout0_47 Vdout0_47ck81 = 1.8 time = 820
.meas tran vdout0_47ck81 FIND v(dout0_47) AT=820.05n

* CHECK dout0_48 Vdout0_48ck81 = 1.8 time = 820
.meas tran vdout0_48ck81 FIND v(dout0_48) AT=820.05n

* CHECK dout0_49 Vdout0_49ck81 = 0 time = 820
.meas tran vdout0_49ck81 FIND v(dout0_49) AT=820.05n

* CHECK dout0_50 Vdout0_50ck81 = 0 time = 820
.meas tran vdout0_50ck81 FIND v(dout0_50) AT=820.05n

* CHECK dout0_51 Vdout0_51ck81 = 0 time = 820
.meas tran vdout0_51ck81 FIND v(dout0_51) AT=820.05n

* CHECK dout0_52 Vdout0_52ck81 = 0 time = 820
.meas tran vdout0_52ck81 FIND v(dout0_52) AT=820.05n

* CHECK dout0_53 Vdout0_53ck81 = 1.8 time = 820
.meas tran vdout0_53ck81 FIND v(dout0_53) AT=820.05n

* CHECK dout0_54 Vdout0_54ck81 = 1.8 time = 820
.meas tran vdout0_54ck81 FIND v(dout0_54) AT=820.05n

* CHECK dout0_55 Vdout0_55ck81 = 0 time = 820
.meas tran vdout0_55ck81 FIND v(dout0_55) AT=820.05n

* CHECK dout0_56 Vdout0_56ck81 = 0 time = 820
.meas tran vdout0_56ck81 FIND v(dout0_56) AT=820.05n

* CHECK dout0_57 Vdout0_57ck81 = 0 time = 820
.meas tran vdout0_57ck81 FIND v(dout0_57) AT=820.05n

* CHECK dout0_58 Vdout0_58ck81 = 0 time = 820
.meas tran vdout0_58ck81 FIND v(dout0_58) AT=820.05n

* CHECK dout0_59 Vdout0_59ck81 = 1.8 time = 820
.meas tran vdout0_59ck81 FIND v(dout0_59) AT=820.05n

* CHECK dout0_60 Vdout0_60ck81 = 1.8 time = 820
.meas tran vdout0_60ck81 FIND v(dout0_60) AT=820.05n

* CHECK dout0_61 Vdout0_61ck81 = 0 time = 820
.meas tran vdout0_61ck81 FIND v(dout0_61) AT=820.05n

* CHECK dout0_62 Vdout0_62ck81 = 1.8 time = 820
.meas tran vdout0_62ck81 FIND v(dout0_62) AT=820.05n

* CHECK dout0_63 Vdout0_63ck81 = 0 time = 820
.meas tran vdout0_63ck81 FIND v(dout0_63) AT=820.05n

* CHECK dout0_64 Vdout0_64ck81 = 0 time = 820
.meas tran vdout0_64ck81 FIND v(dout0_64) AT=820.05n

* CHECK dout0_0 Vdout0_0ck82 = 1.8 time = 830
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=830.05n

* CHECK dout0_1 Vdout0_1ck82 = 0 time = 830
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=830.05n

* CHECK dout0_2 Vdout0_2ck82 = 1.8 time = 830
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=830.05n

* CHECK dout0_3 Vdout0_3ck82 = 0 time = 830
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=830.05n

* CHECK dout0_4 Vdout0_4ck82 = 1.8 time = 830
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=830.05n

* CHECK dout0_5 Vdout0_5ck82 = 0 time = 830
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=830.05n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 830
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=830.05n

* CHECK dout0_7 Vdout0_7ck82 = 0 time = 830
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=830.05n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 830
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=830.05n

* CHECK dout0_9 Vdout0_9ck82 = 0 time = 830
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=830.05n

* CHECK dout0_10 Vdout0_10ck82 = 1.8 time = 830
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=830.05n

* CHECK dout0_11 Vdout0_11ck82 = 0 time = 830
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=830.05n

* CHECK dout0_12 Vdout0_12ck82 = 0 time = 830
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=830.05n

* CHECK dout0_13 Vdout0_13ck82 = 0 time = 830
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=830.05n

* CHECK dout0_14 Vdout0_14ck82 = 0 time = 830
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=830.05n

* CHECK dout0_15 Vdout0_15ck82 = 0 time = 830
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=830.05n

* CHECK dout0_16 Vdout0_16ck82 = 1.8 time = 830
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=830.05n

* CHECK dout0_17 Vdout0_17ck82 = 0 time = 830
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=830.05n

* CHECK dout0_18 Vdout0_18ck82 = 0 time = 830
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=830.05n

* CHECK dout0_19 Vdout0_19ck82 = 1.8 time = 830
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=830.05n

* CHECK dout0_20 Vdout0_20ck82 = 1.8 time = 830
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=830.05n

* CHECK dout0_21 Vdout0_21ck82 = 0 time = 830
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=830.05n

* CHECK dout0_22 Vdout0_22ck82 = 0 time = 830
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=830.05n

* CHECK dout0_23 Vdout0_23ck82 = 1.8 time = 830
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=830.05n

* CHECK dout0_24 Vdout0_24ck82 = 1.8 time = 830
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=830.05n

* CHECK dout0_25 Vdout0_25ck82 = 1.8 time = 830
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=830.05n

* CHECK dout0_26 Vdout0_26ck82 = 1.8 time = 830
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=830.05n

* CHECK dout0_27 Vdout0_27ck82 = 0 time = 830
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=830.05n

* CHECK dout0_28 Vdout0_28ck82 = 0 time = 830
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=830.05n

* CHECK dout0_29 Vdout0_29ck82 = 0 time = 830
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=830.05n

* CHECK dout0_30 Vdout0_30ck82 = 1.8 time = 830
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=830.05n

* CHECK dout0_31 Vdout0_31ck82 = 0 time = 830
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=830.05n

* CHECK dout0_32 Vdout0_32ck82 = 0 time = 830
.meas tran vdout0_32ck82 FIND v(dout0_32) AT=830.05n

* CHECK dout0_33 Vdout0_33ck82 = 0 time = 830
.meas tran vdout0_33ck82 FIND v(dout0_33) AT=830.05n

* CHECK dout0_34 Vdout0_34ck82 = 0 time = 830
.meas tran vdout0_34ck82 FIND v(dout0_34) AT=830.05n

* CHECK dout0_35 Vdout0_35ck82 = 1.8 time = 830
.meas tran vdout0_35ck82 FIND v(dout0_35) AT=830.05n

* CHECK dout0_36 Vdout0_36ck82 = 0 time = 830
.meas tran vdout0_36ck82 FIND v(dout0_36) AT=830.05n

* CHECK dout0_37 Vdout0_37ck82 = 1.8 time = 830
.meas tran vdout0_37ck82 FIND v(dout0_37) AT=830.05n

* CHECK dout0_38 Vdout0_38ck82 = 0 time = 830
.meas tran vdout0_38ck82 FIND v(dout0_38) AT=830.05n

* CHECK dout0_39 Vdout0_39ck82 = 0 time = 830
.meas tran vdout0_39ck82 FIND v(dout0_39) AT=830.05n

* CHECK dout0_40 Vdout0_40ck82 = 1.8 time = 830
.meas tran vdout0_40ck82 FIND v(dout0_40) AT=830.05n

* CHECK dout0_41 Vdout0_41ck82 = 0 time = 830
.meas tran vdout0_41ck82 FIND v(dout0_41) AT=830.05n

* CHECK dout0_42 Vdout0_42ck82 = 0 time = 830
.meas tran vdout0_42ck82 FIND v(dout0_42) AT=830.05n

* CHECK dout0_43 Vdout0_43ck82 = 0 time = 830
.meas tran vdout0_43ck82 FIND v(dout0_43) AT=830.05n

* CHECK dout0_44 Vdout0_44ck82 = 0 time = 830
.meas tran vdout0_44ck82 FIND v(dout0_44) AT=830.05n

* CHECK dout0_45 Vdout0_45ck82 = 1.8 time = 830
.meas tran vdout0_45ck82 FIND v(dout0_45) AT=830.05n

* CHECK dout0_46 Vdout0_46ck82 = 1.8 time = 830
.meas tran vdout0_46ck82 FIND v(dout0_46) AT=830.05n

* CHECK dout0_47 Vdout0_47ck82 = 0 time = 830
.meas tran vdout0_47ck82 FIND v(dout0_47) AT=830.05n

* CHECK dout0_48 Vdout0_48ck82 = 0 time = 830
.meas tran vdout0_48ck82 FIND v(dout0_48) AT=830.05n

* CHECK dout0_49 Vdout0_49ck82 = 1.8 time = 830
.meas tran vdout0_49ck82 FIND v(dout0_49) AT=830.05n

* CHECK dout0_50 Vdout0_50ck82 = 0 time = 830
.meas tran vdout0_50ck82 FIND v(dout0_50) AT=830.05n

* CHECK dout0_51 Vdout0_51ck82 = 0 time = 830
.meas tran vdout0_51ck82 FIND v(dout0_51) AT=830.05n

* CHECK dout0_52 Vdout0_52ck82 = 1.8 time = 830
.meas tran vdout0_52ck82 FIND v(dout0_52) AT=830.05n

* CHECK dout0_53 Vdout0_53ck82 = 0 time = 830
.meas tran vdout0_53ck82 FIND v(dout0_53) AT=830.05n

* CHECK dout0_54 Vdout0_54ck82 = 1.8 time = 830
.meas tran vdout0_54ck82 FIND v(dout0_54) AT=830.05n

* CHECK dout0_55 Vdout0_55ck82 = 1.8 time = 830
.meas tran vdout0_55ck82 FIND v(dout0_55) AT=830.05n

* CHECK dout0_56 Vdout0_56ck82 = 0 time = 830
.meas tran vdout0_56ck82 FIND v(dout0_56) AT=830.05n

* CHECK dout0_57 Vdout0_57ck82 = 0 time = 830
.meas tran vdout0_57ck82 FIND v(dout0_57) AT=830.05n

* CHECK dout0_58 Vdout0_58ck82 = 1.8 time = 830
.meas tran vdout0_58ck82 FIND v(dout0_58) AT=830.05n

* CHECK dout0_59 Vdout0_59ck82 = 0 time = 830
.meas tran vdout0_59ck82 FIND v(dout0_59) AT=830.05n

* CHECK dout0_60 Vdout0_60ck82 = 0 time = 830
.meas tran vdout0_60ck82 FIND v(dout0_60) AT=830.05n

* CHECK dout0_61 Vdout0_61ck82 = 1.8 time = 830
.meas tran vdout0_61ck82 FIND v(dout0_61) AT=830.05n

* CHECK dout0_62 Vdout0_62ck82 = 1.8 time = 830
.meas tran vdout0_62ck82 FIND v(dout0_62) AT=830.05n

* CHECK dout0_63 Vdout0_63ck82 = 1.8 time = 830
.meas tran vdout0_63ck82 FIND v(dout0_63) AT=830.05n

* CHECK dout0_64 Vdout0_64ck82 = 0 time = 830
.meas tran vdout0_64ck82 FIND v(dout0_64) AT=830.05n

* CHECK dout0_0 Vdout0_0ck84 = 0 time = 850
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=850.05n

* CHECK dout0_1 Vdout0_1ck84 = 0 time = 850
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=850.05n

* CHECK dout0_2 Vdout0_2ck84 = 1.8 time = 850
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=850.05n

* CHECK dout0_3 Vdout0_3ck84 = 0 time = 850
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=850.05n

* CHECK dout0_4 Vdout0_4ck84 = 0 time = 850
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=850.05n

* CHECK dout0_5 Vdout0_5ck84 = 0 time = 850
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=850.05n

* CHECK dout0_6 Vdout0_6ck84 = 0 time = 850
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=850.05n

* CHECK dout0_7 Vdout0_7ck84 = 1.8 time = 850
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=850.05n

* CHECK dout0_8 Vdout0_8ck84 = 0 time = 850
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=850.05n

* CHECK dout0_9 Vdout0_9ck84 = 0 time = 850
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=850.05n

* CHECK dout0_10 Vdout0_10ck84 = 1.8 time = 850
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=850.05n

* CHECK dout0_11 Vdout0_11ck84 = 1.8 time = 850
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=850.05n

* CHECK dout0_12 Vdout0_12ck84 = 1.8 time = 850
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=850.05n

* CHECK dout0_13 Vdout0_13ck84 = 0 time = 850
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=850.05n

* CHECK dout0_14 Vdout0_14ck84 = 1.8 time = 850
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=850.05n

* CHECK dout0_15 Vdout0_15ck84 = 1.8 time = 850
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=850.05n

* CHECK dout0_16 Vdout0_16ck84 = 0 time = 850
.meas tran vdout0_16ck84 FIND v(dout0_16) AT=850.05n

* CHECK dout0_17 Vdout0_17ck84 = 0 time = 850
.meas tran vdout0_17ck84 FIND v(dout0_17) AT=850.05n

* CHECK dout0_18 Vdout0_18ck84 = 0 time = 850
.meas tran vdout0_18ck84 FIND v(dout0_18) AT=850.05n

* CHECK dout0_19 Vdout0_19ck84 = 1.8 time = 850
.meas tran vdout0_19ck84 FIND v(dout0_19) AT=850.05n

* CHECK dout0_20 Vdout0_20ck84 = 0 time = 850
.meas tran vdout0_20ck84 FIND v(dout0_20) AT=850.05n

* CHECK dout0_21 Vdout0_21ck84 = 1.8 time = 850
.meas tran vdout0_21ck84 FIND v(dout0_21) AT=850.05n

* CHECK dout0_22 Vdout0_22ck84 = 0 time = 850
.meas tran vdout0_22ck84 FIND v(dout0_22) AT=850.05n

* CHECK dout0_23 Vdout0_23ck84 = 1.8 time = 850
.meas tran vdout0_23ck84 FIND v(dout0_23) AT=850.05n

* CHECK dout0_24 Vdout0_24ck84 = 1.8 time = 850
.meas tran vdout0_24ck84 FIND v(dout0_24) AT=850.05n

* CHECK dout0_25 Vdout0_25ck84 = 1.8 time = 850
.meas tran vdout0_25ck84 FIND v(dout0_25) AT=850.05n

* CHECK dout0_26 Vdout0_26ck84 = 0 time = 850
.meas tran vdout0_26ck84 FIND v(dout0_26) AT=850.05n

* CHECK dout0_27 Vdout0_27ck84 = 0 time = 850
.meas tran vdout0_27ck84 FIND v(dout0_27) AT=850.05n

* CHECK dout0_28 Vdout0_28ck84 = 1.8 time = 850
.meas tran vdout0_28ck84 FIND v(dout0_28) AT=850.05n

* CHECK dout0_29 Vdout0_29ck84 = 0 time = 850
.meas tran vdout0_29ck84 FIND v(dout0_29) AT=850.05n

* CHECK dout0_30 Vdout0_30ck84 = 1.8 time = 850
.meas tran vdout0_30ck84 FIND v(dout0_30) AT=850.05n

* CHECK dout0_31 Vdout0_31ck84 = 0 time = 850
.meas tran vdout0_31ck84 FIND v(dout0_31) AT=850.05n

* CHECK dout0_32 Vdout0_32ck84 = 1.8 time = 850
.meas tran vdout0_32ck84 FIND v(dout0_32) AT=850.05n

* CHECK dout0_33 Vdout0_33ck84 = 1.8 time = 850
.meas tran vdout0_33ck84 FIND v(dout0_33) AT=850.05n

* CHECK dout0_34 Vdout0_34ck84 = 1.8 time = 850
.meas tran vdout0_34ck84 FIND v(dout0_34) AT=850.05n

* CHECK dout0_35 Vdout0_35ck84 = 0 time = 850
.meas tran vdout0_35ck84 FIND v(dout0_35) AT=850.05n

* CHECK dout0_36 Vdout0_36ck84 = 0 time = 850
.meas tran vdout0_36ck84 FIND v(dout0_36) AT=850.05n

* CHECK dout0_37 Vdout0_37ck84 = 1.8 time = 850
.meas tran vdout0_37ck84 FIND v(dout0_37) AT=850.05n

* CHECK dout0_38 Vdout0_38ck84 = 0 time = 850
.meas tran vdout0_38ck84 FIND v(dout0_38) AT=850.05n

* CHECK dout0_39 Vdout0_39ck84 = 1.8 time = 850
.meas tran vdout0_39ck84 FIND v(dout0_39) AT=850.05n

* CHECK dout0_40 Vdout0_40ck84 = 0 time = 850
.meas tran vdout0_40ck84 FIND v(dout0_40) AT=850.05n

* CHECK dout0_41 Vdout0_41ck84 = 1.8 time = 850
.meas tran vdout0_41ck84 FIND v(dout0_41) AT=850.05n

* CHECK dout0_42 Vdout0_42ck84 = 0 time = 850
.meas tran vdout0_42ck84 FIND v(dout0_42) AT=850.05n

* CHECK dout0_43 Vdout0_43ck84 = 1.8 time = 850
.meas tran vdout0_43ck84 FIND v(dout0_43) AT=850.05n

* CHECK dout0_44 Vdout0_44ck84 = 1.8 time = 850
.meas tran vdout0_44ck84 FIND v(dout0_44) AT=850.05n

* CHECK dout0_45 Vdout0_45ck84 = 1.8 time = 850
.meas tran vdout0_45ck84 FIND v(dout0_45) AT=850.05n

* CHECK dout0_46 Vdout0_46ck84 = 0 time = 850
.meas tran vdout0_46ck84 FIND v(dout0_46) AT=850.05n

* CHECK dout0_47 Vdout0_47ck84 = 0 time = 850
.meas tran vdout0_47ck84 FIND v(dout0_47) AT=850.05n

* CHECK dout0_48 Vdout0_48ck84 = 1.8 time = 850
.meas tran vdout0_48ck84 FIND v(dout0_48) AT=850.05n

* CHECK dout0_49 Vdout0_49ck84 = 1.8 time = 850
.meas tran vdout0_49ck84 FIND v(dout0_49) AT=850.05n

* CHECK dout0_50 Vdout0_50ck84 = 1.8 time = 850
.meas tran vdout0_50ck84 FIND v(dout0_50) AT=850.05n

* CHECK dout0_51 Vdout0_51ck84 = 1.8 time = 850
.meas tran vdout0_51ck84 FIND v(dout0_51) AT=850.05n

* CHECK dout0_52 Vdout0_52ck84 = 1.8 time = 850
.meas tran vdout0_52ck84 FIND v(dout0_52) AT=850.05n

* CHECK dout0_53 Vdout0_53ck84 = 1.8 time = 850
.meas tran vdout0_53ck84 FIND v(dout0_53) AT=850.05n

* CHECK dout0_54 Vdout0_54ck84 = 0 time = 850
.meas tran vdout0_54ck84 FIND v(dout0_54) AT=850.05n

* CHECK dout0_55 Vdout0_55ck84 = 0 time = 850
.meas tran vdout0_55ck84 FIND v(dout0_55) AT=850.05n

* CHECK dout0_56 Vdout0_56ck84 = 0 time = 850
.meas tran vdout0_56ck84 FIND v(dout0_56) AT=850.05n

* CHECK dout0_57 Vdout0_57ck84 = 0 time = 850
.meas tran vdout0_57ck84 FIND v(dout0_57) AT=850.05n

* CHECK dout0_58 Vdout0_58ck84 = 0 time = 850
.meas tran vdout0_58ck84 FIND v(dout0_58) AT=850.05n

* CHECK dout0_59 Vdout0_59ck84 = 1.8 time = 850
.meas tran vdout0_59ck84 FIND v(dout0_59) AT=850.05n

* CHECK dout0_60 Vdout0_60ck84 = 0 time = 850
.meas tran vdout0_60ck84 FIND v(dout0_60) AT=850.05n

* CHECK dout0_61 Vdout0_61ck84 = 0 time = 850
.meas tran vdout0_61ck84 FIND v(dout0_61) AT=850.05n

* CHECK dout0_62 Vdout0_62ck84 = 1.8 time = 850
.meas tran vdout0_62ck84 FIND v(dout0_62) AT=850.05n

* CHECK dout0_63 Vdout0_63ck84 = 0 time = 850
.meas tran vdout0_63ck84 FIND v(dout0_63) AT=850.05n

* CHECK dout0_64 Vdout0_64ck84 = 0 time = 850
.meas tran vdout0_64ck84 FIND v(dout0_64) AT=850.05n

* CHECK dout0_0 Vdout0_0ck85 = 0 time = 860
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=860.05n

* CHECK dout0_1 Vdout0_1ck85 = 1.8 time = 860
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=860.05n

* CHECK dout0_2 Vdout0_2ck85 = 1.8 time = 860
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=860.05n

* CHECK dout0_3 Vdout0_3ck85 = 0 time = 860
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=860.05n

* CHECK dout0_4 Vdout0_4ck85 = 1.8 time = 860
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=860.05n

* CHECK dout0_5 Vdout0_5ck85 = 1.8 time = 860
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=860.05n

* CHECK dout0_6 Vdout0_6ck85 = 0 time = 860
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=860.05n

* CHECK dout0_7 Vdout0_7ck85 = 1.8 time = 860
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=860.05n

* CHECK dout0_8 Vdout0_8ck85 = 1.8 time = 860
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=860.05n

* CHECK dout0_9 Vdout0_9ck85 = 1.8 time = 860
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=860.05n

* CHECK dout0_10 Vdout0_10ck85 = 0 time = 860
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=860.05n

* CHECK dout0_11 Vdout0_11ck85 = 0 time = 860
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=860.05n

* CHECK dout0_12 Vdout0_12ck85 = 0 time = 860
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=860.05n

* CHECK dout0_13 Vdout0_13ck85 = 0 time = 860
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=860.05n

* CHECK dout0_14 Vdout0_14ck85 = 0 time = 860
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=860.05n

* CHECK dout0_15 Vdout0_15ck85 = 0 time = 860
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=860.05n

* CHECK dout0_16 Vdout0_16ck85 = 1.8 time = 860
.meas tran vdout0_16ck85 FIND v(dout0_16) AT=860.05n

* CHECK dout0_17 Vdout0_17ck85 = 0 time = 860
.meas tran vdout0_17ck85 FIND v(dout0_17) AT=860.05n

* CHECK dout0_18 Vdout0_18ck85 = 1.8 time = 860
.meas tran vdout0_18ck85 FIND v(dout0_18) AT=860.05n

* CHECK dout0_19 Vdout0_19ck85 = 1.8 time = 860
.meas tran vdout0_19ck85 FIND v(dout0_19) AT=860.05n

* CHECK dout0_20 Vdout0_20ck85 = 1.8 time = 860
.meas tran vdout0_20ck85 FIND v(dout0_20) AT=860.05n

* CHECK dout0_21 Vdout0_21ck85 = 0 time = 860
.meas tran vdout0_21ck85 FIND v(dout0_21) AT=860.05n

* CHECK dout0_22 Vdout0_22ck85 = 0 time = 860
.meas tran vdout0_22ck85 FIND v(dout0_22) AT=860.05n

* CHECK dout0_23 Vdout0_23ck85 = 0 time = 860
.meas tran vdout0_23ck85 FIND v(dout0_23) AT=860.05n

* CHECK dout0_24 Vdout0_24ck85 = 0 time = 860
.meas tran vdout0_24ck85 FIND v(dout0_24) AT=860.05n

* CHECK dout0_25 Vdout0_25ck85 = 0 time = 860
.meas tran vdout0_25ck85 FIND v(dout0_25) AT=860.05n

* CHECK dout0_26 Vdout0_26ck85 = 1.8 time = 860
.meas tran vdout0_26ck85 FIND v(dout0_26) AT=860.05n

* CHECK dout0_27 Vdout0_27ck85 = 1.8 time = 860
.meas tran vdout0_27ck85 FIND v(dout0_27) AT=860.05n

* CHECK dout0_28 Vdout0_28ck85 = 0 time = 860
.meas tran vdout0_28ck85 FIND v(dout0_28) AT=860.05n

* CHECK dout0_29 Vdout0_29ck85 = 0 time = 860
.meas tran vdout0_29ck85 FIND v(dout0_29) AT=860.05n

* CHECK dout0_30 Vdout0_30ck85 = 0 time = 860
.meas tran vdout0_30ck85 FIND v(dout0_30) AT=860.05n

* CHECK dout0_31 Vdout0_31ck85 = 1.8 time = 860
.meas tran vdout0_31ck85 FIND v(dout0_31) AT=860.05n

* CHECK dout0_32 Vdout0_32ck85 = 1.8 time = 860
.meas tran vdout0_32ck85 FIND v(dout0_32) AT=860.05n

* CHECK dout0_33 Vdout0_33ck85 = 1.8 time = 860
.meas tran vdout0_33ck85 FIND v(dout0_33) AT=860.05n

* CHECK dout0_34 Vdout0_34ck85 = 1.8 time = 860
.meas tran vdout0_34ck85 FIND v(dout0_34) AT=860.05n

* CHECK dout0_35 Vdout0_35ck85 = 1.8 time = 860
.meas tran vdout0_35ck85 FIND v(dout0_35) AT=860.05n

* CHECK dout0_36 Vdout0_36ck85 = 1.8 time = 860
.meas tran vdout0_36ck85 FIND v(dout0_36) AT=860.05n

* CHECK dout0_37 Vdout0_37ck85 = 1.8 time = 860
.meas tran vdout0_37ck85 FIND v(dout0_37) AT=860.05n

* CHECK dout0_38 Vdout0_38ck85 = 1.8 time = 860
.meas tran vdout0_38ck85 FIND v(dout0_38) AT=860.05n

* CHECK dout0_39 Vdout0_39ck85 = 1.8 time = 860
.meas tran vdout0_39ck85 FIND v(dout0_39) AT=860.05n

* CHECK dout0_40 Vdout0_40ck85 = 0 time = 860
.meas tran vdout0_40ck85 FIND v(dout0_40) AT=860.05n

* CHECK dout0_41 Vdout0_41ck85 = 0 time = 860
.meas tran vdout0_41ck85 FIND v(dout0_41) AT=860.05n

* CHECK dout0_42 Vdout0_42ck85 = 0 time = 860
.meas tran vdout0_42ck85 FIND v(dout0_42) AT=860.05n

* CHECK dout0_43 Vdout0_43ck85 = 0 time = 860
.meas tran vdout0_43ck85 FIND v(dout0_43) AT=860.05n

* CHECK dout0_44 Vdout0_44ck85 = 1.8 time = 860
.meas tran vdout0_44ck85 FIND v(dout0_44) AT=860.05n

* CHECK dout0_45 Vdout0_45ck85 = 1.8 time = 860
.meas tran vdout0_45ck85 FIND v(dout0_45) AT=860.05n

* CHECK dout0_46 Vdout0_46ck85 = 0 time = 860
.meas tran vdout0_46ck85 FIND v(dout0_46) AT=860.05n

* CHECK dout0_47 Vdout0_47ck85 = 1.8 time = 860
.meas tran vdout0_47ck85 FIND v(dout0_47) AT=860.05n

* CHECK dout0_48 Vdout0_48ck85 = 1.8 time = 860
.meas tran vdout0_48ck85 FIND v(dout0_48) AT=860.05n

* CHECK dout0_49 Vdout0_49ck85 = 1.8 time = 860
.meas tran vdout0_49ck85 FIND v(dout0_49) AT=860.05n

* CHECK dout0_50 Vdout0_50ck85 = 0 time = 860
.meas tran vdout0_50ck85 FIND v(dout0_50) AT=860.05n

* CHECK dout0_51 Vdout0_51ck85 = 0 time = 860
.meas tran vdout0_51ck85 FIND v(dout0_51) AT=860.05n

* CHECK dout0_52 Vdout0_52ck85 = 0 time = 860
.meas tran vdout0_52ck85 FIND v(dout0_52) AT=860.05n

* CHECK dout0_53 Vdout0_53ck85 = 1.8 time = 860
.meas tran vdout0_53ck85 FIND v(dout0_53) AT=860.05n

* CHECK dout0_54 Vdout0_54ck85 = 0 time = 860
.meas tran vdout0_54ck85 FIND v(dout0_54) AT=860.05n

* CHECK dout0_55 Vdout0_55ck85 = 0 time = 860
.meas tran vdout0_55ck85 FIND v(dout0_55) AT=860.05n

* CHECK dout0_56 Vdout0_56ck85 = 0 time = 860
.meas tran vdout0_56ck85 FIND v(dout0_56) AT=860.05n

* CHECK dout0_57 Vdout0_57ck85 = 1.8 time = 860
.meas tran vdout0_57ck85 FIND v(dout0_57) AT=860.05n

* CHECK dout0_58 Vdout0_58ck85 = 0 time = 860
.meas tran vdout0_58ck85 FIND v(dout0_58) AT=860.05n

* CHECK dout0_59 Vdout0_59ck85 = 1.8 time = 860
.meas tran vdout0_59ck85 FIND v(dout0_59) AT=860.05n

* CHECK dout0_60 Vdout0_60ck85 = 0 time = 860
.meas tran vdout0_60ck85 FIND v(dout0_60) AT=860.05n

* CHECK dout0_61 Vdout0_61ck85 = 0 time = 860
.meas tran vdout0_61ck85 FIND v(dout0_61) AT=860.05n

* CHECK dout0_62 Vdout0_62ck85 = 0 time = 860
.meas tran vdout0_62ck85 FIND v(dout0_62) AT=860.05n

* CHECK dout0_63 Vdout0_63ck85 = 1.8 time = 860
.meas tran vdout0_63ck85 FIND v(dout0_63) AT=860.05n

* CHECK dout0_64 Vdout0_64ck85 = 0 time = 860
.meas tran vdout0_64ck85 FIND v(dout0_64) AT=860.05n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 900
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=900.05n

* CHECK dout0_1 Vdout0_1ck89 = 1.8 time = 900
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=900.05n

* CHECK dout0_2 Vdout0_2ck89 = 1.8 time = 900
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=900.05n

* CHECK dout0_3 Vdout0_3ck89 = 1.8 time = 900
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=900.05n

* CHECK dout0_4 Vdout0_4ck89 = 1.8 time = 900
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=900.05n

* CHECK dout0_5 Vdout0_5ck89 = 1.8 time = 900
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=900.05n

* CHECK dout0_6 Vdout0_6ck89 = 1.8 time = 900
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=900.05n

* CHECK dout0_7 Vdout0_7ck89 = 1.8 time = 900
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=900.05n

* CHECK dout0_8 Vdout0_8ck89 = 1.8 time = 900
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=900.05n

* CHECK dout0_9 Vdout0_9ck89 = 0 time = 900
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=900.05n

* CHECK dout0_10 Vdout0_10ck89 = 1.8 time = 900
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=900.05n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 900
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=900.05n

* CHECK dout0_12 Vdout0_12ck89 = 1.8 time = 900
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=900.05n

* CHECK dout0_13 Vdout0_13ck89 = 0 time = 900
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=900.05n

* CHECK dout0_14 Vdout0_14ck89 = 1.8 time = 900
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=900.05n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 900
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=900.05n

* CHECK dout0_16 Vdout0_16ck89 = 1.8 time = 900
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=900.05n

* CHECK dout0_17 Vdout0_17ck89 = 0 time = 900
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=900.05n

* CHECK dout0_18 Vdout0_18ck89 = 1.8 time = 900
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=900.05n

* CHECK dout0_19 Vdout0_19ck89 = 0 time = 900
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=900.05n

* CHECK dout0_20 Vdout0_20ck89 = 1.8 time = 900
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=900.05n

* CHECK dout0_21 Vdout0_21ck89 = 0 time = 900
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=900.05n

* CHECK dout0_22 Vdout0_22ck89 = 1.8 time = 900
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=900.05n

* CHECK dout0_23 Vdout0_23ck89 = 0 time = 900
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=900.05n

* CHECK dout0_24 Vdout0_24ck89 = 1.8 time = 900
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=900.05n

* CHECK dout0_25 Vdout0_25ck89 = 1.8 time = 900
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=900.05n

* CHECK dout0_26 Vdout0_26ck89 = 0 time = 900
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=900.05n

* CHECK dout0_27 Vdout0_27ck89 = 0 time = 900
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=900.05n

* CHECK dout0_28 Vdout0_28ck89 = 0 time = 900
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=900.05n

* CHECK dout0_29 Vdout0_29ck89 = 0 time = 900
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=900.05n

* CHECK dout0_30 Vdout0_30ck89 = 1.8 time = 900
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=900.05n

* CHECK dout0_31 Vdout0_31ck89 = 0 time = 900
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=900.05n

* CHECK dout0_32 Vdout0_32ck89 = 1.8 time = 900
.meas tran vdout0_32ck89 FIND v(dout0_32) AT=900.05n

* CHECK dout0_33 Vdout0_33ck89 = 0 time = 900
.meas tran vdout0_33ck89 FIND v(dout0_33) AT=900.05n

* CHECK dout0_34 Vdout0_34ck89 = 1.8 time = 900
.meas tran vdout0_34ck89 FIND v(dout0_34) AT=900.05n

* CHECK dout0_35 Vdout0_35ck89 = 0 time = 900
.meas tran vdout0_35ck89 FIND v(dout0_35) AT=900.05n

* CHECK dout0_36 Vdout0_36ck89 = 1.8 time = 900
.meas tran vdout0_36ck89 FIND v(dout0_36) AT=900.05n

* CHECK dout0_37 Vdout0_37ck89 = 0 time = 900
.meas tran vdout0_37ck89 FIND v(dout0_37) AT=900.05n

* CHECK dout0_38 Vdout0_38ck89 = 0 time = 900
.meas tran vdout0_38ck89 FIND v(dout0_38) AT=900.05n

* CHECK dout0_39 Vdout0_39ck89 = 1.8 time = 900
.meas tran vdout0_39ck89 FIND v(dout0_39) AT=900.05n

* CHECK dout0_40 Vdout0_40ck89 = 1.8 time = 900
.meas tran vdout0_40ck89 FIND v(dout0_40) AT=900.05n

* CHECK dout0_41 Vdout0_41ck89 = 0 time = 900
.meas tran vdout0_41ck89 FIND v(dout0_41) AT=900.05n

* CHECK dout0_42 Vdout0_42ck89 = 1.8 time = 900
.meas tran vdout0_42ck89 FIND v(dout0_42) AT=900.05n

* CHECK dout0_43 Vdout0_43ck89 = 1.8 time = 900
.meas tran vdout0_43ck89 FIND v(dout0_43) AT=900.05n

* CHECK dout0_44 Vdout0_44ck89 = 1.8 time = 900
.meas tran vdout0_44ck89 FIND v(dout0_44) AT=900.05n

* CHECK dout0_45 Vdout0_45ck89 = 1.8 time = 900
.meas tran vdout0_45ck89 FIND v(dout0_45) AT=900.05n

* CHECK dout0_46 Vdout0_46ck89 = 1.8 time = 900
.meas tran vdout0_46ck89 FIND v(dout0_46) AT=900.05n

* CHECK dout0_47 Vdout0_47ck89 = 1.8 time = 900
.meas tran vdout0_47ck89 FIND v(dout0_47) AT=900.05n

* CHECK dout0_48 Vdout0_48ck89 = 1.8 time = 900
.meas tran vdout0_48ck89 FIND v(dout0_48) AT=900.05n

* CHECK dout0_49 Vdout0_49ck89 = 1.8 time = 900
.meas tran vdout0_49ck89 FIND v(dout0_49) AT=900.05n

* CHECK dout0_50 Vdout0_50ck89 = 1.8 time = 900
.meas tran vdout0_50ck89 FIND v(dout0_50) AT=900.05n

* CHECK dout0_51 Vdout0_51ck89 = 0 time = 900
.meas tran vdout0_51ck89 FIND v(dout0_51) AT=900.05n

* CHECK dout0_52 Vdout0_52ck89 = 1.8 time = 900
.meas tran vdout0_52ck89 FIND v(dout0_52) AT=900.05n

* CHECK dout0_53 Vdout0_53ck89 = 0 time = 900
.meas tran vdout0_53ck89 FIND v(dout0_53) AT=900.05n

* CHECK dout0_54 Vdout0_54ck89 = 1.8 time = 900
.meas tran vdout0_54ck89 FIND v(dout0_54) AT=900.05n

* CHECK dout0_55 Vdout0_55ck89 = 0 time = 900
.meas tran vdout0_55ck89 FIND v(dout0_55) AT=900.05n

* CHECK dout0_56 Vdout0_56ck89 = 0 time = 900
.meas tran vdout0_56ck89 FIND v(dout0_56) AT=900.05n

* CHECK dout0_57 Vdout0_57ck89 = 0 time = 900
.meas tran vdout0_57ck89 FIND v(dout0_57) AT=900.05n

* CHECK dout0_58 Vdout0_58ck89 = 1.8 time = 900
.meas tran vdout0_58ck89 FIND v(dout0_58) AT=900.05n

* CHECK dout0_59 Vdout0_59ck89 = 0 time = 900
.meas tran vdout0_59ck89 FIND v(dout0_59) AT=900.05n

* CHECK dout0_60 Vdout0_60ck89 = 1.8 time = 900
.meas tran vdout0_60ck89 FIND v(dout0_60) AT=900.05n

* CHECK dout0_61 Vdout0_61ck89 = 1.8 time = 900
.meas tran vdout0_61ck89 FIND v(dout0_61) AT=900.05n

* CHECK dout0_62 Vdout0_62ck89 = 0 time = 900
.meas tran vdout0_62ck89 FIND v(dout0_62) AT=900.05n

* CHECK dout0_63 Vdout0_63ck89 = 0 time = 900
.meas tran vdout0_63ck89 FIND v(dout0_63) AT=900.05n

* CHECK dout0_64 Vdout0_64ck89 = 0 time = 900
.meas tran vdout0_64ck89 FIND v(dout0_64) AT=900.05n

* CHECK dout0_0 Vdout0_0ck94 = 1.8 time = 950
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=950.05n

* CHECK dout0_1 Vdout0_1ck94 = 1.8 time = 950
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=950.05n

* CHECK dout0_2 Vdout0_2ck94 = 0 time = 950
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=950.05n

* CHECK dout0_3 Vdout0_3ck94 = 0 time = 950
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=950.05n

* CHECK dout0_4 Vdout0_4ck94 = 1.8 time = 950
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=950.05n

* CHECK dout0_5 Vdout0_5ck94 = 1.8 time = 950
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=950.05n

* CHECK dout0_6 Vdout0_6ck94 = 0 time = 950
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=950.05n

* CHECK dout0_7 Vdout0_7ck94 = 0 time = 950
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=950.05n

* CHECK dout0_8 Vdout0_8ck94 = 1.8 time = 950
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=950.05n

* CHECK dout0_9 Vdout0_9ck94 = 1.8 time = 950
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=950.05n

* CHECK dout0_10 Vdout0_10ck94 = 0 time = 950
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=950.05n

* CHECK dout0_11 Vdout0_11ck94 = 1.8 time = 950
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=950.05n

* CHECK dout0_12 Vdout0_12ck94 = 0 time = 950
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=950.05n

* CHECK dout0_13 Vdout0_13ck94 = 1.8 time = 950
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=950.05n

* CHECK dout0_14 Vdout0_14ck94 = 1.8 time = 950
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=950.05n

* CHECK dout0_15 Vdout0_15ck94 = 1.8 time = 950
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=950.05n

* CHECK dout0_16 Vdout0_16ck94 = 1.8 time = 950
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=950.05n

* CHECK dout0_17 Vdout0_17ck94 = 0 time = 950
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=950.05n

* CHECK dout0_18 Vdout0_18ck94 = 0 time = 950
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=950.05n

* CHECK dout0_19 Vdout0_19ck94 = 0 time = 950
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=950.05n

* CHECK dout0_20 Vdout0_20ck94 = 1.8 time = 950
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=950.05n

* CHECK dout0_21 Vdout0_21ck94 = 1.8 time = 950
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=950.05n

* CHECK dout0_22 Vdout0_22ck94 = 1.8 time = 950
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=950.05n

* CHECK dout0_23 Vdout0_23ck94 = 0 time = 950
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=950.05n

* CHECK dout0_24 Vdout0_24ck94 = 1.8 time = 950
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=950.05n

* CHECK dout0_25 Vdout0_25ck94 = 1.8 time = 950
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=950.05n

* CHECK dout0_26 Vdout0_26ck94 = 0 time = 950
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=950.05n

* CHECK dout0_27 Vdout0_27ck94 = 0 time = 950
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=950.05n

* CHECK dout0_28 Vdout0_28ck94 = 0 time = 950
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=950.05n

* CHECK dout0_29 Vdout0_29ck94 = 1.8 time = 950
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=950.05n

* CHECK dout0_30 Vdout0_30ck94 = 1.8 time = 950
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=950.05n

* CHECK dout0_31 Vdout0_31ck94 = 0 time = 950
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=950.05n

* CHECK dout0_32 Vdout0_32ck94 = 1.8 time = 950
.meas tran vdout0_32ck94 FIND v(dout0_32) AT=950.05n

* CHECK dout0_33 Vdout0_33ck94 = 0 time = 950
.meas tran vdout0_33ck94 FIND v(dout0_33) AT=950.05n

* CHECK dout0_34 Vdout0_34ck94 = 0 time = 950
.meas tran vdout0_34ck94 FIND v(dout0_34) AT=950.05n

* CHECK dout0_35 Vdout0_35ck94 = 1.8 time = 950
.meas tran vdout0_35ck94 FIND v(dout0_35) AT=950.05n

* CHECK dout0_36 Vdout0_36ck94 = 0 time = 950
.meas tran vdout0_36ck94 FIND v(dout0_36) AT=950.05n

* CHECK dout0_37 Vdout0_37ck94 = 0 time = 950
.meas tran vdout0_37ck94 FIND v(dout0_37) AT=950.05n

* CHECK dout0_38 Vdout0_38ck94 = 0 time = 950
.meas tran vdout0_38ck94 FIND v(dout0_38) AT=950.05n

* CHECK dout0_39 Vdout0_39ck94 = 1.8 time = 950
.meas tran vdout0_39ck94 FIND v(dout0_39) AT=950.05n

* CHECK dout0_40 Vdout0_40ck94 = 0 time = 950
.meas tran vdout0_40ck94 FIND v(dout0_40) AT=950.05n

* CHECK dout0_41 Vdout0_41ck94 = 1.8 time = 950
.meas tran vdout0_41ck94 FIND v(dout0_41) AT=950.05n

* CHECK dout0_42 Vdout0_42ck94 = 0 time = 950
.meas tran vdout0_42ck94 FIND v(dout0_42) AT=950.05n

* CHECK dout0_43 Vdout0_43ck94 = 1.8 time = 950
.meas tran vdout0_43ck94 FIND v(dout0_43) AT=950.05n

* CHECK dout0_44 Vdout0_44ck94 = 1.8 time = 950
.meas tran vdout0_44ck94 FIND v(dout0_44) AT=950.05n

* CHECK dout0_45 Vdout0_45ck94 = 1.8 time = 950
.meas tran vdout0_45ck94 FIND v(dout0_45) AT=950.05n

* CHECK dout0_46 Vdout0_46ck94 = 0 time = 950
.meas tran vdout0_46ck94 FIND v(dout0_46) AT=950.05n

* CHECK dout0_47 Vdout0_47ck94 = 0 time = 950
.meas tran vdout0_47ck94 FIND v(dout0_47) AT=950.05n

* CHECK dout0_48 Vdout0_48ck94 = 1.8 time = 950
.meas tran vdout0_48ck94 FIND v(dout0_48) AT=950.05n

* CHECK dout0_49 Vdout0_49ck94 = 0 time = 950
.meas tran vdout0_49ck94 FIND v(dout0_49) AT=950.05n

* CHECK dout0_50 Vdout0_50ck94 = 1.8 time = 950
.meas tran vdout0_50ck94 FIND v(dout0_50) AT=950.05n

* CHECK dout0_51 Vdout0_51ck94 = 1.8 time = 950
.meas tran vdout0_51ck94 FIND v(dout0_51) AT=950.05n

* CHECK dout0_52 Vdout0_52ck94 = 0 time = 950
.meas tran vdout0_52ck94 FIND v(dout0_52) AT=950.05n

* CHECK dout0_53 Vdout0_53ck94 = 1.8 time = 950
.meas tran vdout0_53ck94 FIND v(dout0_53) AT=950.05n

* CHECK dout0_54 Vdout0_54ck94 = 1.8 time = 950
.meas tran vdout0_54ck94 FIND v(dout0_54) AT=950.05n

* CHECK dout0_55 Vdout0_55ck94 = 1.8 time = 950
.meas tran vdout0_55ck94 FIND v(dout0_55) AT=950.05n

* CHECK dout0_56 Vdout0_56ck94 = 0 time = 950
.meas tran vdout0_56ck94 FIND v(dout0_56) AT=950.05n

* CHECK dout0_57 Vdout0_57ck94 = 1.8 time = 950
.meas tran vdout0_57ck94 FIND v(dout0_57) AT=950.05n

* CHECK dout0_58 Vdout0_58ck94 = 0 time = 950
.meas tran vdout0_58ck94 FIND v(dout0_58) AT=950.05n

* CHECK dout0_59 Vdout0_59ck94 = 1.8 time = 950
.meas tran vdout0_59ck94 FIND v(dout0_59) AT=950.05n

* CHECK dout0_60 Vdout0_60ck94 = 1.8 time = 950
.meas tran vdout0_60ck94 FIND v(dout0_60) AT=950.05n

* CHECK dout0_61 Vdout0_61ck94 = 0 time = 950
.meas tran vdout0_61ck94 FIND v(dout0_61) AT=950.05n

* CHECK dout0_62 Vdout0_62ck94 = 1.8 time = 950
.meas tran vdout0_62ck94 FIND v(dout0_62) AT=950.05n

* CHECK dout0_63 Vdout0_63ck94 = 1.8 time = 950
.meas tran vdout0_63ck94 FIND v(dout0_63) AT=950.05n

* CHECK dout0_64 Vdout0_64ck94 = 0 time = 950
.meas tran vdout0_64ck94 FIND v(dout0_64) AT=950.05n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 970
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=970.05n

* CHECK dout0_1 Vdout0_1ck96 = 1.8 time = 970
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=970.05n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 970
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=970.05n

* CHECK dout0_3 Vdout0_3ck96 = 1.8 time = 970
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=970.05n

* CHECK dout0_4 Vdout0_4ck96 = 1.8 time = 970
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=970.05n

* CHECK dout0_5 Vdout0_5ck96 = 1.8 time = 970
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=970.05n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 970
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=970.05n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 970
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=970.05n

* CHECK dout0_8 Vdout0_8ck96 = 1.8 time = 970
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=970.05n

* CHECK dout0_9 Vdout0_9ck96 = 1.8 time = 970
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=970.05n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 970
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=970.05n

* CHECK dout0_11 Vdout0_11ck96 = 0 time = 970
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=970.05n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 970
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=970.05n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 970
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=970.05n

* CHECK dout0_14 Vdout0_14ck96 = 0 time = 970
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=970.05n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 970
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=970.05n

* CHECK dout0_16 Vdout0_16ck96 = 1.8 time = 970
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=970.05n

* CHECK dout0_17 Vdout0_17ck96 = 0 time = 970
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=970.05n

* CHECK dout0_18 Vdout0_18ck96 = 1.8 time = 970
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=970.05n

* CHECK dout0_19 Vdout0_19ck96 = 1.8 time = 970
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=970.05n

* CHECK dout0_20 Vdout0_20ck96 = 1.8 time = 970
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=970.05n

* CHECK dout0_21 Vdout0_21ck96 = 0 time = 970
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=970.05n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 970
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=970.05n

* CHECK dout0_23 Vdout0_23ck96 = 0 time = 970
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=970.05n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 970
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=970.05n

* CHECK dout0_25 Vdout0_25ck96 = 0 time = 970
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=970.05n

* CHECK dout0_26 Vdout0_26ck96 = 1.8 time = 970
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=970.05n

* CHECK dout0_27 Vdout0_27ck96 = 1.8 time = 970
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=970.05n

* CHECK dout0_28 Vdout0_28ck96 = 0 time = 970
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=970.05n

* CHECK dout0_29 Vdout0_29ck96 = 0 time = 970
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=970.05n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 970
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=970.05n

* CHECK dout0_31 Vdout0_31ck96 = 1.8 time = 970
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=970.05n

* CHECK dout0_32 Vdout0_32ck96 = 0 time = 970
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=970.05n

* CHECK dout0_33 Vdout0_33ck96 = 1.8 time = 970
.meas tran vdout0_33ck96 FIND v(dout0_33) AT=970.05n

* CHECK dout0_34 Vdout0_34ck96 = 1.8 time = 970
.meas tran vdout0_34ck96 FIND v(dout0_34) AT=970.05n

* CHECK dout0_35 Vdout0_35ck96 = 1.8 time = 970
.meas tran vdout0_35ck96 FIND v(dout0_35) AT=970.05n

* CHECK dout0_36 Vdout0_36ck96 = 1.8 time = 970
.meas tran vdout0_36ck96 FIND v(dout0_36) AT=970.05n

* CHECK dout0_37 Vdout0_37ck96 = 0 time = 970
.meas tran vdout0_37ck96 FIND v(dout0_37) AT=970.05n

* CHECK dout0_38 Vdout0_38ck96 = 0 time = 970
.meas tran vdout0_38ck96 FIND v(dout0_38) AT=970.05n

* CHECK dout0_39 Vdout0_39ck96 = 0 time = 970
.meas tran vdout0_39ck96 FIND v(dout0_39) AT=970.05n

* CHECK dout0_40 Vdout0_40ck96 = 0 time = 970
.meas tran vdout0_40ck96 FIND v(dout0_40) AT=970.05n

* CHECK dout0_41 Vdout0_41ck96 = 0 time = 970
.meas tran vdout0_41ck96 FIND v(dout0_41) AT=970.05n

* CHECK dout0_42 Vdout0_42ck96 = 0 time = 970
.meas tran vdout0_42ck96 FIND v(dout0_42) AT=970.05n

* CHECK dout0_43 Vdout0_43ck96 = 0 time = 970
.meas tran vdout0_43ck96 FIND v(dout0_43) AT=970.05n

* CHECK dout0_44 Vdout0_44ck96 = 1.8 time = 970
.meas tran vdout0_44ck96 FIND v(dout0_44) AT=970.05n

* CHECK dout0_45 Vdout0_45ck96 = 1.8 time = 970
.meas tran vdout0_45ck96 FIND v(dout0_45) AT=970.05n

* CHECK dout0_46 Vdout0_46ck96 = 0 time = 970
.meas tran vdout0_46ck96 FIND v(dout0_46) AT=970.05n

* CHECK dout0_47 Vdout0_47ck96 = 1.8 time = 970
.meas tran vdout0_47ck96 FIND v(dout0_47) AT=970.05n

* CHECK dout0_48 Vdout0_48ck96 = 1.8 time = 970
.meas tran vdout0_48ck96 FIND v(dout0_48) AT=970.05n

* CHECK dout0_49 Vdout0_49ck96 = 1.8 time = 970
.meas tran vdout0_49ck96 FIND v(dout0_49) AT=970.05n

* CHECK dout0_50 Vdout0_50ck96 = 0 time = 970
.meas tran vdout0_50ck96 FIND v(dout0_50) AT=970.05n

* CHECK dout0_51 Vdout0_51ck96 = 0 time = 970
.meas tran vdout0_51ck96 FIND v(dout0_51) AT=970.05n

* CHECK dout0_52 Vdout0_52ck96 = 0 time = 970
.meas tran vdout0_52ck96 FIND v(dout0_52) AT=970.05n

* CHECK dout0_53 Vdout0_53ck96 = 1.8 time = 970
.meas tran vdout0_53ck96 FIND v(dout0_53) AT=970.05n

* CHECK dout0_54 Vdout0_54ck96 = 0 time = 970
.meas tran vdout0_54ck96 FIND v(dout0_54) AT=970.05n

* CHECK dout0_55 Vdout0_55ck96 = 0 time = 970
.meas tran vdout0_55ck96 FIND v(dout0_55) AT=970.05n

* CHECK dout0_56 Vdout0_56ck96 = 0 time = 970
.meas tran vdout0_56ck96 FIND v(dout0_56) AT=970.05n

* CHECK dout0_57 Vdout0_57ck96 = 1.8 time = 970
.meas tran vdout0_57ck96 FIND v(dout0_57) AT=970.05n

* CHECK dout0_58 Vdout0_58ck96 = 0 time = 970
.meas tran vdout0_58ck96 FIND v(dout0_58) AT=970.05n

* CHECK dout0_59 Vdout0_59ck96 = 1.8 time = 970
.meas tran vdout0_59ck96 FIND v(dout0_59) AT=970.05n

* CHECK dout0_60 Vdout0_60ck96 = 0 time = 970
.meas tran vdout0_60ck96 FIND v(dout0_60) AT=970.05n

* CHECK dout0_61 Vdout0_61ck96 = 0 time = 970
.meas tran vdout0_61ck96 FIND v(dout0_61) AT=970.05n

* CHECK dout0_62 Vdout0_62ck96 = 0 time = 970
.meas tran vdout0_62ck96 FIND v(dout0_62) AT=970.05n

* CHECK dout0_63 Vdout0_63ck96 = 1.8 time = 970
.meas tran vdout0_63ck96 FIND v(dout0_63) AT=970.05n

* CHECK dout0_64 Vdout0_64ck96 = 0 time = 970
.meas tran vdout0_64ck96 FIND v(dout0_64) AT=970.05n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 1030
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=1030.05n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 1030
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=1030.05n

* CHECK dout0_2 Vdout0_2ck102 = 1.8 time = 1030
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=1030.05n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 1030
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=1030.05n

* CHECK dout0_4 Vdout0_4ck102 = 1.8 time = 1030
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=1030.05n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 1030
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=1030.05n

* CHECK dout0_6 Vdout0_6ck102 = 1.8 time = 1030
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=1030.05n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 1030
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=1030.05n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 1030
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=1030.05n

* CHECK dout0_9 Vdout0_9ck102 = 1.8 time = 1030
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=1030.05n

* CHECK dout0_10 Vdout0_10ck102 = 1.8 time = 1030
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=1030.05n

* CHECK dout0_11 Vdout0_11ck102 = 1.8 time = 1030
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=1030.05n

* CHECK dout0_12 Vdout0_12ck102 = 1.8 time = 1030
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=1030.05n

* CHECK dout0_13 Vdout0_13ck102 = 1.8 time = 1030
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=1030.05n

* CHECK dout0_14 Vdout0_14ck102 = 1.8 time = 1030
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=1030.05n

* CHECK dout0_15 Vdout0_15ck102 = 1.8 time = 1030
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=1030.05n

* CHECK dout0_16 Vdout0_16ck102 = 0 time = 1030
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=1030.05n

* CHECK dout0_17 Vdout0_17ck102 = 1.8 time = 1030
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=1030.05n

* CHECK dout0_18 Vdout0_18ck102 = 1.8 time = 1030
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=1030.05n

* CHECK dout0_19 Vdout0_19ck102 = 1.8 time = 1030
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=1030.05n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 1030
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=1030.05n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 1030
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=1030.05n

* CHECK dout0_22 Vdout0_22ck102 = 1.8 time = 1030
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=1030.05n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 1030
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=1030.05n

* CHECK dout0_24 Vdout0_24ck102 = 1.8 time = 1030
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=1030.05n

* CHECK dout0_25 Vdout0_25ck102 = 1.8 time = 1030
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=1030.05n

* CHECK dout0_26 Vdout0_26ck102 = 1.8 time = 1030
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=1030.05n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 1030
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=1030.05n

* CHECK dout0_28 Vdout0_28ck102 = 1.8 time = 1030
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=1030.05n

* CHECK dout0_29 Vdout0_29ck102 = 0 time = 1030
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=1030.05n

* CHECK dout0_30 Vdout0_30ck102 = 1.8 time = 1030
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=1030.05n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 1030
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=1030.05n

* CHECK dout0_32 Vdout0_32ck102 = 1.8 time = 1030
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=1030.05n

* CHECK dout0_33 Vdout0_33ck102 = 1.8 time = 1030
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=1030.05n

* CHECK dout0_34 Vdout0_34ck102 = 0 time = 1030
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=1030.05n

* CHECK dout0_35 Vdout0_35ck102 = 1.8 time = 1030
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=1030.05n

* CHECK dout0_36 Vdout0_36ck102 = 1.8 time = 1030
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=1030.05n

* CHECK dout0_37 Vdout0_37ck102 = 0 time = 1030
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=1030.05n

* CHECK dout0_38 Vdout0_38ck102 = 1.8 time = 1030
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=1030.05n

* CHECK dout0_39 Vdout0_39ck102 = 1.8 time = 1030
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=1030.05n

* CHECK dout0_40 Vdout0_40ck102 = 1.8 time = 1030
.meas tran vdout0_40ck102 FIND v(dout0_40) AT=1030.05n

* CHECK dout0_41 Vdout0_41ck102 = 1.8 time = 1030
.meas tran vdout0_41ck102 FIND v(dout0_41) AT=1030.05n

* CHECK dout0_42 Vdout0_42ck102 = 1.8 time = 1030
.meas tran vdout0_42ck102 FIND v(dout0_42) AT=1030.05n

* CHECK dout0_43 Vdout0_43ck102 = 1.8 time = 1030
.meas tran vdout0_43ck102 FIND v(dout0_43) AT=1030.05n

* CHECK dout0_44 Vdout0_44ck102 = 1.8 time = 1030
.meas tran vdout0_44ck102 FIND v(dout0_44) AT=1030.05n

* CHECK dout0_45 Vdout0_45ck102 = 1.8 time = 1030
.meas tran vdout0_45ck102 FIND v(dout0_45) AT=1030.05n

* CHECK dout0_46 Vdout0_46ck102 = 1.8 time = 1030
.meas tran vdout0_46ck102 FIND v(dout0_46) AT=1030.05n

* CHECK dout0_47 Vdout0_47ck102 = 0 time = 1030
.meas tran vdout0_47ck102 FIND v(dout0_47) AT=1030.05n

* CHECK dout0_48 Vdout0_48ck102 = 0 time = 1030
.meas tran vdout0_48ck102 FIND v(dout0_48) AT=1030.05n

* CHECK dout0_49 Vdout0_49ck102 = 1.8 time = 1030
.meas tran vdout0_49ck102 FIND v(dout0_49) AT=1030.05n

* CHECK dout0_50 Vdout0_50ck102 = 1.8 time = 1030
.meas tran vdout0_50ck102 FIND v(dout0_50) AT=1030.05n

* CHECK dout0_51 Vdout0_51ck102 = 1.8 time = 1030
.meas tran vdout0_51ck102 FIND v(dout0_51) AT=1030.05n

* CHECK dout0_52 Vdout0_52ck102 = 0 time = 1030
.meas tran vdout0_52ck102 FIND v(dout0_52) AT=1030.05n

* CHECK dout0_53 Vdout0_53ck102 = 0 time = 1030
.meas tran vdout0_53ck102 FIND v(dout0_53) AT=1030.05n

* CHECK dout0_54 Vdout0_54ck102 = 1.8 time = 1030
.meas tran vdout0_54ck102 FIND v(dout0_54) AT=1030.05n

* CHECK dout0_55 Vdout0_55ck102 = 1.8 time = 1030
.meas tran vdout0_55ck102 FIND v(dout0_55) AT=1030.05n

* CHECK dout0_56 Vdout0_56ck102 = 1.8 time = 1030
.meas tran vdout0_56ck102 FIND v(dout0_56) AT=1030.05n

* CHECK dout0_57 Vdout0_57ck102 = 0 time = 1030
.meas tran vdout0_57ck102 FIND v(dout0_57) AT=1030.05n

* CHECK dout0_58 Vdout0_58ck102 = 0 time = 1030
.meas tran vdout0_58ck102 FIND v(dout0_58) AT=1030.05n

* CHECK dout0_59 Vdout0_59ck102 = 1.8 time = 1030
.meas tran vdout0_59ck102 FIND v(dout0_59) AT=1030.05n

* CHECK dout0_60 Vdout0_60ck102 = 1.8 time = 1030
.meas tran vdout0_60ck102 FIND v(dout0_60) AT=1030.05n

* CHECK dout0_61 Vdout0_61ck102 = 0 time = 1030
.meas tran vdout0_61ck102 FIND v(dout0_61) AT=1030.05n

* CHECK dout0_62 Vdout0_62ck102 = 0 time = 1030
.meas tran vdout0_62ck102 FIND v(dout0_62) AT=1030.05n

* CHECK dout0_63 Vdout0_63ck102 = 1.8 time = 1030
.meas tran vdout0_63ck102 FIND v(dout0_63) AT=1030.05n

* CHECK dout0_64 Vdout0_64ck102 = 0 time = 1030
.meas tran vdout0_64ck102 FIND v(dout0_64) AT=1030.05n

* CHECK dout0_0 Vdout0_0ck103 = 1.8 time = 1040
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=1040.05n

* CHECK dout0_1 Vdout0_1ck103 = 1.8 time = 1040
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=1040.05n

* CHECK dout0_2 Vdout0_2ck103 = 0 time = 1040
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=1040.05n

* CHECK dout0_3 Vdout0_3ck103 = 1.8 time = 1040
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=1040.05n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 1040
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=1040.05n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 1040
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=1040.05n

* CHECK dout0_6 Vdout0_6ck103 = 1.8 time = 1040
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=1040.05n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 1040
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=1040.05n

* CHECK dout0_8 Vdout0_8ck103 = 0 time = 1040
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=1040.05n

* CHECK dout0_9 Vdout0_9ck103 = 1.8 time = 1040
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=1040.05n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 1040
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=1040.05n

* CHECK dout0_11 Vdout0_11ck103 = 1.8 time = 1040
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=1040.05n

* CHECK dout0_12 Vdout0_12ck103 = 1.8 time = 1040
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=1040.05n

* CHECK dout0_13 Vdout0_13ck103 = 1.8 time = 1040
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=1040.05n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 1040
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=1040.05n

* CHECK dout0_15 Vdout0_15ck103 = 1.8 time = 1040
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=1040.05n

* CHECK dout0_16 Vdout0_16ck103 = 0 time = 1040
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=1040.05n

* CHECK dout0_17 Vdout0_17ck103 = 0 time = 1040
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=1040.05n

* CHECK dout0_18 Vdout0_18ck103 = 0 time = 1040
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=1040.05n

* CHECK dout0_19 Vdout0_19ck103 = 1.8 time = 1040
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=1040.05n

* CHECK dout0_20 Vdout0_20ck103 = 0 time = 1040
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=1040.05n

* CHECK dout0_21 Vdout0_21ck103 = 0 time = 1040
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=1040.05n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 1040
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=1040.05n

* CHECK dout0_23 Vdout0_23ck103 = 1.8 time = 1040
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=1040.05n

* CHECK dout0_24 Vdout0_24ck103 = 0 time = 1040
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=1040.05n

* CHECK dout0_25 Vdout0_25ck103 = 0 time = 1040
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=1040.05n

* CHECK dout0_26 Vdout0_26ck103 = 1.8 time = 1040
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=1040.05n

* CHECK dout0_27 Vdout0_27ck103 = 1.8 time = 1040
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=1040.05n

* CHECK dout0_28 Vdout0_28ck103 = 1.8 time = 1040
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=1040.05n

* CHECK dout0_29 Vdout0_29ck103 = 0 time = 1040
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=1040.05n

* CHECK dout0_30 Vdout0_30ck103 = 1.8 time = 1040
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=1040.05n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 1040
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=1040.05n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 1040
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=1040.05n

* CHECK dout0_33 Vdout0_33ck103 = 0 time = 1040
.meas tran vdout0_33ck103 FIND v(dout0_33) AT=1040.05n

* CHECK dout0_34 Vdout0_34ck103 = 1.8 time = 1040
.meas tran vdout0_34ck103 FIND v(dout0_34) AT=1040.05n

* CHECK dout0_35 Vdout0_35ck103 = 1.8 time = 1040
.meas tran vdout0_35ck103 FIND v(dout0_35) AT=1040.05n

* CHECK dout0_36 Vdout0_36ck103 = 1.8 time = 1040
.meas tran vdout0_36ck103 FIND v(dout0_36) AT=1040.05n

* CHECK dout0_37 Vdout0_37ck103 = 1.8 time = 1040
.meas tran vdout0_37ck103 FIND v(dout0_37) AT=1040.05n

* CHECK dout0_38 Vdout0_38ck103 = 1.8 time = 1040
.meas tran vdout0_38ck103 FIND v(dout0_38) AT=1040.05n

* CHECK dout0_39 Vdout0_39ck103 = 1.8 time = 1040
.meas tran vdout0_39ck103 FIND v(dout0_39) AT=1040.05n

* CHECK dout0_40 Vdout0_40ck103 = 0 time = 1040
.meas tran vdout0_40ck103 FIND v(dout0_40) AT=1040.05n

* CHECK dout0_41 Vdout0_41ck103 = 1.8 time = 1040
.meas tran vdout0_41ck103 FIND v(dout0_41) AT=1040.05n

* CHECK dout0_42 Vdout0_42ck103 = 0 time = 1040
.meas tran vdout0_42ck103 FIND v(dout0_42) AT=1040.05n

* CHECK dout0_43 Vdout0_43ck103 = 0 time = 1040
.meas tran vdout0_43ck103 FIND v(dout0_43) AT=1040.05n

* CHECK dout0_44 Vdout0_44ck103 = 0 time = 1040
.meas tran vdout0_44ck103 FIND v(dout0_44) AT=1040.05n

* CHECK dout0_45 Vdout0_45ck103 = 1.8 time = 1040
.meas tran vdout0_45ck103 FIND v(dout0_45) AT=1040.05n

* CHECK dout0_46 Vdout0_46ck103 = 0 time = 1040
.meas tran vdout0_46ck103 FIND v(dout0_46) AT=1040.05n

* CHECK dout0_47 Vdout0_47ck103 = 0 time = 1040
.meas tran vdout0_47ck103 FIND v(dout0_47) AT=1040.05n

* CHECK dout0_48 Vdout0_48ck103 = 0 time = 1040
.meas tran vdout0_48ck103 FIND v(dout0_48) AT=1040.05n

* CHECK dout0_49 Vdout0_49ck103 = 1.8 time = 1040
.meas tran vdout0_49ck103 FIND v(dout0_49) AT=1040.05n

* CHECK dout0_50 Vdout0_50ck103 = 0 time = 1040
.meas tran vdout0_50ck103 FIND v(dout0_50) AT=1040.05n

* CHECK dout0_51 Vdout0_51ck103 = 0 time = 1040
.meas tran vdout0_51ck103 FIND v(dout0_51) AT=1040.05n

* CHECK dout0_52 Vdout0_52ck103 = 1.8 time = 1040
.meas tran vdout0_52ck103 FIND v(dout0_52) AT=1040.05n

* CHECK dout0_53 Vdout0_53ck103 = 0 time = 1040
.meas tran vdout0_53ck103 FIND v(dout0_53) AT=1040.05n

* CHECK dout0_54 Vdout0_54ck103 = 1.8 time = 1040
.meas tran vdout0_54ck103 FIND v(dout0_54) AT=1040.05n

* CHECK dout0_55 Vdout0_55ck103 = 1.8 time = 1040
.meas tran vdout0_55ck103 FIND v(dout0_55) AT=1040.05n

* CHECK dout0_56 Vdout0_56ck103 = 1.8 time = 1040
.meas tran vdout0_56ck103 FIND v(dout0_56) AT=1040.05n

* CHECK dout0_57 Vdout0_57ck103 = 1.8 time = 1040
.meas tran vdout0_57ck103 FIND v(dout0_57) AT=1040.05n

* CHECK dout0_58 Vdout0_58ck103 = 0 time = 1040
.meas tran vdout0_58ck103 FIND v(dout0_58) AT=1040.05n

* CHECK dout0_59 Vdout0_59ck103 = 0 time = 1040
.meas tran vdout0_59ck103 FIND v(dout0_59) AT=1040.05n

* CHECK dout0_60 Vdout0_60ck103 = 1.8 time = 1040
.meas tran vdout0_60ck103 FIND v(dout0_60) AT=1040.05n

* CHECK dout0_61 Vdout0_61ck103 = 0 time = 1040
.meas tran vdout0_61ck103 FIND v(dout0_61) AT=1040.05n

* CHECK dout0_62 Vdout0_62ck103 = 1.8 time = 1040
.meas tran vdout0_62ck103 FIND v(dout0_62) AT=1040.05n

* CHECK dout0_63 Vdout0_63ck103 = 1.8 time = 1040
.meas tran vdout0_63ck103 FIND v(dout0_63) AT=1040.05n

* CHECK dout0_64 Vdout0_64ck103 = 0 time = 1040
.meas tran vdout0_64ck103 FIND v(dout0_64) AT=1040.05n

* CHECK dout0_0 Vdout0_0ck104 = 1.8 time = 1050
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=1050.05n

* CHECK dout0_1 Vdout0_1ck104 = 0 time = 1050
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=1050.05n

* CHECK dout0_2 Vdout0_2ck104 = 1.8 time = 1050
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=1050.05n

* CHECK dout0_3 Vdout0_3ck104 = 0 time = 1050
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=1050.05n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 1050
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=1050.05n

* CHECK dout0_5 Vdout0_5ck104 = 0 time = 1050
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=1050.05n

* CHECK dout0_6 Vdout0_6ck104 = 0 time = 1050
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=1050.05n

* CHECK dout0_7 Vdout0_7ck104 = 1.8 time = 1050
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=1050.05n

* CHECK dout0_8 Vdout0_8ck104 = 1.8 time = 1050
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=1050.05n

* CHECK dout0_9 Vdout0_9ck104 = 0 time = 1050
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=1050.05n

* CHECK dout0_10 Vdout0_10ck104 = 0 time = 1050
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=1050.05n

* CHECK dout0_11 Vdout0_11ck104 = 0 time = 1050
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=1050.05n

* CHECK dout0_12 Vdout0_12ck104 = 1.8 time = 1050
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=1050.05n

* CHECK dout0_13 Vdout0_13ck104 = 1.8 time = 1050
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=1050.05n

* CHECK dout0_14 Vdout0_14ck104 = 1.8 time = 1050
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=1050.05n

* CHECK dout0_15 Vdout0_15ck104 = 0 time = 1050
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=1050.05n

* CHECK dout0_16 Vdout0_16ck104 = 1.8 time = 1050
.meas tran vdout0_16ck104 FIND v(dout0_16) AT=1050.05n

* CHECK dout0_17 Vdout0_17ck104 = 0 time = 1050
.meas tran vdout0_17ck104 FIND v(dout0_17) AT=1050.05n

* CHECK dout0_18 Vdout0_18ck104 = 0 time = 1050
.meas tran vdout0_18ck104 FIND v(dout0_18) AT=1050.05n

* CHECK dout0_19 Vdout0_19ck104 = 0 time = 1050
.meas tran vdout0_19ck104 FIND v(dout0_19) AT=1050.05n

* CHECK dout0_20 Vdout0_20ck104 = 1.8 time = 1050
.meas tran vdout0_20ck104 FIND v(dout0_20) AT=1050.05n

* CHECK dout0_21 Vdout0_21ck104 = 0 time = 1050
.meas tran vdout0_21ck104 FIND v(dout0_21) AT=1050.05n

* CHECK dout0_22 Vdout0_22ck104 = 1.8 time = 1050
.meas tran vdout0_22ck104 FIND v(dout0_22) AT=1050.05n

* CHECK dout0_23 Vdout0_23ck104 = 1.8 time = 1050
.meas tran vdout0_23ck104 FIND v(dout0_23) AT=1050.05n

* CHECK dout0_24 Vdout0_24ck104 = 0 time = 1050
.meas tran vdout0_24ck104 FIND v(dout0_24) AT=1050.05n

* CHECK dout0_25 Vdout0_25ck104 = 1.8 time = 1050
.meas tran vdout0_25ck104 FIND v(dout0_25) AT=1050.05n

* CHECK dout0_26 Vdout0_26ck104 = 1.8 time = 1050
.meas tran vdout0_26ck104 FIND v(dout0_26) AT=1050.05n

* CHECK dout0_27 Vdout0_27ck104 = 0 time = 1050
.meas tran vdout0_27ck104 FIND v(dout0_27) AT=1050.05n

* CHECK dout0_28 Vdout0_28ck104 = 0 time = 1050
.meas tran vdout0_28ck104 FIND v(dout0_28) AT=1050.05n

* CHECK dout0_29 Vdout0_29ck104 = 1.8 time = 1050
.meas tran vdout0_29ck104 FIND v(dout0_29) AT=1050.05n

* CHECK dout0_30 Vdout0_30ck104 = 0 time = 1050
.meas tran vdout0_30ck104 FIND v(dout0_30) AT=1050.05n

* CHECK dout0_31 Vdout0_31ck104 = 1.8 time = 1050
.meas tran vdout0_31ck104 FIND v(dout0_31) AT=1050.05n

* CHECK dout0_32 Vdout0_32ck104 = 0 time = 1050
.meas tran vdout0_32ck104 FIND v(dout0_32) AT=1050.05n

* CHECK dout0_33 Vdout0_33ck104 = 0 time = 1050
.meas tran vdout0_33ck104 FIND v(dout0_33) AT=1050.05n

* CHECK dout0_34 Vdout0_34ck104 = 0 time = 1050
.meas tran vdout0_34ck104 FIND v(dout0_34) AT=1050.05n

* CHECK dout0_35 Vdout0_35ck104 = 1.8 time = 1050
.meas tran vdout0_35ck104 FIND v(dout0_35) AT=1050.05n

* CHECK dout0_36 Vdout0_36ck104 = 0 time = 1050
.meas tran vdout0_36ck104 FIND v(dout0_36) AT=1050.05n

* CHECK dout0_37 Vdout0_37ck104 = 0 time = 1050
.meas tran vdout0_37ck104 FIND v(dout0_37) AT=1050.05n

* CHECK dout0_38 Vdout0_38ck104 = 0 time = 1050
.meas tran vdout0_38ck104 FIND v(dout0_38) AT=1050.05n

* CHECK dout0_39 Vdout0_39ck104 = 0 time = 1050
.meas tran vdout0_39ck104 FIND v(dout0_39) AT=1050.05n

* CHECK dout0_40 Vdout0_40ck104 = 0 time = 1050
.meas tran vdout0_40ck104 FIND v(dout0_40) AT=1050.05n

* CHECK dout0_41 Vdout0_41ck104 = 1.8 time = 1050
.meas tran vdout0_41ck104 FIND v(dout0_41) AT=1050.05n

* CHECK dout0_42 Vdout0_42ck104 = 1.8 time = 1050
.meas tran vdout0_42ck104 FIND v(dout0_42) AT=1050.05n

* CHECK dout0_43 Vdout0_43ck104 = 0 time = 1050
.meas tran vdout0_43ck104 FIND v(dout0_43) AT=1050.05n

* CHECK dout0_44 Vdout0_44ck104 = 0 time = 1050
.meas tran vdout0_44ck104 FIND v(dout0_44) AT=1050.05n

* CHECK dout0_45 Vdout0_45ck104 = 1.8 time = 1050
.meas tran vdout0_45ck104 FIND v(dout0_45) AT=1050.05n

* CHECK dout0_46 Vdout0_46ck104 = 1.8 time = 1050
.meas tran vdout0_46ck104 FIND v(dout0_46) AT=1050.05n

* CHECK dout0_47 Vdout0_47ck104 = 0 time = 1050
.meas tran vdout0_47ck104 FIND v(dout0_47) AT=1050.05n

* CHECK dout0_48 Vdout0_48ck104 = 1.8 time = 1050
.meas tran vdout0_48ck104 FIND v(dout0_48) AT=1050.05n

* CHECK dout0_49 Vdout0_49ck104 = 1.8 time = 1050
.meas tran vdout0_49ck104 FIND v(dout0_49) AT=1050.05n

* CHECK dout0_50 Vdout0_50ck104 = 0 time = 1050
.meas tran vdout0_50ck104 FIND v(dout0_50) AT=1050.05n

* CHECK dout0_51 Vdout0_51ck104 = 0 time = 1050
.meas tran vdout0_51ck104 FIND v(dout0_51) AT=1050.05n

* CHECK dout0_52 Vdout0_52ck104 = 0 time = 1050
.meas tran vdout0_52ck104 FIND v(dout0_52) AT=1050.05n

* CHECK dout0_53 Vdout0_53ck104 = 1.8 time = 1050
.meas tran vdout0_53ck104 FIND v(dout0_53) AT=1050.05n

* CHECK dout0_54 Vdout0_54ck104 = 0 time = 1050
.meas tran vdout0_54ck104 FIND v(dout0_54) AT=1050.05n

* CHECK dout0_55 Vdout0_55ck104 = 0 time = 1050
.meas tran vdout0_55ck104 FIND v(dout0_55) AT=1050.05n

* CHECK dout0_56 Vdout0_56ck104 = 1.8 time = 1050
.meas tran vdout0_56ck104 FIND v(dout0_56) AT=1050.05n

* CHECK dout0_57 Vdout0_57ck104 = 0 time = 1050
.meas tran vdout0_57ck104 FIND v(dout0_57) AT=1050.05n

* CHECK dout0_58 Vdout0_58ck104 = 0 time = 1050
.meas tran vdout0_58ck104 FIND v(dout0_58) AT=1050.05n

* CHECK dout0_59 Vdout0_59ck104 = 0 time = 1050
.meas tran vdout0_59ck104 FIND v(dout0_59) AT=1050.05n

* CHECK dout0_60 Vdout0_60ck104 = 0 time = 1050
.meas tran vdout0_60ck104 FIND v(dout0_60) AT=1050.05n

* CHECK dout0_61 Vdout0_61ck104 = 1.8 time = 1050
.meas tran vdout0_61ck104 FIND v(dout0_61) AT=1050.05n

* CHECK dout0_62 Vdout0_62ck104 = 1.8 time = 1050
.meas tran vdout0_62ck104 FIND v(dout0_62) AT=1050.05n

* CHECK dout0_63 Vdout0_63ck104 = 1.8 time = 1050
.meas tran vdout0_63ck104 FIND v(dout0_63) AT=1050.05n

* CHECK dout0_64 Vdout0_64ck104 = 0 time = 1050
.meas tran vdout0_64ck104 FIND v(dout0_64) AT=1050.05n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 1060
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=1060.05n

* CHECK dout0_1 Vdout0_1ck105 = 1.8 time = 1060
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=1060.05n

* CHECK dout0_2 Vdout0_2ck105 = 1.8 time = 1060
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=1060.05n

* CHECK dout0_3 Vdout0_3ck105 = 1.8 time = 1060
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=1060.05n

* CHECK dout0_4 Vdout0_4ck105 = 1.8 time = 1060
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=1060.05n

* CHECK dout0_5 Vdout0_5ck105 = 1.8 time = 1060
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=1060.05n

* CHECK dout0_6 Vdout0_6ck105 = 1.8 time = 1060
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=1060.05n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 1060
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=1060.05n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 1060
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=1060.05n

* CHECK dout0_9 Vdout0_9ck105 = 0 time = 1060
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=1060.05n

* CHECK dout0_10 Vdout0_10ck105 = 1.8 time = 1060
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=1060.05n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 1060
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=1060.05n

* CHECK dout0_12 Vdout0_12ck105 = 1.8 time = 1060
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=1060.05n

* CHECK dout0_13 Vdout0_13ck105 = 0 time = 1060
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=1060.05n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 1060
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=1060.05n

* CHECK dout0_15 Vdout0_15ck105 = 1.8 time = 1060
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=1060.05n

* CHECK dout0_16 Vdout0_16ck105 = 0 time = 1060
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=1060.05n

* CHECK dout0_17 Vdout0_17ck105 = 1.8 time = 1060
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=1060.05n

* CHECK dout0_18 Vdout0_18ck105 = 0 time = 1060
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=1060.05n

* CHECK dout0_19 Vdout0_19ck105 = 0 time = 1060
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=1060.05n

* CHECK dout0_20 Vdout0_20ck105 = 0 time = 1060
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=1060.05n

* CHECK dout0_21 Vdout0_21ck105 = 1.8 time = 1060
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=1060.05n

* CHECK dout0_22 Vdout0_22ck105 = 1.8 time = 1060
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=1060.05n

* CHECK dout0_23 Vdout0_23ck105 = 1.8 time = 1060
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=1060.05n

* CHECK dout0_24 Vdout0_24ck105 = 1.8 time = 1060
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=1060.05n

* CHECK dout0_25 Vdout0_25ck105 = 1.8 time = 1060
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=1060.05n

* CHECK dout0_26 Vdout0_26ck105 = 0 time = 1060
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=1060.05n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 1060
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=1060.05n

* CHECK dout0_28 Vdout0_28ck105 = 0 time = 1060
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=1060.05n

* CHECK dout0_29 Vdout0_29ck105 = 0 time = 1060
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=1060.05n

* CHECK dout0_30 Vdout0_30ck105 = 1.8 time = 1060
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=1060.05n

* CHECK dout0_31 Vdout0_31ck105 = 0 time = 1060
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=1060.05n

* CHECK dout0_32 Vdout0_32ck105 = 1.8 time = 1060
.meas tran vdout0_32ck105 FIND v(dout0_32) AT=1060.05n

* CHECK dout0_33 Vdout0_33ck105 = 0 time = 1060
.meas tran vdout0_33ck105 FIND v(dout0_33) AT=1060.05n

* CHECK dout0_34 Vdout0_34ck105 = 1.8 time = 1060
.meas tran vdout0_34ck105 FIND v(dout0_34) AT=1060.05n

* CHECK dout0_35 Vdout0_35ck105 = 0 time = 1060
.meas tran vdout0_35ck105 FIND v(dout0_35) AT=1060.05n

* CHECK dout0_36 Vdout0_36ck105 = 1.8 time = 1060
.meas tran vdout0_36ck105 FIND v(dout0_36) AT=1060.05n

* CHECK dout0_37 Vdout0_37ck105 = 0 time = 1060
.meas tran vdout0_37ck105 FIND v(dout0_37) AT=1060.05n

* CHECK dout0_38 Vdout0_38ck105 = 0 time = 1060
.meas tran vdout0_38ck105 FIND v(dout0_38) AT=1060.05n

* CHECK dout0_39 Vdout0_39ck105 = 1.8 time = 1060
.meas tran vdout0_39ck105 FIND v(dout0_39) AT=1060.05n

* CHECK dout0_40 Vdout0_40ck105 = 1.8 time = 1060
.meas tran vdout0_40ck105 FIND v(dout0_40) AT=1060.05n

* CHECK dout0_41 Vdout0_41ck105 = 0 time = 1060
.meas tran vdout0_41ck105 FIND v(dout0_41) AT=1060.05n

* CHECK dout0_42 Vdout0_42ck105 = 1.8 time = 1060
.meas tran vdout0_42ck105 FIND v(dout0_42) AT=1060.05n

* CHECK dout0_43 Vdout0_43ck105 = 1.8 time = 1060
.meas tran vdout0_43ck105 FIND v(dout0_43) AT=1060.05n

* CHECK dout0_44 Vdout0_44ck105 = 1.8 time = 1060
.meas tran vdout0_44ck105 FIND v(dout0_44) AT=1060.05n

* CHECK dout0_45 Vdout0_45ck105 = 0 time = 1060
.meas tran vdout0_45ck105 FIND v(dout0_45) AT=1060.05n

* CHECK dout0_46 Vdout0_46ck105 = 1.8 time = 1060
.meas tran vdout0_46ck105 FIND v(dout0_46) AT=1060.05n

* CHECK dout0_47 Vdout0_47ck105 = 1.8 time = 1060
.meas tran vdout0_47ck105 FIND v(dout0_47) AT=1060.05n

* CHECK dout0_48 Vdout0_48ck105 = 0 time = 1060
.meas tran vdout0_48ck105 FIND v(dout0_48) AT=1060.05n

* CHECK dout0_49 Vdout0_49ck105 = 0 time = 1060
.meas tran vdout0_49ck105 FIND v(dout0_49) AT=1060.05n

* CHECK dout0_50 Vdout0_50ck105 = 1.8 time = 1060
.meas tran vdout0_50ck105 FIND v(dout0_50) AT=1060.05n

* CHECK dout0_51 Vdout0_51ck105 = 1.8 time = 1060
.meas tran vdout0_51ck105 FIND v(dout0_51) AT=1060.05n

* CHECK dout0_52 Vdout0_52ck105 = 0 time = 1060
.meas tran vdout0_52ck105 FIND v(dout0_52) AT=1060.05n

* CHECK dout0_53 Vdout0_53ck105 = 1.8 time = 1060
.meas tran vdout0_53ck105 FIND v(dout0_53) AT=1060.05n

* CHECK dout0_54 Vdout0_54ck105 = 1.8 time = 1060
.meas tran vdout0_54ck105 FIND v(dout0_54) AT=1060.05n

* CHECK dout0_55 Vdout0_55ck105 = 0 time = 1060
.meas tran vdout0_55ck105 FIND v(dout0_55) AT=1060.05n

* CHECK dout0_56 Vdout0_56ck105 = 0 time = 1060
.meas tran vdout0_56ck105 FIND v(dout0_56) AT=1060.05n

* CHECK dout0_57 Vdout0_57ck105 = 0 time = 1060
.meas tran vdout0_57ck105 FIND v(dout0_57) AT=1060.05n

* CHECK dout0_58 Vdout0_58ck105 = 1.8 time = 1060
.meas tran vdout0_58ck105 FIND v(dout0_58) AT=1060.05n

* CHECK dout0_59 Vdout0_59ck105 = 0 time = 1060
.meas tran vdout0_59ck105 FIND v(dout0_59) AT=1060.05n

* CHECK dout0_60 Vdout0_60ck105 = 1.8 time = 1060
.meas tran vdout0_60ck105 FIND v(dout0_60) AT=1060.05n

* CHECK dout0_61 Vdout0_61ck105 = 1.8 time = 1060
.meas tran vdout0_61ck105 FIND v(dout0_61) AT=1060.05n

* CHECK dout0_62 Vdout0_62ck105 = 0 time = 1060
.meas tran vdout0_62ck105 FIND v(dout0_62) AT=1060.05n

* CHECK dout0_63 Vdout0_63ck105 = 0 time = 1060
.meas tran vdout0_63ck105 FIND v(dout0_63) AT=1060.05n

* CHECK dout0_64 Vdout0_64ck105 = 0 time = 1060
.meas tran vdout0_64ck105 FIND v(dout0_64) AT=1060.05n

* CHECK dout0_0 Vdout0_0ck106 = 1.8 time = 1070
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=1070.05n

* CHECK dout0_1 Vdout0_1ck106 = 1.8 time = 1070
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=1070.05n

* CHECK dout0_2 Vdout0_2ck106 = 0 time = 1070
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=1070.05n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 1070
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=1070.05n

* CHECK dout0_4 Vdout0_4ck106 = 1.8 time = 1070
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=1070.05n

* CHECK dout0_5 Vdout0_5ck106 = 1.8 time = 1070
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=1070.05n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 1070
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=1070.05n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 1070
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=1070.05n

* CHECK dout0_8 Vdout0_8ck106 = 1.8 time = 1070
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=1070.05n

* CHECK dout0_9 Vdout0_9ck106 = 1.8 time = 1070
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=1070.05n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 1070
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=1070.05n

* CHECK dout0_11 Vdout0_11ck106 = 1.8 time = 1070
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=1070.05n

* CHECK dout0_12 Vdout0_12ck106 = 0 time = 1070
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=1070.05n

* CHECK dout0_13 Vdout0_13ck106 = 1.8 time = 1070
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=1070.05n

* CHECK dout0_14 Vdout0_14ck106 = 1.8 time = 1070
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=1070.05n

* CHECK dout0_15 Vdout0_15ck106 = 1.8 time = 1070
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=1070.05n

* CHECK dout0_16 Vdout0_16ck106 = 1.8 time = 1070
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=1070.05n

* CHECK dout0_17 Vdout0_17ck106 = 0 time = 1070
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=1070.05n

* CHECK dout0_18 Vdout0_18ck106 = 0 time = 1070
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=1070.05n

* CHECK dout0_19 Vdout0_19ck106 = 0 time = 1070
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=1070.05n

* CHECK dout0_20 Vdout0_20ck106 = 1.8 time = 1070
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=1070.05n

* CHECK dout0_21 Vdout0_21ck106 = 1.8 time = 1070
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=1070.05n

* CHECK dout0_22 Vdout0_22ck106 = 1.8 time = 1070
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=1070.05n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 1070
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=1070.05n

* CHECK dout0_24 Vdout0_24ck106 = 1.8 time = 1070
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=1070.05n

* CHECK dout0_25 Vdout0_25ck106 = 1.8 time = 1070
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=1070.05n

* CHECK dout0_26 Vdout0_26ck106 = 0 time = 1070
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=1070.05n

* CHECK dout0_27 Vdout0_27ck106 = 0 time = 1070
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=1070.05n

* CHECK dout0_28 Vdout0_28ck106 = 0 time = 1070
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=1070.05n

* CHECK dout0_29 Vdout0_29ck106 = 1.8 time = 1070
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=1070.05n

* CHECK dout0_30 Vdout0_30ck106 = 1.8 time = 1070
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=1070.05n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 1070
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=1070.05n

* CHECK dout0_32 Vdout0_32ck106 = 1.8 time = 1070
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=1070.05n

* CHECK dout0_33 Vdout0_33ck106 = 0 time = 1070
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=1070.05n

* CHECK dout0_34 Vdout0_34ck106 = 0 time = 1070
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=1070.05n

* CHECK dout0_35 Vdout0_35ck106 = 1.8 time = 1070
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=1070.05n

* CHECK dout0_36 Vdout0_36ck106 = 0 time = 1070
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=1070.05n

* CHECK dout0_37 Vdout0_37ck106 = 0 time = 1070
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=1070.05n

* CHECK dout0_38 Vdout0_38ck106 = 0 time = 1070
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=1070.05n

* CHECK dout0_39 Vdout0_39ck106 = 1.8 time = 1070
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=1070.05n

* CHECK dout0_40 Vdout0_40ck106 = 0 time = 1070
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=1070.05n

* CHECK dout0_41 Vdout0_41ck106 = 1.8 time = 1070
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=1070.05n

* CHECK dout0_42 Vdout0_42ck106 = 0 time = 1070
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=1070.05n

* CHECK dout0_43 Vdout0_43ck106 = 1.8 time = 1070
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=1070.05n

* CHECK dout0_44 Vdout0_44ck106 = 1.8 time = 1070
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=1070.05n

* CHECK dout0_45 Vdout0_45ck106 = 1.8 time = 1070
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=1070.05n

* CHECK dout0_46 Vdout0_46ck106 = 0 time = 1070
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=1070.05n

* CHECK dout0_47 Vdout0_47ck106 = 0 time = 1070
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=1070.05n

* CHECK dout0_48 Vdout0_48ck106 = 1.8 time = 1070
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=1070.05n

* CHECK dout0_49 Vdout0_49ck106 = 0 time = 1070
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=1070.05n

* CHECK dout0_50 Vdout0_50ck106 = 1.8 time = 1070
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=1070.05n

* CHECK dout0_51 Vdout0_51ck106 = 1.8 time = 1070
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=1070.05n

* CHECK dout0_52 Vdout0_52ck106 = 0 time = 1070
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=1070.05n

* CHECK dout0_53 Vdout0_53ck106 = 1.8 time = 1070
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=1070.05n

* CHECK dout0_54 Vdout0_54ck106 = 1.8 time = 1070
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=1070.05n

* CHECK dout0_55 Vdout0_55ck106 = 1.8 time = 1070
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=1070.05n

* CHECK dout0_56 Vdout0_56ck106 = 0 time = 1070
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=1070.05n

* CHECK dout0_57 Vdout0_57ck106 = 1.8 time = 1070
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=1070.05n

* CHECK dout0_58 Vdout0_58ck106 = 0 time = 1070
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=1070.05n

* CHECK dout0_59 Vdout0_59ck106 = 1.8 time = 1070
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=1070.05n

* CHECK dout0_60 Vdout0_60ck106 = 1.8 time = 1070
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=1070.05n

* CHECK dout0_61 Vdout0_61ck106 = 0 time = 1070
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=1070.05n

* CHECK dout0_62 Vdout0_62ck106 = 1.8 time = 1070
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=1070.05n

* CHECK dout0_63 Vdout0_63ck106 = 1.8 time = 1070
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=1070.05n

* CHECK dout0_64 Vdout0_64ck106 = 0 time = 1070
.meas tran vdout0_64ck106 FIND v(dout0_64) AT=1070.05n

* CHECK dout0_0 Vdout0_0ck109 = 1.8 time = 1100
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=1100.05n

* CHECK dout0_1 Vdout0_1ck109 = 0 time = 1100
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=1100.05n

* CHECK dout0_2 Vdout0_2ck109 = 1.8 time = 1100
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=1100.05n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 1100
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=1100.05n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 1100
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=1100.05n

* CHECK dout0_5 Vdout0_5ck109 = 0 time = 1100
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=1100.05n

* CHECK dout0_6 Vdout0_6ck109 = 0 time = 1100
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=1100.05n

* CHECK dout0_7 Vdout0_7ck109 = 1.8 time = 1100
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=1100.05n

* CHECK dout0_8 Vdout0_8ck109 = 1.8 time = 1100
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=1100.05n

* CHECK dout0_9 Vdout0_9ck109 = 0 time = 1100
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=1100.05n

* CHECK dout0_10 Vdout0_10ck109 = 0 time = 1100
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=1100.05n

* CHECK dout0_11 Vdout0_11ck109 = 0 time = 1100
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=1100.05n

* CHECK dout0_12 Vdout0_12ck109 = 1.8 time = 1100
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=1100.05n

* CHECK dout0_13 Vdout0_13ck109 = 1.8 time = 1100
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=1100.05n

* CHECK dout0_14 Vdout0_14ck109 = 1.8 time = 1100
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=1100.05n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 1100
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=1100.05n

* CHECK dout0_16 Vdout0_16ck109 = 1.8 time = 1100
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=1100.05n

* CHECK dout0_17 Vdout0_17ck109 = 0 time = 1100
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=1100.05n

* CHECK dout0_18 Vdout0_18ck109 = 0 time = 1100
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=1100.05n

* CHECK dout0_19 Vdout0_19ck109 = 0 time = 1100
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=1100.05n

* CHECK dout0_20 Vdout0_20ck109 = 1.8 time = 1100
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=1100.05n

* CHECK dout0_21 Vdout0_21ck109 = 0 time = 1100
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=1100.05n

* CHECK dout0_22 Vdout0_22ck109 = 1.8 time = 1100
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=1100.05n

* CHECK dout0_23 Vdout0_23ck109 = 1.8 time = 1100
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=1100.05n

* CHECK dout0_24 Vdout0_24ck109 = 0 time = 1100
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=1100.05n

* CHECK dout0_25 Vdout0_25ck109 = 1.8 time = 1100
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=1100.05n

* CHECK dout0_26 Vdout0_26ck109 = 1.8 time = 1100
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=1100.05n

* CHECK dout0_27 Vdout0_27ck109 = 0 time = 1100
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=1100.05n

* CHECK dout0_28 Vdout0_28ck109 = 0 time = 1100
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=1100.05n

* CHECK dout0_29 Vdout0_29ck109 = 1.8 time = 1100
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=1100.05n

* CHECK dout0_30 Vdout0_30ck109 = 0 time = 1100
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=1100.05n

* CHECK dout0_31 Vdout0_31ck109 = 1.8 time = 1100
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=1100.05n

* CHECK dout0_32 Vdout0_32ck109 = 0 time = 1100
.meas tran vdout0_32ck109 FIND v(dout0_32) AT=1100.05n

* CHECK dout0_33 Vdout0_33ck109 = 0 time = 1100
.meas tran vdout0_33ck109 FIND v(dout0_33) AT=1100.05n

* CHECK dout0_34 Vdout0_34ck109 = 0 time = 1100
.meas tran vdout0_34ck109 FIND v(dout0_34) AT=1100.05n

* CHECK dout0_35 Vdout0_35ck109 = 1.8 time = 1100
.meas tran vdout0_35ck109 FIND v(dout0_35) AT=1100.05n

* CHECK dout0_36 Vdout0_36ck109 = 0 time = 1100
.meas tran vdout0_36ck109 FIND v(dout0_36) AT=1100.05n

* CHECK dout0_37 Vdout0_37ck109 = 0 time = 1100
.meas tran vdout0_37ck109 FIND v(dout0_37) AT=1100.05n

* CHECK dout0_38 Vdout0_38ck109 = 0 time = 1100
.meas tran vdout0_38ck109 FIND v(dout0_38) AT=1100.05n

* CHECK dout0_39 Vdout0_39ck109 = 0 time = 1100
.meas tran vdout0_39ck109 FIND v(dout0_39) AT=1100.05n

* CHECK dout0_40 Vdout0_40ck109 = 0 time = 1100
.meas tran vdout0_40ck109 FIND v(dout0_40) AT=1100.05n

* CHECK dout0_41 Vdout0_41ck109 = 1.8 time = 1100
.meas tran vdout0_41ck109 FIND v(dout0_41) AT=1100.05n

* CHECK dout0_42 Vdout0_42ck109 = 1.8 time = 1100
.meas tran vdout0_42ck109 FIND v(dout0_42) AT=1100.05n

* CHECK dout0_43 Vdout0_43ck109 = 0 time = 1100
.meas tran vdout0_43ck109 FIND v(dout0_43) AT=1100.05n

* CHECK dout0_44 Vdout0_44ck109 = 0 time = 1100
.meas tran vdout0_44ck109 FIND v(dout0_44) AT=1100.05n

* CHECK dout0_45 Vdout0_45ck109 = 1.8 time = 1100
.meas tran vdout0_45ck109 FIND v(dout0_45) AT=1100.05n

* CHECK dout0_46 Vdout0_46ck109 = 1.8 time = 1100
.meas tran vdout0_46ck109 FIND v(dout0_46) AT=1100.05n

* CHECK dout0_47 Vdout0_47ck109 = 0 time = 1100
.meas tran vdout0_47ck109 FIND v(dout0_47) AT=1100.05n

* CHECK dout0_48 Vdout0_48ck109 = 1.8 time = 1100
.meas tran vdout0_48ck109 FIND v(dout0_48) AT=1100.05n

* CHECK dout0_49 Vdout0_49ck109 = 1.8 time = 1100
.meas tran vdout0_49ck109 FIND v(dout0_49) AT=1100.05n

* CHECK dout0_50 Vdout0_50ck109 = 0 time = 1100
.meas tran vdout0_50ck109 FIND v(dout0_50) AT=1100.05n

* CHECK dout0_51 Vdout0_51ck109 = 0 time = 1100
.meas tran vdout0_51ck109 FIND v(dout0_51) AT=1100.05n

* CHECK dout0_52 Vdout0_52ck109 = 0 time = 1100
.meas tran vdout0_52ck109 FIND v(dout0_52) AT=1100.05n

* CHECK dout0_53 Vdout0_53ck109 = 1.8 time = 1100
.meas tran vdout0_53ck109 FIND v(dout0_53) AT=1100.05n

* CHECK dout0_54 Vdout0_54ck109 = 0 time = 1100
.meas tran vdout0_54ck109 FIND v(dout0_54) AT=1100.05n

* CHECK dout0_55 Vdout0_55ck109 = 0 time = 1100
.meas tran vdout0_55ck109 FIND v(dout0_55) AT=1100.05n

* CHECK dout0_56 Vdout0_56ck109 = 1.8 time = 1100
.meas tran vdout0_56ck109 FIND v(dout0_56) AT=1100.05n

* CHECK dout0_57 Vdout0_57ck109 = 0 time = 1100
.meas tran vdout0_57ck109 FIND v(dout0_57) AT=1100.05n

* CHECK dout0_58 Vdout0_58ck109 = 0 time = 1100
.meas tran vdout0_58ck109 FIND v(dout0_58) AT=1100.05n

* CHECK dout0_59 Vdout0_59ck109 = 0 time = 1100
.meas tran vdout0_59ck109 FIND v(dout0_59) AT=1100.05n

* CHECK dout0_60 Vdout0_60ck109 = 0 time = 1100
.meas tran vdout0_60ck109 FIND v(dout0_60) AT=1100.05n

* CHECK dout0_61 Vdout0_61ck109 = 1.8 time = 1100
.meas tran vdout0_61ck109 FIND v(dout0_61) AT=1100.05n

* CHECK dout0_62 Vdout0_62ck109 = 1.8 time = 1100
.meas tran vdout0_62ck109 FIND v(dout0_62) AT=1100.05n

* CHECK dout0_63 Vdout0_63ck109 = 1.8 time = 1100
.meas tran vdout0_63ck109 FIND v(dout0_63) AT=1100.05n

* CHECK dout0_64 Vdout0_64ck109 = 0 time = 1100
.meas tran vdout0_64ck109 FIND v(dout0_64) AT=1100.05n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 1110
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=1110.05n

* CHECK dout0_1 Vdout0_1ck110 = 0 time = 1110
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=1110.05n

* CHECK dout0_2 Vdout0_2ck110 = 1.8 time = 1110
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=1110.05n

* CHECK dout0_3 Vdout0_3ck110 = 0 time = 1110
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=1110.05n

* CHECK dout0_4 Vdout0_4ck110 = 1.8 time = 1110
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=1110.05n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 1110
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=1110.05n

* CHECK dout0_6 Vdout0_6ck110 = 1.8 time = 1110
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=1110.05n

* CHECK dout0_7 Vdout0_7ck110 = 0 time = 1110
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=1110.05n

* CHECK dout0_8 Vdout0_8ck110 = 0 time = 1110
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=1110.05n

* CHECK dout0_9 Vdout0_9ck110 = 1.8 time = 1110
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=1110.05n

* CHECK dout0_10 Vdout0_10ck110 = 1.8 time = 1110
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=1110.05n

* CHECK dout0_11 Vdout0_11ck110 = 1.8 time = 1110
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=1110.05n

* CHECK dout0_12 Vdout0_12ck110 = 1.8 time = 1110
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=1110.05n

* CHECK dout0_13 Vdout0_13ck110 = 1.8 time = 1110
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=1110.05n

* CHECK dout0_14 Vdout0_14ck110 = 1.8 time = 1110
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=1110.05n

* CHECK dout0_15 Vdout0_15ck110 = 1.8 time = 1110
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=1110.05n

* CHECK dout0_16 Vdout0_16ck110 = 0 time = 1110
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=1110.05n

* CHECK dout0_17 Vdout0_17ck110 = 1.8 time = 1110
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=1110.05n

* CHECK dout0_18 Vdout0_18ck110 = 1.8 time = 1110
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=1110.05n

* CHECK dout0_19 Vdout0_19ck110 = 1.8 time = 1110
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=1110.05n

* CHECK dout0_20 Vdout0_20ck110 = 0 time = 1110
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=1110.05n

* CHECK dout0_21 Vdout0_21ck110 = 0 time = 1110
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=1110.05n

* CHECK dout0_22 Vdout0_22ck110 = 1.8 time = 1110
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=1110.05n

* CHECK dout0_23 Vdout0_23ck110 = 0 time = 1110
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=1110.05n

* CHECK dout0_24 Vdout0_24ck110 = 1.8 time = 1110
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=1110.05n

* CHECK dout0_25 Vdout0_25ck110 = 1.8 time = 1110
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=1110.05n

* CHECK dout0_26 Vdout0_26ck110 = 1.8 time = 1110
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=1110.05n

* CHECK dout0_27 Vdout0_27ck110 = 0 time = 1110
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=1110.05n

* CHECK dout0_28 Vdout0_28ck110 = 1.8 time = 1110
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=1110.05n

* CHECK dout0_29 Vdout0_29ck110 = 0 time = 1110
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=1110.05n

* CHECK dout0_30 Vdout0_30ck110 = 1.8 time = 1110
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=1110.05n

* CHECK dout0_31 Vdout0_31ck110 = 0 time = 1110
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=1110.05n

* CHECK dout0_32 Vdout0_32ck110 = 1.8 time = 1110
.meas tran vdout0_32ck110 FIND v(dout0_32) AT=1110.05n

* CHECK dout0_33 Vdout0_33ck110 = 1.8 time = 1110
.meas tran vdout0_33ck110 FIND v(dout0_33) AT=1110.05n

* CHECK dout0_34 Vdout0_34ck110 = 0 time = 1110
.meas tran vdout0_34ck110 FIND v(dout0_34) AT=1110.05n

* CHECK dout0_35 Vdout0_35ck110 = 1.8 time = 1110
.meas tran vdout0_35ck110 FIND v(dout0_35) AT=1110.05n

* CHECK dout0_36 Vdout0_36ck110 = 1.8 time = 1110
.meas tran vdout0_36ck110 FIND v(dout0_36) AT=1110.05n

* CHECK dout0_37 Vdout0_37ck110 = 0 time = 1110
.meas tran vdout0_37ck110 FIND v(dout0_37) AT=1110.05n

* CHECK dout0_38 Vdout0_38ck110 = 1.8 time = 1110
.meas tran vdout0_38ck110 FIND v(dout0_38) AT=1110.05n

* CHECK dout0_39 Vdout0_39ck110 = 1.8 time = 1110
.meas tran vdout0_39ck110 FIND v(dout0_39) AT=1110.05n

* CHECK dout0_40 Vdout0_40ck110 = 1.8 time = 1110
.meas tran vdout0_40ck110 FIND v(dout0_40) AT=1110.05n

* CHECK dout0_41 Vdout0_41ck110 = 1.8 time = 1110
.meas tran vdout0_41ck110 FIND v(dout0_41) AT=1110.05n

* CHECK dout0_42 Vdout0_42ck110 = 1.8 time = 1110
.meas tran vdout0_42ck110 FIND v(dout0_42) AT=1110.05n

* CHECK dout0_43 Vdout0_43ck110 = 1.8 time = 1110
.meas tran vdout0_43ck110 FIND v(dout0_43) AT=1110.05n

* CHECK dout0_44 Vdout0_44ck110 = 1.8 time = 1110
.meas tran vdout0_44ck110 FIND v(dout0_44) AT=1110.05n

* CHECK dout0_45 Vdout0_45ck110 = 1.8 time = 1110
.meas tran vdout0_45ck110 FIND v(dout0_45) AT=1110.05n

* CHECK dout0_46 Vdout0_46ck110 = 1.8 time = 1110
.meas tran vdout0_46ck110 FIND v(dout0_46) AT=1110.05n

* CHECK dout0_47 Vdout0_47ck110 = 0 time = 1110
.meas tran vdout0_47ck110 FIND v(dout0_47) AT=1110.05n

* CHECK dout0_48 Vdout0_48ck110 = 0 time = 1110
.meas tran vdout0_48ck110 FIND v(dout0_48) AT=1110.05n

* CHECK dout0_49 Vdout0_49ck110 = 1.8 time = 1110
.meas tran vdout0_49ck110 FIND v(dout0_49) AT=1110.05n

* CHECK dout0_50 Vdout0_50ck110 = 1.8 time = 1110
.meas tran vdout0_50ck110 FIND v(dout0_50) AT=1110.05n

* CHECK dout0_51 Vdout0_51ck110 = 1.8 time = 1110
.meas tran vdout0_51ck110 FIND v(dout0_51) AT=1110.05n

* CHECK dout0_52 Vdout0_52ck110 = 0 time = 1110
.meas tran vdout0_52ck110 FIND v(dout0_52) AT=1110.05n

* CHECK dout0_53 Vdout0_53ck110 = 0 time = 1110
.meas tran vdout0_53ck110 FIND v(dout0_53) AT=1110.05n

* CHECK dout0_54 Vdout0_54ck110 = 1.8 time = 1110
.meas tran vdout0_54ck110 FIND v(dout0_54) AT=1110.05n

* CHECK dout0_55 Vdout0_55ck110 = 1.8 time = 1110
.meas tran vdout0_55ck110 FIND v(dout0_55) AT=1110.05n

* CHECK dout0_56 Vdout0_56ck110 = 1.8 time = 1110
.meas tran vdout0_56ck110 FIND v(dout0_56) AT=1110.05n

* CHECK dout0_57 Vdout0_57ck110 = 0 time = 1110
.meas tran vdout0_57ck110 FIND v(dout0_57) AT=1110.05n

* CHECK dout0_58 Vdout0_58ck110 = 0 time = 1110
.meas tran vdout0_58ck110 FIND v(dout0_58) AT=1110.05n

* CHECK dout0_59 Vdout0_59ck110 = 1.8 time = 1110
.meas tran vdout0_59ck110 FIND v(dout0_59) AT=1110.05n

* CHECK dout0_60 Vdout0_60ck110 = 1.8 time = 1110
.meas tran vdout0_60ck110 FIND v(dout0_60) AT=1110.05n

* CHECK dout0_61 Vdout0_61ck110 = 0 time = 1110
.meas tran vdout0_61ck110 FIND v(dout0_61) AT=1110.05n

* CHECK dout0_62 Vdout0_62ck110 = 0 time = 1110
.meas tran vdout0_62ck110 FIND v(dout0_62) AT=1110.05n

* CHECK dout0_63 Vdout0_63ck110 = 1.8 time = 1110
.meas tran vdout0_63ck110 FIND v(dout0_63) AT=1110.05n

* CHECK dout0_64 Vdout0_64ck110 = 0 time = 1110
.meas tran vdout0_64ck110 FIND v(dout0_64) AT=1110.05n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 1140
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=1140.05n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 1140
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=1140.05n

* CHECK dout0_2 Vdout0_2ck113 = 1.8 time = 1140
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=1140.05n

* CHECK dout0_3 Vdout0_3ck113 = 0 time = 1140
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=1140.05n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 1140
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=1140.05n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 1140
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=1140.05n

* CHECK dout0_6 Vdout0_6ck113 = 0 time = 1140
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=1140.05n

* CHECK dout0_7 Vdout0_7ck113 = 1.8 time = 1140
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=1140.05n

* CHECK dout0_8 Vdout0_8ck113 = 0 time = 1140
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=1140.05n

* CHECK dout0_9 Vdout0_9ck113 = 0 time = 1140
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=1140.05n

* CHECK dout0_10 Vdout0_10ck113 = 1.8 time = 1140
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=1140.05n

* CHECK dout0_11 Vdout0_11ck113 = 1.8 time = 1140
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=1140.05n

* CHECK dout0_12 Vdout0_12ck113 = 1.8 time = 1140
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=1140.05n

* CHECK dout0_13 Vdout0_13ck113 = 0 time = 1140
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=1140.05n

* CHECK dout0_14 Vdout0_14ck113 = 1.8 time = 1140
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=1140.05n

* CHECK dout0_15 Vdout0_15ck113 = 1.8 time = 1140
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=1140.05n

* CHECK dout0_16 Vdout0_16ck113 = 0 time = 1140
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=1140.05n

* CHECK dout0_17 Vdout0_17ck113 = 0 time = 1140
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=1140.05n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 1140
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=1140.05n

* CHECK dout0_19 Vdout0_19ck113 = 1.8 time = 1140
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=1140.05n

* CHECK dout0_20 Vdout0_20ck113 = 0 time = 1140
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=1140.05n

* CHECK dout0_21 Vdout0_21ck113 = 1.8 time = 1140
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=1140.05n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 1140
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=1140.05n

* CHECK dout0_23 Vdout0_23ck113 = 1.8 time = 1140
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=1140.05n

* CHECK dout0_24 Vdout0_24ck113 = 1.8 time = 1140
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=1140.05n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 1140
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=1140.05n

* CHECK dout0_26 Vdout0_26ck113 = 0 time = 1140
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=1140.05n

* CHECK dout0_27 Vdout0_27ck113 = 1.8 time = 1140
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=1140.05n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 1140
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=1140.05n

* CHECK dout0_29 Vdout0_29ck113 = 0 time = 1140
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=1140.05n

* CHECK dout0_30 Vdout0_30ck113 = 1.8 time = 1140
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=1140.05n

* CHECK dout0_31 Vdout0_31ck113 = 1.8 time = 1140
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=1140.05n

* CHECK dout0_32 Vdout0_32ck113 = 1.8 time = 1140
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=1140.05n

* CHECK dout0_33 Vdout0_33ck113 = 1.8 time = 1140
.meas tran vdout0_33ck113 FIND v(dout0_33) AT=1140.05n

* CHECK dout0_34 Vdout0_34ck113 = 1.8 time = 1140
.meas tran vdout0_34ck113 FIND v(dout0_34) AT=1140.05n

* CHECK dout0_35 Vdout0_35ck113 = 0 time = 1140
.meas tran vdout0_35ck113 FIND v(dout0_35) AT=1140.05n

* CHECK dout0_36 Vdout0_36ck113 = 0 time = 1140
.meas tran vdout0_36ck113 FIND v(dout0_36) AT=1140.05n

* CHECK dout0_37 Vdout0_37ck113 = 1.8 time = 1140
.meas tran vdout0_37ck113 FIND v(dout0_37) AT=1140.05n

* CHECK dout0_38 Vdout0_38ck113 = 0 time = 1140
.meas tran vdout0_38ck113 FIND v(dout0_38) AT=1140.05n

* CHECK dout0_39 Vdout0_39ck113 = 1.8 time = 1140
.meas tran vdout0_39ck113 FIND v(dout0_39) AT=1140.05n

* CHECK dout0_40 Vdout0_40ck113 = 1.8 time = 1140
.meas tran vdout0_40ck113 FIND v(dout0_40) AT=1140.05n

* CHECK dout0_41 Vdout0_41ck113 = 1.8 time = 1140
.meas tran vdout0_41ck113 FIND v(dout0_41) AT=1140.05n

* CHECK dout0_42 Vdout0_42ck113 = 1.8 time = 1140
.meas tran vdout0_42ck113 FIND v(dout0_42) AT=1140.05n

* CHECK dout0_43 Vdout0_43ck113 = 0 time = 1140
.meas tran vdout0_43ck113 FIND v(dout0_43) AT=1140.05n

* CHECK dout0_44 Vdout0_44ck113 = 1.8 time = 1140
.meas tran vdout0_44ck113 FIND v(dout0_44) AT=1140.05n

* CHECK dout0_45 Vdout0_45ck113 = 1.8 time = 1140
.meas tran vdout0_45ck113 FIND v(dout0_45) AT=1140.05n

* CHECK dout0_46 Vdout0_46ck113 = 0 time = 1140
.meas tran vdout0_46ck113 FIND v(dout0_46) AT=1140.05n

* CHECK dout0_47 Vdout0_47ck113 = 0 time = 1140
.meas tran vdout0_47ck113 FIND v(dout0_47) AT=1140.05n

* CHECK dout0_48 Vdout0_48ck113 = 1.8 time = 1140
.meas tran vdout0_48ck113 FIND v(dout0_48) AT=1140.05n

* CHECK dout0_49 Vdout0_49ck113 = 1.8 time = 1140
.meas tran vdout0_49ck113 FIND v(dout0_49) AT=1140.05n

* CHECK dout0_50 Vdout0_50ck113 = 1.8 time = 1140
.meas tran vdout0_50ck113 FIND v(dout0_50) AT=1140.05n

* CHECK dout0_51 Vdout0_51ck113 = 1.8 time = 1140
.meas tran vdout0_51ck113 FIND v(dout0_51) AT=1140.05n

* CHECK dout0_52 Vdout0_52ck113 = 1.8 time = 1140
.meas tran vdout0_52ck113 FIND v(dout0_52) AT=1140.05n

* CHECK dout0_53 Vdout0_53ck113 = 1.8 time = 1140
.meas tran vdout0_53ck113 FIND v(dout0_53) AT=1140.05n

* CHECK dout0_54 Vdout0_54ck113 = 0 time = 1140
.meas tran vdout0_54ck113 FIND v(dout0_54) AT=1140.05n

* CHECK dout0_55 Vdout0_55ck113 = 0 time = 1140
.meas tran vdout0_55ck113 FIND v(dout0_55) AT=1140.05n

* CHECK dout0_56 Vdout0_56ck113 = 0 time = 1140
.meas tran vdout0_56ck113 FIND v(dout0_56) AT=1140.05n

* CHECK dout0_57 Vdout0_57ck113 = 1.8 time = 1140
.meas tran vdout0_57ck113 FIND v(dout0_57) AT=1140.05n

* CHECK dout0_58 Vdout0_58ck113 = 1.8 time = 1140
.meas tran vdout0_58ck113 FIND v(dout0_58) AT=1140.05n

* CHECK dout0_59 Vdout0_59ck113 = 0 time = 1140
.meas tran vdout0_59ck113 FIND v(dout0_59) AT=1140.05n

* CHECK dout0_60 Vdout0_60ck113 = 1.8 time = 1140
.meas tran vdout0_60ck113 FIND v(dout0_60) AT=1140.05n

* CHECK dout0_61 Vdout0_61ck113 = 0 time = 1140
.meas tran vdout0_61ck113 FIND v(dout0_61) AT=1140.05n

* CHECK dout0_62 Vdout0_62ck113 = 0 time = 1140
.meas tran vdout0_62ck113 FIND v(dout0_62) AT=1140.05n

* CHECK dout0_63 Vdout0_63ck113 = 0 time = 1140
.meas tran vdout0_63ck113 FIND v(dout0_63) AT=1140.05n

* CHECK dout0_64 Vdout0_64ck113 = 0 time = 1140
.meas tran vdout0_64ck113 FIND v(dout0_64) AT=1140.05n

* CHECK dout0_0 Vdout0_0ck114 = 1.8 time = 1150
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=1150.05n

* CHECK dout0_1 Vdout0_1ck114 = 0 time = 1150
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=1150.05n

* CHECK dout0_2 Vdout0_2ck114 = 1.8 time = 1150
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=1150.05n

* CHECK dout0_3 Vdout0_3ck114 = 0 time = 1150
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=1150.05n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 1150
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=1150.05n

* CHECK dout0_5 Vdout0_5ck114 = 1.8 time = 1150
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=1150.05n

* CHECK dout0_6 Vdout0_6ck114 = 0 time = 1150
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=1150.05n

* CHECK dout0_7 Vdout0_7ck114 = 0 time = 1150
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=1150.05n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 1150
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=1150.05n

* CHECK dout0_9 Vdout0_9ck114 = 0 time = 1150
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=1150.05n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 1150
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=1150.05n

* CHECK dout0_11 Vdout0_11ck114 = 1.8 time = 1150
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=1150.05n

* CHECK dout0_12 Vdout0_12ck114 = 0 time = 1150
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=1150.05n

* CHECK dout0_13 Vdout0_13ck114 = 1.8 time = 1150
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=1150.05n

* CHECK dout0_14 Vdout0_14ck114 = 1.8 time = 1150
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=1150.05n

* CHECK dout0_15 Vdout0_15ck114 = 1.8 time = 1150
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=1150.05n

* CHECK dout0_16 Vdout0_16ck114 = 1.8 time = 1150
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=1150.05n

* CHECK dout0_17 Vdout0_17ck114 = 1.8 time = 1150
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=1150.05n

* CHECK dout0_18 Vdout0_18ck114 = 0 time = 1150
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=1150.05n

* CHECK dout0_19 Vdout0_19ck114 = 1.8 time = 1150
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=1150.05n

* CHECK dout0_20 Vdout0_20ck114 = 0 time = 1150
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=1150.05n

* CHECK dout0_21 Vdout0_21ck114 = 1.8 time = 1150
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=1150.05n

* CHECK dout0_22 Vdout0_22ck114 = 0 time = 1150
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=1150.05n

* CHECK dout0_23 Vdout0_23ck114 = 0 time = 1150
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=1150.05n

* CHECK dout0_24 Vdout0_24ck114 = 0 time = 1150
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=1150.05n

* CHECK dout0_25 Vdout0_25ck114 = 1.8 time = 1150
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=1150.05n

* CHECK dout0_26 Vdout0_26ck114 = 0 time = 1150
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=1150.05n

* CHECK dout0_27 Vdout0_27ck114 = 0 time = 1150
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=1150.05n

* CHECK dout0_28 Vdout0_28ck114 = 0 time = 1150
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=1150.05n

* CHECK dout0_29 Vdout0_29ck114 = 1.8 time = 1150
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=1150.05n

* CHECK dout0_30 Vdout0_30ck114 = 1.8 time = 1150
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=1150.05n

* CHECK dout0_31 Vdout0_31ck114 = 0 time = 1150
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=1150.05n

* CHECK dout0_32 Vdout0_32ck114 = 1.8 time = 1150
.meas tran vdout0_32ck114 FIND v(dout0_32) AT=1150.05n

* CHECK dout0_33 Vdout0_33ck114 = 0 time = 1150
.meas tran vdout0_33ck114 FIND v(dout0_33) AT=1150.05n

* CHECK dout0_34 Vdout0_34ck114 = 1.8 time = 1150
.meas tran vdout0_34ck114 FIND v(dout0_34) AT=1150.05n

* CHECK dout0_35 Vdout0_35ck114 = 1.8 time = 1150
.meas tran vdout0_35ck114 FIND v(dout0_35) AT=1150.05n

* CHECK dout0_36 Vdout0_36ck114 = 1.8 time = 1150
.meas tran vdout0_36ck114 FIND v(dout0_36) AT=1150.05n

* CHECK dout0_37 Vdout0_37ck114 = 0 time = 1150
.meas tran vdout0_37ck114 FIND v(dout0_37) AT=1150.05n

* CHECK dout0_38 Vdout0_38ck114 = 0 time = 1150
.meas tran vdout0_38ck114 FIND v(dout0_38) AT=1150.05n

* CHECK dout0_39 Vdout0_39ck114 = 1.8 time = 1150
.meas tran vdout0_39ck114 FIND v(dout0_39) AT=1150.05n

* CHECK dout0_40 Vdout0_40ck114 = 0 time = 1150
.meas tran vdout0_40ck114 FIND v(dout0_40) AT=1150.05n

* CHECK dout0_41 Vdout0_41ck114 = 0 time = 1150
.meas tran vdout0_41ck114 FIND v(dout0_41) AT=1150.05n

* CHECK dout0_42 Vdout0_42ck114 = 0 time = 1150
.meas tran vdout0_42ck114 FIND v(dout0_42) AT=1150.05n

* CHECK dout0_43 Vdout0_43ck114 = 0 time = 1150
.meas tran vdout0_43ck114 FIND v(dout0_43) AT=1150.05n

* CHECK dout0_44 Vdout0_44ck114 = 0 time = 1150
.meas tran vdout0_44ck114 FIND v(dout0_44) AT=1150.05n

* CHECK dout0_45 Vdout0_45ck114 = 1.8 time = 1150
.meas tran vdout0_45ck114 FIND v(dout0_45) AT=1150.05n

* CHECK dout0_46 Vdout0_46ck114 = 0 time = 1150
.meas tran vdout0_46ck114 FIND v(dout0_46) AT=1150.05n

* CHECK dout0_47 Vdout0_47ck114 = 1.8 time = 1150
.meas tran vdout0_47ck114 FIND v(dout0_47) AT=1150.05n

* CHECK dout0_48 Vdout0_48ck114 = 0 time = 1150
.meas tran vdout0_48ck114 FIND v(dout0_48) AT=1150.05n

* CHECK dout0_49 Vdout0_49ck114 = 0 time = 1150
.meas tran vdout0_49ck114 FIND v(dout0_49) AT=1150.05n

* CHECK dout0_50 Vdout0_50ck114 = 0 time = 1150
.meas tran vdout0_50ck114 FIND v(dout0_50) AT=1150.05n

* CHECK dout0_51 Vdout0_51ck114 = 0 time = 1150
.meas tran vdout0_51ck114 FIND v(dout0_51) AT=1150.05n

* CHECK dout0_52 Vdout0_52ck114 = 0 time = 1150
.meas tran vdout0_52ck114 FIND v(dout0_52) AT=1150.05n

* CHECK dout0_53 Vdout0_53ck114 = 1.8 time = 1150
.meas tran vdout0_53ck114 FIND v(dout0_53) AT=1150.05n

* CHECK dout0_54 Vdout0_54ck114 = 1.8 time = 1150
.meas tran vdout0_54ck114 FIND v(dout0_54) AT=1150.05n

* CHECK dout0_55 Vdout0_55ck114 = 0 time = 1150
.meas tran vdout0_55ck114 FIND v(dout0_55) AT=1150.05n

* CHECK dout0_56 Vdout0_56ck114 = 1.8 time = 1150
.meas tran vdout0_56ck114 FIND v(dout0_56) AT=1150.05n

* CHECK dout0_57 Vdout0_57ck114 = 0 time = 1150
.meas tran vdout0_57ck114 FIND v(dout0_57) AT=1150.05n

* CHECK dout0_58 Vdout0_58ck114 = 1.8 time = 1150
.meas tran vdout0_58ck114 FIND v(dout0_58) AT=1150.05n

* CHECK dout0_59 Vdout0_59ck114 = 0 time = 1150
.meas tran vdout0_59ck114 FIND v(dout0_59) AT=1150.05n

* CHECK dout0_60 Vdout0_60ck114 = 0 time = 1150
.meas tran vdout0_60ck114 FIND v(dout0_60) AT=1150.05n

* CHECK dout0_61 Vdout0_61ck114 = 0 time = 1150
.meas tran vdout0_61ck114 FIND v(dout0_61) AT=1150.05n

* CHECK dout0_62 Vdout0_62ck114 = 0 time = 1150
.meas tran vdout0_62ck114 FIND v(dout0_62) AT=1150.05n

* CHECK dout0_63 Vdout0_63ck114 = 0 time = 1150
.meas tran vdout0_63ck114 FIND v(dout0_63) AT=1150.05n

* CHECK dout0_64 Vdout0_64ck114 = 0 time = 1150
.meas tran vdout0_64ck114 FIND v(dout0_64) AT=1150.05n

* CHECK dout0_0 Vdout0_0ck120 = 1.8 time = 1210
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=1210.05n

* CHECK dout0_1 Vdout0_1ck120 = 1.8 time = 1210
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=1210.05n

* CHECK dout0_2 Vdout0_2ck120 = 0 time = 1210
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=1210.05n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 1210
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=1210.05n

* CHECK dout0_4 Vdout0_4ck120 = 1.8 time = 1210
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=1210.05n

* CHECK dout0_5 Vdout0_5ck120 = 1.8 time = 1210
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=1210.05n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 1210
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=1210.05n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 1210
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=1210.05n

* CHECK dout0_8 Vdout0_8ck120 = 1.8 time = 1210
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=1210.05n

* CHECK dout0_9 Vdout0_9ck120 = 1.8 time = 1210
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=1210.05n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 1210
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=1210.05n

* CHECK dout0_11 Vdout0_11ck120 = 1.8 time = 1210
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=1210.05n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 1210
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=1210.05n

* CHECK dout0_13 Vdout0_13ck120 = 1.8 time = 1210
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=1210.05n

* CHECK dout0_14 Vdout0_14ck120 = 1.8 time = 1210
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=1210.05n

* CHECK dout0_15 Vdout0_15ck120 = 1.8 time = 1210
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=1210.05n

* CHECK dout0_16 Vdout0_16ck120 = 1.8 time = 1210
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=1210.05n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 1210
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=1210.05n

* CHECK dout0_18 Vdout0_18ck120 = 0 time = 1210
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=1210.05n

* CHECK dout0_19 Vdout0_19ck120 = 0 time = 1210
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=1210.05n

* CHECK dout0_20 Vdout0_20ck120 = 1.8 time = 1210
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=1210.05n

* CHECK dout0_21 Vdout0_21ck120 = 1.8 time = 1210
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=1210.05n

* CHECK dout0_22 Vdout0_22ck120 = 1.8 time = 1210
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=1210.05n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 1210
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=1210.05n

* CHECK dout0_24 Vdout0_24ck120 = 1.8 time = 1210
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=1210.05n

* CHECK dout0_25 Vdout0_25ck120 = 1.8 time = 1210
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=1210.05n

* CHECK dout0_26 Vdout0_26ck120 = 0 time = 1210
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=1210.05n

* CHECK dout0_27 Vdout0_27ck120 = 0 time = 1210
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=1210.05n

* CHECK dout0_28 Vdout0_28ck120 = 0 time = 1210
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=1210.05n

* CHECK dout0_29 Vdout0_29ck120 = 1.8 time = 1210
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=1210.05n

* CHECK dout0_30 Vdout0_30ck120 = 1.8 time = 1210
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=1210.05n

* CHECK dout0_31 Vdout0_31ck120 = 0 time = 1210
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=1210.05n

* CHECK dout0_32 Vdout0_32ck120 = 1.8 time = 1210
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=1210.05n

* CHECK dout0_33 Vdout0_33ck120 = 0 time = 1210
.meas tran vdout0_33ck120 FIND v(dout0_33) AT=1210.05n

* CHECK dout0_34 Vdout0_34ck120 = 0 time = 1210
.meas tran vdout0_34ck120 FIND v(dout0_34) AT=1210.05n

* CHECK dout0_35 Vdout0_35ck120 = 1.8 time = 1210
.meas tran vdout0_35ck120 FIND v(dout0_35) AT=1210.05n

* CHECK dout0_36 Vdout0_36ck120 = 0 time = 1210
.meas tran vdout0_36ck120 FIND v(dout0_36) AT=1210.05n

* CHECK dout0_37 Vdout0_37ck120 = 0 time = 1210
.meas tran vdout0_37ck120 FIND v(dout0_37) AT=1210.05n

* CHECK dout0_38 Vdout0_38ck120 = 0 time = 1210
.meas tran vdout0_38ck120 FIND v(dout0_38) AT=1210.05n

* CHECK dout0_39 Vdout0_39ck120 = 1.8 time = 1210
.meas tran vdout0_39ck120 FIND v(dout0_39) AT=1210.05n

* CHECK dout0_40 Vdout0_40ck120 = 0 time = 1210
.meas tran vdout0_40ck120 FIND v(dout0_40) AT=1210.05n

* CHECK dout0_41 Vdout0_41ck120 = 1.8 time = 1210
.meas tran vdout0_41ck120 FIND v(dout0_41) AT=1210.05n

* CHECK dout0_42 Vdout0_42ck120 = 0 time = 1210
.meas tran vdout0_42ck120 FIND v(dout0_42) AT=1210.05n

* CHECK dout0_43 Vdout0_43ck120 = 1.8 time = 1210
.meas tran vdout0_43ck120 FIND v(dout0_43) AT=1210.05n

* CHECK dout0_44 Vdout0_44ck120 = 1.8 time = 1210
.meas tran vdout0_44ck120 FIND v(dout0_44) AT=1210.05n

* CHECK dout0_45 Vdout0_45ck120 = 1.8 time = 1210
.meas tran vdout0_45ck120 FIND v(dout0_45) AT=1210.05n

* CHECK dout0_46 Vdout0_46ck120 = 0 time = 1210
.meas tran vdout0_46ck120 FIND v(dout0_46) AT=1210.05n

* CHECK dout0_47 Vdout0_47ck120 = 0 time = 1210
.meas tran vdout0_47ck120 FIND v(dout0_47) AT=1210.05n

* CHECK dout0_48 Vdout0_48ck120 = 1.8 time = 1210
.meas tran vdout0_48ck120 FIND v(dout0_48) AT=1210.05n

* CHECK dout0_49 Vdout0_49ck120 = 0 time = 1210
.meas tran vdout0_49ck120 FIND v(dout0_49) AT=1210.05n

* CHECK dout0_50 Vdout0_50ck120 = 1.8 time = 1210
.meas tran vdout0_50ck120 FIND v(dout0_50) AT=1210.05n

* CHECK dout0_51 Vdout0_51ck120 = 1.8 time = 1210
.meas tran vdout0_51ck120 FIND v(dout0_51) AT=1210.05n

* CHECK dout0_52 Vdout0_52ck120 = 0 time = 1210
.meas tran vdout0_52ck120 FIND v(dout0_52) AT=1210.05n

* CHECK dout0_53 Vdout0_53ck120 = 1.8 time = 1210
.meas tran vdout0_53ck120 FIND v(dout0_53) AT=1210.05n

* CHECK dout0_54 Vdout0_54ck120 = 1.8 time = 1210
.meas tran vdout0_54ck120 FIND v(dout0_54) AT=1210.05n

* CHECK dout0_55 Vdout0_55ck120 = 1.8 time = 1210
.meas tran vdout0_55ck120 FIND v(dout0_55) AT=1210.05n

* CHECK dout0_56 Vdout0_56ck120 = 0 time = 1210
.meas tran vdout0_56ck120 FIND v(dout0_56) AT=1210.05n

* CHECK dout0_57 Vdout0_57ck120 = 1.8 time = 1210
.meas tran vdout0_57ck120 FIND v(dout0_57) AT=1210.05n

* CHECK dout0_58 Vdout0_58ck120 = 0 time = 1210
.meas tran vdout0_58ck120 FIND v(dout0_58) AT=1210.05n

* CHECK dout0_59 Vdout0_59ck120 = 1.8 time = 1210
.meas tran vdout0_59ck120 FIND v(dout0_59) AT=1210.05n

* CHECK dout0_60 Vdout0_60ck120 = 1.8 time = 1210
.meas tran vdout0_60ck120 FIND v(dout0_60) AT=1210.05n

* CHECK dout0_61 Vdout0_61ck120 = 0 time = 1210
.meas tran vdout0_61ck120 FIND v(dout0_61) AT=1210.05n

* CHECK dout0_62 Vdout0_62ck120 = 1.8 time = 1210
.meas tran vdout0_62ck120 FIND v(dout0_62) AT=1210.05n

* CHECK dout0_63 Vdout0_63ck120 = 1.8 time = 1210
.meas tran vdout0_63ck120 FIND v(dout0_63) AT=1210.05n

* CHECK dout0_64 Vdout0_64ck120 = 0 time = 1210
.meas tran vdout0_64ck120 FIND v(dout0_64) AT=1210.05n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 1220
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=1220.05n

* CHECK dout0_1 Vdout0_1ck121 = 0 time = 1220
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=1220.05n

* CHECK dout0_2 Vdout0_2ck121 = 1.8 time = 1220
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=1220.05n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 1220
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=1220.05n

* CHECK dout0_4 Vdout0_4ck121 = 1.8 time = 1220
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=1220.05n

* CHECK dout0_5 Vdout0_5ck121 = 0 time = 1220
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=1220.05n

* CHECK dout0_6 Vdout0_6ck121 = 1.8 time = 1220
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=1220.05n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 1220
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=1220.05n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 1220
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=1220.05n

* CHECK dout0_9 Vdout0_9ck121 = 1.8 time = 1220
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=1220.05n

* CHECK dout0_10 Vdout0_10ck121 = 1.8 time = 1220
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=1220.05n

* CHECK dout0_11 Vdout0_11ck121 = 1.8 time = 1220
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=1220.05n

* CHECK dout0_12 Vdout0_12ck121 = 1.8 time = 1220
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=1220.05n

* CHECK dout0_13 Vdout0_13ck121 = 1.8 time = 1220
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=1220.05n

* CHECK dout0_14 Vdout0_14ck121 = 1.8 time = 1220
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=1220.05n

* CHECK dout0_15 Vdout0_15ck121 = 1.8 time = 1220
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=1220.05n

* CHECK dout0_16 Vdout0_16ck121 = 0 time = 1220
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=1220.05n

* CHECK dout0_17 Vdout0_17ck121 = 1.8 time = 1220
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=1220.05n

* CHECK dout0_18 Vdout0_18ck121 = 1.8 time = 1220
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=1220.05n

* CHECK dout0_19 Vdout0_19ck121 = 1.8 time = 1220
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=1220.05n

* CHECK dout0_20 Vdout0_20ck121 = 0 time = 1220
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=1220.05n

* CHECK dout0_21 Vdout0_21ck121 = 0 time = 1220
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=1220.05n

* CHECK dout0_22 Vdout0_22ck121 = 1.8 time = 1220
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=1220.05n

* CHECK dout0_23 Vdout0_23ck121 = 0 time = 1220
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=1220.05n

* CHECK dout0_24 Vdout0_24ck121 = 1.8 time = 1220
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=1220.05n

* CHECK dout0_25 Vdout0_25ck121 = 1.8 time = 1220
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=1220.05n

* CHECK dout0_26 Vdout0_26ck121 = 1.8 time = 1220
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=1220.05n

* CHECK dout0_27 Vdout0_27ck121 = 0 time = 1220
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=1220.05n

* CHECK dout0_28 Vdout0_28ck121 = 1.8 time = 1220
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=1220.05n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 1220
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=1220.05n

* CHECK dout0_30 Vdout0_30ck121 = 1.8 time = 1220
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=1220.05n

* CHECK dout0_31 Vdout0_31ck121 = 0 time = 1220
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=1220.05n

* CHECK dout0_32 Vdout0_32ck121 = 1.8 time = 1220
.meas tran vdout0_32ck121 FIND v(dout0_32) AT=1220.05n

* CHECK dout0_33 Vdout0_33ck121 = 1.8 time = 1220
.meas tran vdout0_33ck121 FIND v(dout0_33) AT=1220.05n

* CHECK dout0_34 Vdout0_34ck121 = 0 time = 1220
.meas tran vdout0_34ck121 FIND v(dout0_34) AT=1220.05n

* CHECK dout0_35 Vdout0_35ck121 = 1.8 time = 1220
.meas tran vdout0_35ck121 FIND v(dout0_35) AT=1220.05n

* CHECK dout0_36 Vdout0_36ck121 = 1.8 time = 1220
.meas tran vdout0_36ck121 FIND v(dout0_36) AT=1220.05n

* CHECK dout0_37 Vdout0_37ck121 = 0 time = 1220
.meas tran vdout0_37ck121 FIND v(dout0_37) AT=1220.05n

* CHECK dout0_38 Vdout0_38ck121 = 1.8 time = 1220
.meas tran vdout0_38ck121 FIND v(dout0_38) AT=1220.05n

* CHECK dout0_39 Vdout0_39ck121 = 1.8 time = 1220
.meas tran vdout0_39ck121 FIND v(dout0_39) AT=1220.05n

* CHECK dout0_40 Vdout0_40ck121 = 1.8 time = 1220
.meas tran vdout0_40ck121 FIND v(dout0_40) AT=1220.05n

* CHECK dout0_41 Vdout0_41ck121 = 1.8 time = 1220
.meas tran vdout0_41ck121 FIND v(dout0_41) AT=1220.05n

* CHECK dout0_42 Vdout0_42ck121 = 1.8 time = 1220
.meas tran vdout0_42ck121 FIND v(dout0_42) AT=1220.05n

* CHECK dout0_43 Vdout0_43ck121 = 1.8 time = 1220
.meas tran vdout0_43ck121 FIND v(dout0_43) AT=1220.05n

* CHECK dout0_44 Vdout0_44ck121 = 1.8 time = 1220
.meas tran vdout0_44ck121 FIND v(dout0_44) AT=1220.05n

* CHECK dout0_45 Vdout0_45ck121 = 1.8 time = 1220
.meas tran vdout0_45ck121 FIND v(dout0_45) AT=1220.05n

* CHECK dout0_46 Vdout0_46ck121 = 1.8 time = 1220
.meas tran vdout0_46ck121 FIND v(dout0_46) AT=1220.05n

* CHECK dout0_47 Vdout0_47ck121 = 0 time = 1220
.meas tran vdout0_47ck121 FIND v(dout0_47) AT=1220.05n

* CHECK dout0_48 Vdout0_48ck121 = 0 time = 1220
.meas tran vdout0_48ck121 FIND v(dout0_48) AT=1220.05n

* CHECK dout0_49 Vdout0_49ck121 = 1.8 time = 1220
.meas tran vdout0_49ck121 FIND v(dout0_49) AT=1220.05n

* CHECK dout0_50 Vdout0_50ck121 = 1.8 time = 1220
.meas tran vdout0_50ck121 FIND v(dout0_50) AT=1220.05n

* CHECK dout0_51 Vdout0_51ck121 = 1.8 time = 1220
.meas tran vdout0_51ck121 FIND v(dout0_51) AT=1220.05n

* CHECK dout0_52 Vdout0_52ck121 = 0 time = 1220
.meas tran vdout0_52ck121 FIND v(dout0_52) AT=1220.05n

* CHECK dout0_53 Vdout0_53ck121 = 0 time = 1220
.meas tran vdout0_53ck121 FIND v(dout0_53) AT=1220.05n

* CHECK dout0_54 Vdout0_54ck121 = 1.8 time = 1220
.meas tran vdout0_54ck121 FIND v(dout0_54) AT=1220.05n

* CHECK dout0_55 Vdout0_55ck121 = 1.8 time = 1220
.meas tran vdout0_55ck121 FIND v(dout0_55) AT=1220.05n

* CHECK dout0_56 Vdout0_56ck121 = 1.8 time = 1220
.meas tran vdout0_56ck121 FIND v(dout0_56) AT=1220.05n

* CHECK dout0_57 Vdout0_57ck121 = 0 time = 1220
.meas tran vdout0_57ck121 FIND v(dout0_57) AT=1220.05n

* CHECK dout0_58 Vdout0_58ck121 = 0 time = 1220
.meas tran vdout0_58ck121 FIND v(dout0_58) AT=1220.05n

* CHECK dout0_59 Vdout0_59ck121 = 1.8 time = 1220
.meas tran vdout0_59ck121 FIND v(dout0_59) AT=1220.05n

* CHECK dout0_60 Vdout0_60ck121 = 1.8 time = 1220
.meas tran vdout0_60ck121 FIND v(dout0_60) AT=1220.05n

* CHECK dout0_61 Vdout0_61ck121 = 0 time = 1220
.meas tran vdout0_61ck121 FIND v(dout0_61) AT=1220.05n

* CHECK dout0_62 Vdout0_62ck121 = 0 time = 1220
.meas tran vdout0_62ck121 FIND v(dout0_62) AT=1220.05n

* CHECK dout0_63 Vdout0_63ck121 = 1.8 time = 1220
.meas tran vdout0_63ck121 FIND v(dout0_63) AT=1220.05n

* CHECK dout0_64 Vdout0_64ck121 = 0 time = 1220
.meas tran vdout0_64ck121 FIND v(dout0_64) AT=1220.05n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 1230
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=1230.05n

* CHECK dout0_1 Vdout0_1ck122 = 0 time = 1230
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=1230.05n

* CHECK dout0_2 Vdout0_2ck122 = 1.8 time = 1230
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=1230.05n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 1230
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=1230.05n

* CHECK dout0_4 Vdout0_4ck122 = 1.8 time = 1230
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=1230.05n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 1230
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=1230.05n

* CHECK dout0_6 Vdout0_6ck122 = 1.8 time = 1230
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=1230.05n

* CHECK dout0_7 Vdout0_7ck122 = 0 time = 1230
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=1230.05n

* CHECK dout0_8 Vdout0_8ck122 = 0 time = 1230
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=1230.05n

* CHECK dout0_9 Vdout0_9ck122 = 1.8 time = 1230
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=1230.05n

* CHECK dout0_10 Vdout0_10ck122 = 1.8 time = 1230
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=1230.05n

* CHECK dout0_11 Vdout0_11ck122 = 1.8 time = 1230
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=1230.05n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 1230
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=1230.05n

* CHECK dout0_13 Vdout0_13ck122 = 1.8 time = 1230
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=1230.05n

* CHECK dout0_14 Vdout0_14ck122 = 1.8 time = 1230
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=1230.05n

* CHECK dout0_15 Vdout0_15ck122 = 1.8 time = 1230
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=1230.05n

* CHECK dout0_16 Vdout0_16ck122 = 0 time = 1230
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=1230.05n

* CHECK dout0_17 Vdout0_17ck122 = 1.8 time = 1230
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=1230.05n

* CHECK dout0_18 Vdout0_18ck122 = 1.8 time = 1230
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=1230.05n

* CHECK dout0_19 Vdout0_19ck122 = 1.8 time = 1230
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=1230.05n

* CHECK dout0_20 Vdout0_20ck122 = 0 time = 1230
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=1230.05n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 1230
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=1230.05n

* CHECK dout0_22 Vdout0_22ck122 = 1.8 time = 1230
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=1230.05n

* CHECK dout0_23 Vdout0_23ck122 = 0 time = 1230
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=1230.05n

* CHECK dout0_24 Vdout0_24ck122 = 1.8 time = 1230
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=1230.05n

* CHECK dout0_25 Vdout0_25ck122 = 1.8 time = 1230
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=1230.05n

* CHECK dout0_26 Vdout0_26ck122 = 1.8 time = 1230
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=1230.05n

* CHECK dout0_27 Vdout0_27ck122 = 0 time = 1230
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=1230.05n

* CHECK dout0_28 Vdout0_28ck122 = 1.8 time = 1230
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=1230.05n

* CHECK dout0_29 Vdout0_29ck122 = 0 time = 1230
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=1230.05n

* CHECK dout0_30 Vdout0_30ck122 = 1.8 time = 1230
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=1230.05n

* CHECK dout0_31 Vdout0_31ck122 = 0 time = 1230
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=1230.05n

* CHECK dout0_32 Vdout0_32ck122 = 1.8 time = 1230
.meas tran vdout0_32ck122 FIND v(dout0_32) AT=1230.05n

* CHECK dout0_33 Vdout0_33ck122 = 1.8 time = 1230
.meas tran vdout0_33ck122 FIND v(dout0_33) AT=1230.05n

* CHECK dout0_34 Vdout0_34ck122 = 0 time = 1230
.meas tran vdout0_34ck122 FIND v(dout0_34) AT=1230.05n

* CHECK dout0_35 Vdout0_35ck122 = 1.8 time = 1230
.meas tran vdout0_35ck122 FIND v(dout0_35) AT=1230.05n

* CHECK dout0_36 Vdout0_36ck122 = 1.8 time = 1230
.meas tran vdout0_36ck122 FIND v(dout0_36) AT=1230.05n

* CHECK dout0_37 Vdout0_37ck122 = 0 time = 1230
.meas tran vdout0_37ck122 FIND v(dout0_37) AT=1230.05n

* CHECK dout0_38 Vdout0_38ck122 = 1.8 time = 1230
.meas tran vdout0_38ck122 FIND v(dout0_38) AT=1230.05n

* CHECK dout0_39 Vdout0_39ck122 = 1.8 time = 1230
.meas tran vdout0_39ck122 FIND v(dout0_39) AT=1230.05n

* CHECK dout0_40 Vdout0_40ck122 = 1.8 time = 1230
.meas tran vdout0_40ck122 FIND v(dout0_40) AT=1230.05n

* CHECK dout0_41 Vdout0_41ck122 = 1.8 time = 1230
.meas tran vdout0_41ck122 FIND v(dout0_41) AT=1230.05n

* CHECK dout0_42 Vdout0_42ck122 = 1.8 time = 1230
.meas tran vdout0_42ck122 FIND v(dout0_42) AT=1230.05n

* CHECK dout0_43 Vdout0_43ck122 = 1.8 time = 1230
.meas tran vdout0_43ck122 FIND v(dout0_43) AT=1230.05n

* CHECK dout0_44 Vdout0_44ck122 = 1.8 time = 1230
.meas tran vdout0_44ck122 FIND v(dout0_44) AT=1230.05n

* CHECK dout0_45 Vdout0_45ck122 = 1.8 time = 1230
.meas tran vdout0_45ck122 FIND v(dout0_45) AT=1230.05n

* CHECK dout0_46 Vdout0_46ck122 = 1.8 time = 1230
.meas tran vdout0_46ck122 FIND v(dout0_46) AT=1230.05n

* CHECK dout0_47 Vdout0_47ck122 = 0 time = 1230
.meas tran vdout0_47ck122 FIND v(dout0_47) AT=1230.05n

* CHECK dout0_48 Vdout0_48ck122 = 0 time = 1230
.meas tran vdout0_48ck122 FIND v(dout0_48) AT=1230.05n

* CHECK dout0_49 Vdout0_49ck122 = 1.8 time = 1230
.meas tran vdout0_49ck122 FIND v(dout0_49) AT=1230.05n

* CHECK dout0_50 Vdout0_50ck122 = 1.8 time = 1230
.meas tran vdout0_50ck122 FIND v(dout0_50) AT=1230.05n

* CHECK dout0_51 Vdout0_51ck122 = 1.8 time = 1230
.meas tran vdout0_51ck122 FIND v(dout0_51) AT=1230.05n

* CHECK dout0_52 Vdout0_52ck122 = 0 time = 1230
.meas tran vdout0_52ck122 FIND v(dout0_52) AT=1230.05n

* CHECK dout0_53 Vdout0_53ck122 = 0 time = 1230
.meas tran vdout0_53ck122 FIND v(dout0_53) AT=1230.05n

* CHECK dout0_54 Vdout0_54ck122 = 1.8 time = 1230
.meas tran vdout0_54ck122 FIND v(dout0_54) AT=1230.05n

* CHECK dout0_55 Vdout0_55ck122 = 1.8 time = 1230
.meas tran vdout0_55ck122 FIND v(dout0_55) AT=1230.05n

* CHECK dout0_56 Vdout0_56ck122 = 1.8 time = 1230
.meas tran vdout0_56ck122 FIND v(dout0_56) AT=1230.05n

* CHECK dout0_57 Vdout0_57ck122 = 0 time = 1230
.meas tran vdout0_57ck122 FIND v(dout0_57) AT=1230.05n

* CHECK dout0_58 Vdout0_58ck122 = 0 time = 1230
.meas tran vdout0_58ck122 FIND v(dout0_58) AT=1230.05n

* CHECK dout0_59 Vdout0_59ck122 = 1.8 time = 1230
.meas tran vdout0_59ck122 FIND v(dout0_59) AT=1230.05n

* CHECK dout0_60 Vdout0_60ck122 = 1.8 time = 1230
.meas tran vdout0_60ck122 FIND v(dout0_60) AT=1230.05n

* CHECK dout0_61 Vdout0_61ck122 = 0 time = 1230
.meas tran vdout0_61ck122 FIND v(dout0_61) AT=1230.05n

* CHECK dout0_62 Vdout0_62ck122 = 0 time = 1230
.meas tran vdout0_62ck122 FIND v(dout0_62) AT=1230.05n

* CHECK dout0_63 Vdout0_63ck122 = 1.8 time = 1230
.meas tran vdout0_63ck122 FIND v(dout0_63) AT=1230.05n

* CHECK dout0_64 Vdout0_64ck122 = 0 time = 1230
.meas tran vdout0_64ck122 FIND v(dout0_64) AT=1230.05n

* CHECK dout0_0 Vdout0_0ck124 = 1.8 time = 1250
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=1250.05n

* CHECK dout0_1 Vdout0_1ck124 = 1.8 time = 1250
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=1250.05n

* CHECK dout0_2 Vdout0_2ck124 = 0 time = 1250
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=1250.05n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 1250
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=1250.05n

* CHECK dout0_4 Vdout0_4ck124 = 1.8 time = 1250
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=1250.05n

* CHECK dout0_5 Vdout0_5ck124 = 1.8 time = 1250
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=1250.05n

* CHECK dout0_6 Vdout0_6ck124 = 0 time = 1250
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=1250.05n

* CHECK dout0_7 Vdout0_7ck124 = 0 time = 1250
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=1250.05n

* CHECK dout0_8 Vdout0_8ck124 = 1.8 time = 1250
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=1250.05n

* CHECK dout0_9 Vdout0_9ck124 = 1.8 time = 1250
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=1250.05n

* CHECK dout0_10 Vdout0_10ck124 = 0 time = 1250
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=1250.05n

* CHECK dout0_11 Vdout0_11ck124 = 1.8 time = 1250
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=1250.05n

* CHECK dout0_12 Vdout0_12ck124 = 0 time = 1250
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=1250.05n

* CHECK dout0_13 Vdout0_13ck124 = 1.8 time = 1250
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=1250.05n

* CHECK dout0_14 Vdout0_14ck124 = 1.8 time = 1250
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=1250.05n

* CHECK dout0_15 Vdout0_15ck124 = 1.8 time = 1250
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=1250.05n

* CHECK dout0_16 Vdout0_16ck124 = 1.8 time = 1250
.meas tran vdout0_16ck124 FIND v(dout0_16) AT=1250.05n

* CHECK dout0_17 Vdout0_17ck124 = 0 time = 1250
.meas tran vdout0_17ck124 FIND v(dout0_17) AT=1250.05n

* CHECK dout0_18 Vdout0_18ck124 = 0 time = 1250
.meas tran vdout0_18ck124 FIND v(dout0_18) AT=1250.05n

* CHECK dout0_19 Vdout0_19ck124 = 0 time = 1250
.meas tran vdout0_19ck124 FIND v(dout0_19) AT=1250.05n

* CHECK dout0_20 Vdout0_20ck124 = 1.8 time = 1250
.meas tran vdout0_20ck124 FIND v(dout0_20) AT=1250.05n

* CHECK dout0_21 Vdout0_21ck124 = 1.8 time = 1250
.meas tran vdout0_21ck124 FIND v(dout0_21) AT=1250.05n

* CHECK dout0_22 Vdout0_22ck124 = 1.8 time = 1250
.meas tran vdout0_22ck124 FIND v(dout0_22) AT=1250.05n

* CHECK dout0_23 Vdout0_23ck124 = 0 time = 1250
.meas tran vdout0_23ck124 FIND v(dout0_23) AT=1250.05n

* CHECK dout0_24 Vdout0_24ck124 = 1.8 time = 1250
.meas tran vdout0_24ck124 FIND v(dout0_24) AT=1250.05n

* CHECK dout0_25 Vdout0_25ck124 = 1.8 time = 1250
.meas tran vdout0_25ck124 FIND v(dout0_25) AT=1250.05n

* CHECK dout0_26 Vdout0_26ck124 = 0 time = 1250
.meas tran vdout0_26ck124 FIND v(dout0_26) AT=1250.05n

* CHECK dout0_27 Vdout0_27ck124 = 0 time = 1250
.meas tran vdout0_27ck124 FIND v(dout0_27) AT=1250.05n

* CHECK dout0_28 Vdout0_28ck124 = 0 time = 1250
.meas tran vdout0_28ck124 FIND v(dout0_28) AT=1250.05n

* CHECK dout0_29 Vdout0_29ck124 = 1.8 time = 1250
.meas tran vdout0_29ck124 FIND v(dout0_29) AT=1250.05n

* CHECK dout0_30 Vdout0_30ck124 = 1.8 time = 1250
.meas tran vdout0_30ck124 FIND v(dout0_30) AT=1250.05n

* CHECK dout0_31 Vdout0_31ck124 = 0 time = 1250
.meas tran vdout0_31ck124 FIND v(dout0_31) AT=1250.05n

* CHECK dout0_32 Vdout0_32ck124 = 1.8 time = 1250
.meas tran vdout0_32ck124 FIND v(dout0_32) AT=1250.05n

* CHECK dout0_33 Vdout0_33ck124 = 0 time = 1250
.meas tran vdout0_33ck124 FIND v(dout0_33) AT=1250.05n

* CHECK dout0_34 Vdout0_34ck124 = 0 time = 1250
.meas tran vdout0_34ck124 FIND v(dout0_34) AT=1250.05n

* CHECK dout0_35 Vdout0_35ck124 = 1.8 time = 1250
.meas tran vdout0_35ck124 FIND v(dout0_35) AT=1250.05n

* CHECK dout0_36 Vdout0_36ck124 = 0 time = 1250
.meas tran vdout0_36ck124 FIND v(dout0_36) AT=1250.05n

* CHECK dout0_37 Vdout0_37ck124 = 0 time = 1250
.meas tran vdout0_37ck124 FIND v(dout0_37) AT=1250.05n

* CHECK dout0_38 Vdout0_38ck124 = 0 time = 1250
.meas tran vdout0_38ck124 FIND v(dout0_38) AT=1250.05n

* CHECK dout0_39 Vdout0_39ck124 = 1.8 time = 1250
.meas tran vdout0_39ck124 FIND v(dout0_39) AT=1250.05n

* CHECK dout0_40 Vdout0_40ck124 = 0 time = 1250
.meas tran vdout0_40ck124 FIND v(dout0_40) AT=1250.05n

* CHECK dout0_41 Vdout0_41ck124 = 1.8 time = 1250
.meas tran vdout0_41ck124 FIND v(dout0_41) AT=1250.05n

* CHECK dout0_42 Vdout0_42ck124 = 0 time = 1250
.meas tran vdout0_42ck124 FIND v(dout0_42) AT=1250.05n

* CHECK dout0_43 Vdout0_43ck124 = 1.8 time = 1250
.meas tran vdout0_43ck124 FIND v(dout0_43) AT=1250.05n

* CHECK dout0_44 Vdout0_44ck124 = 1.8 time = 1250
.meas tran vdout0_44ck124 FIND v(dout0_44) AT=1250.05n

* CHECK dout0_45 Vdout0_45ck124 = 1.8 time = 1250
.meas tran vdout0_45ck124 FIND v(dout0_45) AT=1250.05n

* CHECK dout0_46 Vdout0_46ck124 = 0 time = 1250
.meas tran vdout0_46ck124 FIND v(dout0_46) AT=1250.05n

* CHECK dout0_47 Vdout0_47ck124 = 0 time = 1250
.meas tran vdout0_47ck124 FIND v(dout0_47) AT=1250.05n

* CHECK dout0_48 Vdout0_48ck124 = 1.8 time = 1250
.meas tran vdout0_48ck124 FIND v(dout0_48) AT=1250.05n

* CHECK dout0_49 Vdout0_49ck124 = 0 time = 1250
.meas tran vdout0_49ck124 FIND v(dout0_49) AT=1250.05n

* CHECK dout0_50 Vdout0_50ck124 = 1.8 time = 1250
.meas tran vdout0_50ck124 FIND v(dout0_50) AT=1250.05n

* CHECK dout0_51 Vdout0_51ck124 = 1.8 time = 1250
.meas tran vdout0_51ck124 FIND v(dout0_51) AT=1250.05n

* CHECK dout0_52 Vdout0_52ck124 = 0 time = 1250
.meas tran vdout0_52ck124 FIND v(dout0_52) AT=1250.05n

* CHECK dout0_53 Vdout0_53ck124 = 1.8 time = 1250
.meas tran vdout0_53ck124 FIND v(dout0_53) AT=1250.05n

* CHECK dout0_54 Vdout0_54ck124 = 1.8 time = 1250
.meas tran vdout0_54ck124 FIND v(dout0_54) AT=1250.05n

* CHECK dout0_55 Vdout0_55ck124 = 1.8 time = 1250
.meas tran vdout0_55ck124 FIND v(dout0_55) AT=1250.05n

* CHECK dout0_56 Vdout0_56ck124 = 0 time = 1250
.meas tran vdout0_56ck124 FIND v(dout0_56) AT=1250.05n

* CHECK dout0_57 Vdout0_57ck124 = 1.8 time = 1250
.meas tran vdout0_57ck124 FIND v(dout0_57) AT=1250.05n

* CHECK dout0_58 Vdout0_58ck124 = 0 time = 1250
.meas tran vdout0_58ck124 FIND v(dout0_58) AT=1250.05n

* CHECK dout0_59 Vdout0_59ck124 = 1.8 time = 1250
.meas tran vdout0_59ck124 FIND v(dout0_59) AT=1250.05n

* CHECK dout0_60 Vdout0_60ck124 = 1.8 time = 1250
.meas tran vdout0_60ck124 FIND v(dout0_60) AT=1250.05n

* CHECK dout0_61 Vdout0_61ck124 = 0 time = 1250
.meas tran vdout0_61ck124 FIND v(dout0_61) AT=1250.05n

* CHECK dout0_62 Vdout0_62ck124 = 1.8 time = 1250
.meas tran vdout0_62ck124 FIND v(dout0_62) AT=1250.05n

* CHECK dout0_63 Vdout0_63ck124 = 1.8 time = 1250
.meas tran vdout0_63ck124 FIND v(dout0_63) AT=1250.05n

* CHECK dout0_64 Vdout0_64ck124 = 0 time = 1250
.meas tran vdout0_64ck124 FIND v(dout0_64) AT=1250.05n

* CHECK dout0_0 Vdout0_0ck130 = 1.8 time = 1310
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=1310.05n

* CHECK dout0_1 Vdout0_1ck130 = 0 time = 1310
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=1310.05n

* CHECK dout0_2 Vdout0_2ck130 = 1.8 time = 1310
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=1310.05n

* CHECK dout0_3 Vdout0_3ck130 = 0 time = 1310
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=1310.05n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 1310
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=1310.05n

* CHECK dout0_5 Vdout0_5ck130 = 1.8 time = 1310
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=1310.05n

* CHECK dout0_6 Vdout0_6ck130 = 0 time = 1310
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=1310.05n

* CHECK dout0_7 Vdout0_7ck130 = 0 time = 1310
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=1310.05n

* CHECK dout0_8 Vdout0_8ck130 = 0 time = 1310
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=1310.05n

* CHECK dout0_9 Vdout0_9ck130 = 0 time = 1310
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=1310.05n

* CHECK dout0_10 Vdout0_10ck130 = 0 time = 1310
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=1310.05n

* CHECK dout0_11 Vdout0_11ck130 = 1.8 time = 1310
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=1310.05n

* CHECK dout0_12 Vdout0_12ck130 = 0 time = 1310
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=1310.05n

* CHECK dout0_13 Vdout0_13ck130 = 1.8 time = 1310
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=1310.05n

* CHECK dout0_14 Vdout0_14ck130 = 1.8 time = 1310
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=1310.05n

* CHECK dout0_15 Vdout0_15ck130 = 1.8 time = 1310
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=1310.05n

* CHECK dout0_16 Vdout0_16ck130 = 1.8 time = 1310
.meas tran vdout0_16ck130 FIND v(dout0_16) AT=1310.05n

* CHECK dout0_17 Vdout0_17ck130 = 1.8 time = 1310
.meas tran vdout0_17ck130 FIND v(dout0_17) AT=1310.05n

* CHECK dout0_18 Vdout0_18ck130 = 0 time = 1310
.meas tran vdout0_18ck130 FIND v(dout0_18) AT=1310.05n

* CHECK dout0_19 Vdout0_19ck130 = 1.8 time = 1310
.meas tran vdout0_19ck130 FIND v(dout0_19) AT=1310.05n

* CHECK dout0_20 Vdout0_20ck130 = 0 time = 1310
.meas tran vdout0_20ck130 FIND v(dout0_20) AT=1310.05n

* CHECK dout0_21 Vdout0_21ck130 = 1.8 time = 1310
.meas tran vdout0_21ck130 FIND v(dout0_21) AT=1310.05n

* CHECK dout0_22 Vdout0_22ck130 = 0 time = 1310
.meas tran vdout0_22ck130 FIND v(dout0_22) AT=1310.05n

* CHECK dout0_23 Vdout0_23ck130 = 0 time = 1310
.meas tran vdout0_23ck130 FIND v(dout0_23) AT=1310.05n

* CHECK dout0_24 Vdout0_24ck130 = 0 time = 1310
.meas tran vdout0_24ck130 FIND v(dout0_24) AT=1310.05n

* CHECK dout0_25 Vdout0_25ck130 = 1.8 time = 1310
.meas tran vdout0_25ck130 FIND v(dout0_25) AT=1310.05n

* CHECK dout0_26 Vdout0_26ck130 = 0 time = 1310
.meas tran vdout0_26ck130 FIND v(dout0_26) AT=1310.05n

* CHECK dout0_27 Vdout0_27ck130 = 0 time = 1310
.meas tran vdout0_27ck130 FIND v(dout0_27) AT=1310.05n

* CHECK dout0_28 Vdout0_28ck130 = 0 time = 1310
.meas tran vdout0_28ck130 FIND v(dout0_28) AT=1310.05n

* CHECK dout0_29 Vdout0_29ck130 = 1.8 time = 1310
.meas tran vdout0_29ck130 FIND v(dout0_29) AT=1310.05n

* CHECK dout0_30 Vdout0_30ck130 = 1.8 time = 1310
.meas tran vdout0_30ck130 FIND v(dout0_30) AT=1310.05n

* CHECK dout0_31 Vdout0_31ck130 = 0 time = 1310
.meas tran vdout0_31ck130 FIND v(dout0_31) AT=1310.05n

* CHECK dout0_32 Vdout0_32ck130 = 1.8 time = 1310
.meas tran vdout0_32ck130 FIND v(dout0_32) AT=1310.05n

* CHECK dout0_33 Vdout0_33ck130 = 0 time = 1310
.meas tran vdout0_33ck130 FIND v(dout0_33) AT=1310.05n

* CHECK dout0_34 Vdout0_34ck130 = 1.8 time = 1310
.meas tran vdout0_34ck130 FIND v(dout0_34) AT=1310.05n

* CHECK dout0_35 Vdout0_35ck130 = 1.8 time = 1310
.meas tran vdout0_35ck130 FIND v(dout0_35) AT=1310.05n

* CHECK dout0_36 Vdout0_36ck130 = 1.8 time = 1310
.meas tran vdout0_36ck130 FIND v(dout0_36) AT=1310.05n

* CHECK dout0_37 Vdout0_37ck130 = 0 time = 1310
.meas tran vdout0_37ck130 FIND v(dout0_37) AT=1310.05n

* CHECK dout0_38 Vdout0_38ck130 = 0 time = 1310
.meas tran vdout0_38ck130 FIND v(dout0_38) AT=1310.05n

* CHECK dout0_39 Vdout0_39ck130 = 1.8 time = 1310
.meas tran vdout0_39ck130 FIND v(dout0_39) AT=1310.05n

* CHECK dout0_40 Vdout0_40ck130 = 0 time = 1310
.meas tran vdout0_40ck130 FIND v(dout0_40) AT=1310.05n

* CHECK dout0_41 Vdout0_41ck130 = 0 time = 1310
.meas tran vdout0_41ck130 FIND v(dout0_41) AT=1310.05n

* CHECK dout0_42 Vdout0_42ck130 = 0 time = 1310
.meas tran vdout0_42ck130 FIND v(dout0_42) AT=1310.05n

* CHECK dout0_43 Vdout0_43ck130 = 0 time = 1310
.meas tran vdout0_43ck130 FIND v(dout0_43) AT=1310.05n

* CHECK dout0_44 Vdout0_44ck130 = 0 time = 1310
.meas tran vdout0_44ck130 FIND v(dout0_44) AT=1310.05n

* CHECK dout0_45 Vdout0_45ck130 = 1.8 time = 1310
.meas tran vdout0_45ck130 FIND v(dout0_45) AT=1310.05n

* CHECK dout0_46 Vdout0_46ck130 = 0 time = 1310
.meas tran vdout0_46ck130 FIND v(dout0_46) AT=1310.05n

* CHECK dout0_47 Vdout0_47ck130 = 1.8 time = 1310
.meas tran vdout0_47ck130 FIND v(dout0_47) AT=1310.05n

* CHECK dout0_48 Vdout0_48ck130 = 0 time = 1310
.meas tran vdout0_48ck130 FIND v(dout0_48) AT=1310.05n

* CHECK dout0_49 Vdout0_49ck130 = 0 time = 1310
.meas tran vdout0_49ck130 FIND v(dout0_49) AT=1310.05n

* CHECK dout0_50 Vdout0_50ck130 = 0 time = 1310
.meas tran vdout0_50ck130 FIND v(dout0_50) AT=1310.05n

* CHECK dout0_51 Vdout0_51ck130 = 0 time = 1310
.meas tran vdout0_51ck130 FIND v(dout0_51) AT=1310.05n

* CHECK dout0_52 Vdout0_52ck130 = 0 time = 1310
.meas tran vdout0_52ck130 FIND v(dout0_52) AT=1310.05n

* CHECK dout0_53 Vdout0_53ck130 = 1.8 time = 1310
.meas tran vdout0_53ck130 FIND v(dout0_53) AT=1310.05n

* CHECK dout0_54 Vdout0_54ck130 = 1.8 time = 1310
.meas tran vdout0_54ck130 FIND v(dout0_54) AT=1310.05n

* CHECK dout0_55 Vdout0_55ck130 = 0 time = 1310
.meas tran vdout0_55ck130 FIND v(dout0_55) AT=1310.05n

* CHECK dout0_56 Vdout0_56ck130 = 1.8 time = 1310
.meas tran vdout0_56ck130 FIND v(dout0_56) AT=1310.05n

* CHECK dout0_57 Vdout0_57ck130 = 0 time = 1310
.meas tran vdout0_57ck130 FIND v(dout0_57) AT=1310.05n

* CHECK dout0_58 Vdout0_58ck130 = 1.8 time = 1310
.meas tran vdout0_58ck130 FIND v(dout0_58) AT=1310.05n

* CHECK dout0_59 Vdout0_59ck130 = 0 time = 1310
.meas tran vdout0_59ck130 FIND v(dout0_59) AT=1310.05n

* CHECK dout0_60 Vdout0_60ck130 = 0 time = 1310
.meas tran vdout0_60ck130 FIND v(dout0_60) AT=1310.05n

* CHECK dout0_61 Vdout0_61ck130 = 0 time = 1310
.meas tran vdout0_61ck130 FIND v(dout0_61) AT=1310.05n

* CHECK dout0_62 Vdout0_62ck130 = 0 time = 1310
.meas tran vdout0_62ck130 FIND v(dout0_62) AT=1310.05n

* CHECK dout0_63 Vdout0_63ck130 = 0 time = 1310
.meas tran vdout0_63ck130 FIND v(dout0_63) AT=1310.05n

* CHECK dout0_64 Vdout0_64ck130 = 0 time = 1310
.meas tran vdout0_64ck130 FIND v(dout0_64) AT=1310.05n

* CHECK dout0_0 Vdout0_0ck131 = 1.8 time = 1320
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=1320.05n

* CHECK dout0_1 Vdout0_1ck131 = 0 time = 1320
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=1320.05n

* CHECK dout0_2 Vdout0_2ck131 = 1.8 time = 1320
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=1320.05n

* CHECK dout0_3 Vdout0_3ck131 = 0 time = 1320
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=1320.05n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 1320
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=1320.05n

* CHECK dout0_5 Vdout0_5ck131 = 1.8 time = 1320
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=1320.05n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 1320
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=1320.05n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 1320
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=1320.05n

* CHECK dout0_8 Vdout0_8ck131 = 0 time = 1320
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=1320.05n

* CHECK dout0_9 Vdout0_9ck131 = 0 time = 1320
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=1320.05n

* CHECK dout0_10 Vdout0_10ck131 = 0 time = 1320
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=1320.05n

* CHECK dout0_11 Vdout0_11ck131 = 1.8 time = 1320
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=1320.05n

* CHECK dout0_12 Vdout0_12ck131 = 0 time = 1320
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=1320.05n

* CHECK dout0_13 Vdout0_13ck131 = 1.8 time = 1320
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=1320.05n

* CHECK dout0_14 Vdout0_14ck131 = 1.8 time = 1320
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=1320.05n

* CHECK dout0_15 Vdout0_15ck131 = 1.8 time = 1320
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=1320.05n

* CHECK dout0_16 Vdout0_16ck131 = 1.8 time = 1320
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=1320.05n

* CHECK dout0_17 Vdout0_17ck131 = 1.8 time = 1320
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=1320.05n

* CHECK dout0_18 Vdout0_18ck131 = 0 time = 1320
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=1320.05n

* CHECK dout0_19 Vdout0_19ck131 = 1.8 time = 1320
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=1320.05n

* CHECK dout0_20 Vdout0_20ck131 = 0 time = 1320
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=1320.05n

* CHECK dout0_21 Vdout0_21ck131 = 1.8 time = 1320
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=1320.05n

* CHECK dout0_22 Vdout0_22ck131 = 0 time = 1320
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=1320.05n

* CHECK dout0_23 Vdout0_23ck131 = 0 time = 1320
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=1320.05n

* CHECK dout0_24 Vdout0_24ck131 = 0 time = 1320
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=1320.05n

* CHECK dout0_25 Vdout0_25ck131 = 1.8 time = 1320
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=1320.05n

* CHECK dout0_26 Vdout0_26ck131 = 0 time = 1320
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=1320.05n

* CHECK dout0_27 Vdout0_27ck131 = 0 time = 1320
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=1320.05n

* CHECK dout0_28 Vdout0_28ck131 = 0 time = 1320
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=1320.05n

* CHECK dout0_29 Vdout0_29ck131 = 1.8 time = 1320
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=1320.05n

* CHECK dout0_30 Vdout0_30ck131 = 1.8 time = 1320
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=1320.05n

* CHECK dout0_31 Vdout0_31ck131 = 0 time = 1320
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=1320.05n

* CHECK dout0_32 Vdout0_32ck131 = 1.8 time = 1320
.meas tran vdout0_32ck131 FIND v(dout0_32) AT=1320.05n

* CHECK dout0_33 Vdout0_33ck131 = 0 time = 1320
.meas tran vdout0_33ck131 FIND v(dout0_33) AT=1320.05n

* CHECK dout0_34 Vdout0_34ck131 = 1.8 time = 1320
.meas tran vdout0_34ck131 FIND v(dout0_34) AT=1320.05n

* CHECK dout0_35 Vdout0_35ck131 = 1.8 time = 1320
.meas tran vdout0_35ck131 FIND v(dout0_35) AT=1320.05n

* CHECK dout0_36 Vdout0_36ck131 = 1.8 time = 1320
.meas tran vdout0_36ck131 FIND v(dout0_36) AT=1320.05n

* CHECK dout0_37 Vdout0_37ck131 = 0 time = 1320
.meas tran vdout0_37ck131 FIND v(dout0_37) AT=1320.05n

* CHECK dout0_38 Vdout0_38ck131 = 0 time = 1320
.meas tran vdout0_38ck131 FIND v(dout0_38) AT=1320.05n

* CHECK dout0_39 Vdout0_39ck131 = 1.8 time = 1320
.meas tran vdout0_39ck131 FIND v(dout0_39) AT=1320.05n

* CHECK dout0_40 Vdout0_40ck131 = 0 time = 1320
.meas tran vdout0_40ck131 FIND v(dout0_40) AT=1320.05n

* CHECK dout0_41 Vdout0_41ck131 = 0 time = 1320
.meas tran vdout0_41ck131 FIND v(dout0_41) AT=1320.05n

* CHECK dout0_42 Vdout0_42ck131 = 0 time = 1320
.meas tran vdout0_42ck131 FIND v(dout0_42) AT=1320.05n

* CHECK dout0_43 Vdout0_43ck131 = 0 time = 1320
.meas tran vdout0_43ck131 FIND v(dout0_43) AT=1320.05n

* CHECK dout0_44 Vdout0_44ck131 = 0 time = 1320
.meas tran vdout0_44ck131 FIND v(dout0_44) AT=1320.05n

* CHECK dout0_45 Vdout0_45ck131 = 1.8 time = 1320
.meas tran vdout0_45ck131 FIND v(dout0_45) AT=1320.05n

* CHECK dout0_46 Vdout0_46ck131 = 0 time = 1320
.meas tran vdout0_46ck131 FIND v(dout0_46) AT=1320.05n

* CHECK dout0_47 Vdout0_47ck131 = 1.8 time = 1320
.meas tran vdout0_47ck131 FIND v(dout0_47) AT=1320.05n

* CHECK dout0_48 Vdout0_48ck131 = 0 time = 1320
.meas tran vdout0_48ck131 FIND v(dout0_48) AT=1320.05n

* CHECK dout0_49 Vdout0_49ck131 = 0 time = 1320
.meas tran vdout0_49ck131 FIND v(dout0_49) AT=1320.05n

* CHECK dout0_50 Vdout0_50ck131 = 0 time = 1320
.meas tran vdout0_50ck131 FIND v(dout0_50) AT=1320.05n

* CHECK dout0_51 Vdout0_51ck131 = 0 time = 1320
.meas tran vdout0_51ck131 FIND v(dout0_51) AT=1320.05n

* CHECK dout0_52 Vdout0_52ck131 = 0 time = 1320
.meas tran vdout0_52ck131 FIND v(dout0_52) AT=1320.05n

* CHECK dout0_53 Vdout0_53ck131 = 1.8 time = 1320
.meas tran vdout0_53ck131 FIND v(dout0_53) AT=1320.05n

* CHECK dout0_54 Vdout0_54ck131 = 1.8 time = 1320
.meas tran vdout0_54ck131 FIND v(dout0_54) AT=1320.05n

* CHECK dout0_55 Vdout0_55ck131 = 0 time = 1320
.meas tran vdout0_55ck131 FIND v(dout0_55) AT=1320.05n

* CHECK dout0_56 Vdout0_56ck131 = 1.8 time = 1320
.meas tran vdout0_56ck131 FIND v(dout0_56) AT=1320.05n

* CHECK dout0_57 Vdout0_57ck131 = 0 time = 1320
.meas tran vdout0_57ck131 FIND v(dout0_57) AT=1320.05n

* CHECK dout0_58 Vdout0_58ck131 = 1.8 time = 1320
.meas tran vdout0_58ck131 FIND v(dout0_58) AT=1320.05n

* CHECK dout0_59 Vdout0_59ck131 = 0 time = 1320
.meas tran vdout0_59ck131 FIND v(dout0_59) AT=1320.05n

* CHECK dout0_60 Vdout0_60ck131 = 0 time = 1320
.meas tran vdout0_60ck131 FIND v(dout0_60) AT=1320.05n

* CHECK dout0_61 Vdout0_61ck131 = 0 time = 1320
.meas tran vdout0_61ck131 FIND v(dout0_61) AT=1320.05n

* CHECK dout0_62 Vdout0_62ck131 = 0 time = 1320
.meas tran vdout0_62ck131 FIND v(dout0_62) AT=1320.05n

* CHECK dout0_63 Vdout0_63ck131 = 0 time = 1320
.meas tran vdout0_63ck131 FIND v(dout0_63) AT=1320.05n

* CHECK dout0_64 Vdout0_64ck131 = 0 time = 1320
.meas tran vdout0_64ck131 FIND v(dout0_64) AT=1320.05n

* CHECK dout0_0 Vdout0_0ck132 = 1.8 time = 1330
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=1330.05n

* CHECK dout0_1 Vdout0_1ck132 = 0 time = 1330
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=1330.05n

* CHECK dout0_2 Vdout0_2ck132 = 1.8 time = 1330
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=1330.05n

* CHECK dout0_3 Vdout0_3ck132 = 0 time = 1330
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=1330.05n

* CHECK dout0_4 Vdout0_4ck132 = 0 time = 1330
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=1330.05n

* CHECK dout0_5 Vdout0_5ck132 = 0 time = 1330
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=1330.05n

* CHECK dout0_6 Vdout0_6ck132 = 0 time = 1330
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=1330.05n

* CHECK dout0_7 Vdout0_7ck132 = 1.8 time = 1330
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=1330.05n

* CHECK dout0_8 Vdout0_8ck132 = 1.8 time = 1330
.meas tran vdout0_8ck132 FIND v(dout0_8) AT=1330.05n

* CHECK dout0_9 Vdout0_9ck132 = 0 time = 1330
.meas tran vdout0_9ck132 FIND v(dout0_9) AT=1330.05n

* CHECK dout0_10 Vdout0_10ck132 = 0 time = 1330
.meas tran vdout0_10ck132 FIND v(dout0_10) AT=1330.05n

* CHECK dout0_11 Vdout0_11ck132 = 0 time = 1330
.meas tran vdout0_11ck132 FIND v(dout0_11) AT=1330.05n

* CHECK dout0_12 Vdout0_12ck132 = 1.8 time = 1330
.meas tran vdout0_12ck132 FIND v(dout0_12) AT=1330.05n

* CHECK dout0_13 Vdout0_13ck132 = 1.8 time = 1330
.meas tran vdout0_13ck132 FIND v(dout0_13) AT=1330.05n

* CHECK dout0_14 Vdout0_14ck132 = 1.8 time = 1330
.meas tran vdout0_14ck132 FIND v(dout0_14) AT=1330.05n

* CHECK dout0_15 Vdout0_15ck132 = 0 time = 1330
.meas tran vdout0_15ck132 FIND v(dout0_15) AT=1330.05n

* CHECK dout0_16 Vdout0_16ck132 = 1.8 time = 1330
.meas tran vdout0_16ck132 FIND v(dout0_16) AT=1330.05n

* CHECK dout0_17 Vdout0_17ck132 = 0 time = 1330
.meas tran vdout0_17ck132 FIND v(dout0_17) AT=1330.05n

* CHECK dout0_18 Vdout0_18ck132 = 0 time = 1330
.meas tran vdout0_18ck132 FIND v(dout0_18) AT=1330.05n

* CHECK dout0_19 Vdout0_19ck132 = 0 time = 1330
.meas tran vdout0_19ck132 FIND v(dout0_19) AT=1330.05n

* CHECK dout0_20 Vdout0_20ck132 = 1.8 time = 1330
.meas tran vdout0_20ck132 FIND v(dout0_20) AT=1330.05n

* CHECK dout0_21 Vdout0_21ck132 = 0 time = 1330
.meas tran vdout0_21ck132 FIND v(dout0_21) AT=1330.05n

* CHECK dout0_22 Vdout0_22ck132 = 1.8 time = 1330
.meas tran vdout0_22ck132 FIND v(dout0_22) AT=1330.05n

* CHECK dout0_23 Vdout0_23ck132 = 1.8 time = 1330
.meas tran vdout0_23ck132 FIND v(dout0_23) AT=1330.05n

* CHECK dout0_24 Vdout0_24ck132 = 0 time = 1330
.meas tran vdout0_24ck132 FIND v(dout0_24) AT=1330.05n

* CHECK dout0_25 Vdout0_25ck132 = 1.8 time = 1330
.meas tran vdout0_25ck132 FIND v(dout0_25) AT=1330.05n

* CHECK dout0_26 Vdout0_26ck132 = 1.8 time = 1330
.meas tran vdout0_26ck132 FIND v(dout0_26) AT=1330.05n

* CHECK dout0_27 Vdout0_27ck132 = 0 time = 1330
.meas tran vdout0_27ck132 FIND v(dout0_27) AT=1330.05n

* CHECK dout0_28 Vdout0_28ck132 = 0 time = 1330
.meas tran vdout0_28ck132 FIND v(dout0_28) AT=1330.05n

* CHECK dout0_29 Vdout0_29ck132 = 1.8 time = 1330
.meas tran vdout0_29ck132 FIND v(dout0_29) AT=1330.05n

* CHECK dout0_30 Vdout0_30ck132 = 0 time = 1330
.meas tran vdout0_30ck132 FIND v(dout0_30) AT=1330.05n

* CHECK dout0_31 Vdout0_31ck132 = 1.8 time = 1330
.meas tran vdout0_31ck132 FIND v(dout0_31) AT=1330.05n

* CHECK dout0_32 Vdout0_32ck132 = 0 time = 1330
.meas tran vdout0_32ck132 FIND v(dout0_32) AT=1330.05n

* CHECK dout0_33 Vdout0_33ck132 = 0 time = 1330
.meas tran vdout0_33ck132 FIND v(dout0_33) AT=1330.05n

* CHECK dout0_34 Vdout0_34ck132 = 0 time = 1330
.meas tran vdout0_34ck132 FIND v(dout0_34) AT=1330.05n

* CHECK dout0_35 Vdout0_35ck132 = 1.8 time = 1330
.meas tran vdout0_35ck132 FIND v(dout0_35) AT=1330.05n

* CHECK dout0_36 Vdout0_36ck132 = 0 time = 1330
.meas tran vdout0_36ck132 FIND v(dout0_36) AT=1330.05n

* CHECK dout0_37 Vdout0_37ck132 = 0 time = 1330
.meas tran vdout0_37ck132 FIND v(dout0_37) AT=1330.05n

* CHECK dout0_38 Vdout0_38ck132 = 0 time = 1330
.meas tran vdout0_38ck132 FIND v(dout0_38) AT=1330.05n

* CHECK dout0_39 Vdout0_39ck132 = 0 time = 1330
.meas tran vdout0_39ck132 FIND v(dout0_39) AT=1330.05n

* CHECK dout0_40 Vdout0_40ck132 = 0 time = 1330
.meas tran vdout0_40ck132 FIND v(dout0_40) AT=1330.05n

* CHECK dout0_41 Vdout0_41ck132 = 1.8 time = 1330
.meas tran vdout0_41ck132 FIND v(dout0_41) AT=1330.05n

* CHECK dout0_42 Vdout0_42ck132 = 1.8 time = 1330
.meas tran vdout0_42ck132 FIND v(dout0_42) AT=1330.05n

* CHECK dout0_43 Vdout0_43ck132 = 0 time = 1330
.meas tran vdout0_43ck132 FIND v(dout0_43) AT=1330.05n

* CHECK dout0_44 Vdout0_44ck132 = 0 time = 1330
.meas tran vdout0_44ck132 FIND v(dout0_44) AT=1330.05n

* CHECK dout0_45 Vdout0_45ck132 = 1.8 time = 1330
.meas tran vdout0_45ck132 FIND v(dout0_45) AT=1330.05n

* CHECK dout0_46 Vdout0_46ck132 = 1.8 time = 1330
.meas tran vdout0_46ck132 FIND v(dout0_46) AT=1330.05n

* CHECK dout0_47 Vdout0_47ck132 = 0 time = 1330
.meas tran vdout0_47ck132 FIND v(dout0_47) AT=1330.05n

* CHECK dout0_48 Vdout0_48ck132 = 1.8 time = 1330
.meas tran vdout0_48ck132 FIND v(dout0_48) AT=1330.05n

* CHECK dout0_49 Vdout0_49ck132 = 1.8 time = 1330
.meas tran vdout0_49ck132 FIND v(dout0_49) AT=1330.05n

* CHECK dout0_50 Vdout0_50ck132 = 0 time = 1330
.meas tran vdout0_50ck132 FIND v(dout0_50) AT=1330.05n

* CHECK dout0_51 Vdout0_51ck132 = 0 time = 1330
.meas tran vdout0_51ck132 FIND v(dout0_51) AT=1330.05n

* CHECK dout0_52 Vdout0_52ck132 = 0 time = 1330
.meas tran vdout0_52ck132 FIND v(dout0_52) AT=1330.05n

* CHECK dout0_53 Vdout0_53ck132 = 1.8 time = 1330
.meas tran vdout0_53ck132 FIND v(dout0_53) AT=1330.05n

* CHECK dout0_54 Vdout0_54ck132 = 0 time = 1330
.meas tran vdout0_54ck132 FIND v(dout0_54) AT=1330.05n

* CHECK dout0_55 Vdout0_55ck132 = 0 time = 1330
.meas tran vdout0_55ck132 FIND v(dout0_55) AT=1330.05n

* CHECK dout0_56 Vdout0_56ck132 = 1.8 time = 1330
.meas tran vdout0_56ck132 FIND v(dout0_56) AT=1330.05n

* CHECK dout0_57 Vdout0_57ck132 = 0 time = 1330
.meas tran vdout0_57ck132 FIND v(dout0_57) AT=1330.05n

* CHECK dout0_58 Vdout0_58ck132 = 0 time = 1330
.meas tran vdout0_58ck132 FIND v(dout0_58) AT=1330.05n

* CHECK dout0_59 Vdout0_59ck132 = 0 time = 1330
.meas tran vdout0_59ck132 FIND v(dout0_59) AT=1330.05n

* CHECK dout0_60 Vdout0_60ck132 = 0 time = 1330
.meas tran vdout0_60ck132 FIND v(dout0_60) AT=1330.05n

* CHECK dout0_61 Vdout0_61ck132 = 1.8 time = 1330
.meas tran vdout0_61ck132 FIND v(dout0_61) AT=1330.05n

* CHECK dout0_62 Vdout0_62ck132 = 1.8 time = 1330
.meas tran vdout0_62ck132 FIND v(dout0_62) AT=1330.05n

* CHECK dout0_63 Vdout0_63ck132 = 1.8 time = 1330
.meas tran vdout0_63ck132 FIND v(dout0_63) AT=1330.05n

* CHECK dout0_64 Vdout0_64ck132 = 0 time = 1330
.meas tran vdout0_64ck132 FIND v(dout0_64) AT=1330.05n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 1370
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=1370.05n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 1370
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=1370.05n

* CHECK dout0_2 Vdout0_2ck136 = 1.8 time = 1370
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=1370.05n

* CHECK dout0_3 Vdout0_3ck136 = 0 time = 1370
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=1370.05n

* CHECK dout0_4 Vdout0_4ck136 = 1.8 time = 1370
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=1370.05n

* CHECK dout0_5 Vdout0_5ck136 = 0 time = 1370
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=1370.05n

* CHECK dout0_6 Vdout0_6ck136 = 0 time = 1370
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=1370.05n

* CHECK dout0_7 Vdout0_7ck136 = 1.8 time = 1370
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=1370.05n

* CHECK dout0_8 Vdout0_8ck136 = 1.8 time = 1370
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=1370.05n

* CHECK dout0_9 Vdout0_9ck136 = 0 time = 1370
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=1370.05n

* CHECK dout0_10 Vdout0_10ck136 = 0 time = 1370
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=1370.05n

* CHECK dout0_11 Vdout0_11ck136 = 0 time = 1370
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=1370.05n

* CHECK dout0_12 Vdout0_12ck136 = 1.8 time = 1370
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=1370.05n

* CHECK dout0_13 Vdout0_13ck136 = 1.8 time = 1370
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=1370.05n

* CHECK dout0_14 Vdout0_14ck136 = 1.8 time = 1370
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=1370.05n

* CHECK dout0_15 Vdout0_15ck136 = 0 time = 1370
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=1370.05n

* CHECK dout0_16 Vdout0_16ck136 = 1.8 time = 1370
.meas tran vdout0_16ck136 FIND v(dout0_16) AT=1370.05n

* CHECK dout0_17 Vdout0_17ck136 = 0 time = 1370
.meas tran vdout0_17ck136 FIND v(dout0_17) AT=1370.05n

* CHECK dout0_18 Vdout0_18ck136 = 0 time = 1370
.meas tran vdout0_18ck136 FIND v(dout0_18) AT=1370.05n

* CHECK dout0_19 Vdout0_19ck136 = 0 time = 1370
.meas tran vdout0_19ck136 FIND v(dout0_19) AT=1370.05n

* CHECK dout0_20 Vdout0_20ck136 = 1.8 time = 1370
.meas tran vdout0_20ck136 FIND v(dout0_20) AT=1370.05n

* CHECK dout0_21 Vdout0_21ck136 = 0 time = 1370
.meas tran vdout0_21ck136 FIND v(dout0_21) AT=1370.05n

* CHECK dout0_22 Vdout0_22ck136 = 1.8 time = 1370
.meas tran vdout0_22ck136 FIND v(dout0_22) AT=1370.05n

* CHECK dout0_23 Vdout0_23ck136 = 1.8 time = 1370
.meas tran vdout0_23ck136 FIND v(dout0_23) AT=1370.05n

* CHECK dout0_24 Vdout0_24ck136 = 0 time = 1370
.meas tran vdout0_24ck136 FIND v(dout0_24) AT=1370.05n

* CHECK dout0_25 Vdout0_25ck136 = 1.8 time = 1370
.meas tran vdout0_25ck136 FIND v(dout0_25) AT=1370.05n

* CHECK dout0_26 Vdout0_26ck136 = 1.8 time = 1370
.meas tran vdout0_26ck136 FIND v(dout0_26) AT=1370.05n

* CHECK dout0_27 Vdout0_27ck136 = 0 time = 1370
.meas tran vdout0_27ck136 FIND v(dout0_27) AT=1370.05n

* CHECK dout0_28 Vdout0_28ck136 = 0 time = 1370
.meas tran vdout0_28ck136 FIND v(dout0_28) AT=1370.05n

* CHECK dout0_29 Vdout0_29ck136 = 1.8 time = 1370
.meas tran vdout0_29ck136 FIND v(dout0_29) AT=1370.05n

* CHECK dout0_30 Vdout0_30ck136 = 0 time = 1370
.meas tran vdout0_30ck136 FIND v(dout0_30) AT=1370.05n

* CHECK dout0_31 Vdout0_31ck136 = 1.8 time = 1370
.meas tran vdout0_31ck136 FIND v(dout0_31) AT=1370.05n

* CHECK dout0_32 Vdout0_32ck136 = 0 time = 1370
.meas tran vdout0_32ck136 FIND v(dout0_32) AT=1370.05n

* CHECK dout0_33 Vdout0_33ck136 = 1.8 time = 1370
.meas tran vdout0_33ck136 FIND v(dout0_33) AT=1370.05n

* CHECK dout0_34 Vdout0_34ck136 = 0 time = 1370
.meas tran vdout0_34ck136 FIND v(dout0_34) AT=1370.05n

* CHECK dout0_35 Vdout0_35ck136 = 0 time = 1370
.meas tran vdout0_35ck136 FIND v(dout0_35) AT=1370.05n

* CHECK dout0_36 Vdout0_36ck136 = 1.8 time = 1370
.meas tran vdout0_36ck136 FIND v(dout0_36) AT=1370.05n

* CHECK dout0_37 Vdout0_37ck136 = 1.8 time = 1370
.meas tran vdout0_37ck136 FIND v(dout0_37) AT=1370.05n

* CHECK dout0_38 Vdout0_38ck136 = 1.8 time = 1370
.meas tran vdout0_38ck136 FIND v(dout0_38) AT=1370.05n

* CHECK dout0_39 Vdout0_39ck136 = 1.8 time = 1370
.meas tran vdout0_39ck136 FIND v(dout0_39) AT=1370.05n

* CHECK dout0_40 Vdout0_40ck136 = 0 time = 1370
.meas tran vdout0_40ck136 FIND v(dout0_40) AT=1370.05n

* CHECK dout0_41 Vdout0_41ck136 = 1.8 time = 1370
.meas tran vdout0_41ck136 FIND v(dout0_41) AT=1370.05n

* CHECK dout0_42 Vdout0_42ck136 = 1.8 time = 1370
.meas tran vdout0_42ck136 FIND v(dout0_42) AT=1370.05n

* CHECK dout0_43 Vdout0_43ck136 = 1.8 time = 1370
.meas tran vdout0_43ck136 FIND v(dout0_43) AT=1370.05n

* CHECK dout0_44 Vdout0_44ck136 = 0 time = 1370
.meas tran vdout0_44ck136 FIND v(dout0_44) AT=1370.05n

* CHECK dout0_45 Vdout0_45ck136 = 0 time = 1370
.meas tran vdout0_45ck136 FIND v(dout0_45) AT=1370.05n

* CHECK dout0_46 Vdout0_46ck136 = 1.8 time = 1370
.meas tran vdout0_46ck136 FIND v(dout0_46) AT=1370.05n

* CHECK dout0_47 Vdout0_47ck136 = 1.8 time = 1370
.meas tran vdout0_47ck136 FIND v(dout0_47) AT=1370.05n

* CHECK dout0_48 Vdout0_48ck136 = 0 time = 1370
.meas tran vdout0_48ck136 FIND v(dout0_48) AT=1370.05n

* CHECK dout0_49 Vdout0_49ck136 = 0 time = 1370
.meas tran vdout0_49ck136 FIND v(dout0_49) AT=1370.05n

* CHECK dout0_50 Vdout0_50ck136 = 0 time = 1370
.meas tran vdout0_50ck136 FIND v(dout0_50) AT=1370.05n

* CHECK dout0_51 Vdout0_51ck136 = 0 time = 1370
.meas tran vdout0_51ck136 FIND v(dout0_51) AT=1370.05n

* CHECK dout0_52 Vdout0_52ck136 = 1.8 time = 1370
.meas tran vdout0_52ck136 FIND v(dout0_52) AT=1370.05n

* CHECK dout0_53 Vdout0_53ck136 = 1.8 time = 1370
.meas tran vdout0_53ck136 FIND v(dout0_53) AT=1370.05n

* CHECK dout0_54 Vdout0_54ck136 = 1.8 time = 1370
.meas tran vdout0_54ck136 FIND v(dout0_54) AT=1370.05n

* CHECK dout0_55 Vdout0_55ck136 = 1.8 time = 1370
.meas tran vdout0_55ck136 FIND v(dout0_55) AT=1370.05n

* CHECK dout0_56 Vdout0_56ck136 = 1.8 time = 1370
.meas tran vdout0_56ck136 FIND v(dout0_56) AT=1370.05n

* CHECK dout0_57 Vdout0_57ck136 = 0 time = 1370
.meas tran vdout0_57ck136 FIND v(dout0_57) AT=1370.05n

* CHECK dout0_58 Vdout0_58ck136 = 1.8 time = 1370
.meas tran vdout0_58ck136 FIND v(dout0_58) AT=1370.05n

* CHECK dout0_59 Vdout0_59ck136 = 1.8 time = 1370
.meas tran vdout0_59ck136 FIND v(dout0_59) AT=1370.05n

* CHECK dout0_60 Vdout0_60ck136 = 1.8 time = 1370
.meas tran vdout0_60ck136 FIND v(dout0_60) AT=1370.05n

* CHECK dout0_61 Vdout0_61ck136 = 0 time = 1370
.meas tran vdout0_61ck136 FIND v(dout0_61) AT=1370.05n

* CHECK dout0_62 Vdout0_62ck136 = 1.8 time = 1370
.meas tran vdout0_62ck136 FIND v(dout0_62) AT=1370.05n

* CHECK dout0_63 Vdout0_63ck136 = 1.8 time = 1370
.meas tran vdout0_63ck136 FIND v(dout0_63) AT=1370.05n

* CHECK dout0_64 Vdout0_64ck136 = 0 time = 1370
.meas tran vdout0_64ck136 FIND v(dout0_64) AT=1370.05n

* CHECK dout0_0 Vdout0_0ck139 = 1.8 time = 1400
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=1400.05n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 1400
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=1400.05n

* CHECK dout0_2 Vdout0_2ck139 = 1.8 time = 1400
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=1400.05n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 1400
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=1400.05n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 1400
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=1400.05n

* CHECK dout0_5 Vdout0_5ck139 = 1.8 time = 1400
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=1400.05n

* CHECK dout0_6 Vdout0_6ck139 = 0 time = 1400
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=1400.05n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 1400
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=1400.05n

* CHECK dout0_8 Vdout0_8ck139 = 1.8 time = 1400
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=1400.05n

* CHECK dout0_9 Vdout0_9ck139 = 0 time = 1400
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=1400.05n

* CHECK dout0_10 Vdout0_10ck139 = 0 time = 1400
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=1400.05n

* CHECK dout0_11 Vdout0_11ck139 = 0 time = 1400
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=1400.05n

* CHECK dout0_12 Vdout0_12ck139 = 1.8 time = 1400
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=1400.05n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 1400
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=1400.05n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 1400
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=1400.05n

* CHECK dout0_15 Vdout0_15ck139 = 0 time = 1400
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=1400.05n

* CHECK dout0_16 Vdout0_16ck139 = 1.8 time = 1400
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=1400.05n

* CHECK dout0_17 Vdout0_17ck139 = 0 time = 1400
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=1400.05n

* CHECK dout0_18 Vdout0_18ck139 = 1.8 time = 1400
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=1400.05n

* CHECK dout0_19 Vdout0_19ck139 = 1.8 time = 1400
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=1400.05n

* CHECK dout0_20 Vdout0_20ck139 = 1.8 time = 1400
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=1400.05n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 1400
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=1400.05n

* CHECK dout0_22 Vdout0_22ck139 = 1.8 time = 1400
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=1400.05n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 1400
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=1400.05n

* CHECK dout0_24 Vdout0_24ck139 = 0 time = 1400
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=1400.05n

* CHECK dout0_25 Vdout0_25ck139 = 1.8 time = 1400
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=1400.05n

* CHECK dout0_26 Vdout0_26ck139 = 0 time = 1400
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=1400.05n

* CHECK dout0_27 Vdout0_27ck139 = 0 time = 1400
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=1400.05n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 1400
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=1400.05n

* CHECK dout0_29 Vdout0_29ck139 = 1.8 time = 1400
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=1400.05n

* CHECK dout0_30 Vdout0_30ck139 = 1.8 time = 1400
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=1400.05n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 1400
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=1400.05n

* CHECK dout0_32 Vdout0_32ck139 = 1.8 time = 1400
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=1400.05n

* CHECK dout0_33 Vdout0_33ck139 = 0 time = 1400
.meas tran vdout0_33ck139 FIND v(dout0_33) AT=1400.05n

* CHECK dout0_34 Vdout0_34ck139 = 1.8 time = 1400
.meas tran vdout0_34ck139 FIND v(dout0_34) AT=1400.05n

* CHECK dout0_35 Vdout0_35ck139 = 1.8 time = 1400
.meas tran vdout0_35ck139 FIND v(dout0_35) AT=1400.05n

* CHECK dout0_36 Vdout0_36ck139 = 1.8 time = 1400
.meas tran vdout0_36ck139 FIND v(dout0_36) AT=1400.05n

* CHECK dout0_37 Vdout0_37ck139 = 0 time = 1400
.meas tran vdout0_37ck139 FIND v(dout0_37) AT=1400.05n

* CHECK dout0_38 Vdout0_38ck139 = 0 time = 1400
.meas tran vdout0_38ck139 FIND v(dout0_38) AT=1400.05n

* CHECK dout0_39 Vdout0_39ck139 = 1.8 time = 1400
.meas tran vdout0_39ck139 FIND v(dout0_39) AT=1400.05n

* CHECK dout0_40 Vdout0_40ck139 = 0 time = 1400
.meas tran vdout0_40ck139 FIND v(dout0_40) AT=1400.05n

* CHECK dout0_41 Vdout0_41ck139 = 0 time = 1400
.meas tran vdout0_41ck139 FIND v(dout0_41) AT=1400.05n

* CHECK dout0_42 Vdout0_42ck139 = 0 time = 1400
.meas tran vdout0_42ck139 FIND v(dout0_42) AT=1400.05n

* CHECK dout0_43 Vdout0_43ck139 = 0 time = 1400
.meas tran vdout0_43ck139 FIND v(dout0_43) AT=1400.05n

* CHECK dout0_44 Vdout0_44ck139 = 0 time = 1400
.meas tran vdout0_44ck139 FIND v(dout0_44) AT=1400.05n

* CHECK dout0_45 Vdout0_45ck139 = 1.8 time = 1400
.meas tran vdout0_45ck139 FIND v(dout0_45) AT=1400.05n

* CHECK dout0_46 Vdout0_46ck139 = 0 time = 1400
.meas tran vdout0_46ck139 FIND v(dout0_46) AT=1400.05n

* CHECK dout0_47 Vdout0_47ck139 = 1.8 time = 1400
.meas tran vdout0_47ck139 FIND v(dout0_47) AT=1400.05n

* CHECK dout0_48 Vdout0_48ck139 = 0 time = 1400
.meas tran vdout0_48ck139 FIND v(dout0_48) AT=1400.05n

* CHECK dout0_49 Vdout0_49ck139 = 0 time = 1400
.meas tran vdout0_49ck139 FIND v(dout0_49) AT=1400.05n

* CHECK dout0_50 Vdout0_50ck139 = 0 time = 1400
.meas tran vdout0_50ck139 FIND v(dout0_50) AT=1400.05n

* CHECK dout0_51 Vdout0_51ck139 = 0 time = 1400
.meas tran vdout0_51ck139 FIND v(dout0_51) AT=1400.05n

* CHECK dout0_52 Vdout0_52ck139 = 0 time = 1400
.meas tran vdout0_52ck139 FIND v(dout0_52) AT=1400.05n

* CHECK dout0_53 Vdout0_53ck139 = 1.8 time = 1400
.meas tran vdout0_53ck139 FIND v(dout0_53) AT=1400.05n

* CHECK dout0_54 Vdout0_54ck139 = 1.8 time = 1400
.meas tran vdout0_54ck139 FIND v(dout0_54) AT=1400.05n

* CHECK dout0_55 Vdout0_55ck139 = 0 time = 1400
.meas tran vdout0_55ck139 FIND v(dout0_55) AT=1400.05n

* CHECK dout0_56 Vdout0_56ck139 = 1.8 time = 1400
.meas tran vdout0_56ck139 FIND v(dout0_56) AT=1400.05n

* CHECK dout0_57 Vdout0_57ck139 = 0 time = 1400
.meas tran vdout0_57ck139 FIND v(dout0_57) AT=1400.05n

* CHECK dout0_58 Vdout0_58ck139 = 1.8 time = 1400
.meas tran vdout0_58ck139 FIND v(dout0_58) AT=1400.05n

* CHECK dout0_59 Vdout0_59ck139 = 0 time = 1400
.meas tran vdout0_59ck139 FIND v(dout0_59) AT=1400.05n

* CHECK dout0_60 Vdout0_60ck139 = 0 time = 1400
.meas tran vdout0_60ck139 FIND v(dout0_60) AT=1400.05n

* CHECK dout0_61 Vdout0_61ck139 = 0 time = 1400
.meas tran vdout0_61ck139 FIND v(dout0_61) AT=1400.05n

* CHECK dout0_62 Vdout0_62ck139 = 0 time = 1400
.meas tran vdout0_62ck139 FIND v(dout0_62) AT=1400.05n

* CHECK dout0_63 Vdout0_63ck139 = 0 time = 1400
.meas tran vdout0_63ck139 FIND v(dout0_63) AT=1400.05n

* CHECK dout0_64 Vdout0_64ck139 = 0 time = 1400
.meas tran vdout0_64ck139 FIND v(dout0_64) AT=1400.05n

* CHECK dout0_0 Vdout0_0ck142 = 0 time = 1430
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=1430.05n

* CHECK dout0_1 Vdout0_1ck142 = 0 time = 1430
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=1430.05n

* CHECK dout0_2 Vdout0_2ck142 = 1.8 time = 1430
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=1430.05n

* CHECK dout0_3 Vdout0_3ck142 = 1.8 time = 1430
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=1430.05n

* CHECK dout0_4 Vdout0_4ck142 = 1.8 time = 1430
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=1430.05n

* CHECK dout0_5 Vdout0_5ck142 = 1.8 time = 1430
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=1430.05n

* CHECK dout0_6 Vdout0_6ck142 = 1.8 time = 1430
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=1430.05n

* CHECK dout0_7 Vdout0_7ck142 = 0 time = 1430
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=1430.05n

* CHECK dout0_8 Vdout0_8ck142 = 1.8 time = 1430
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=1430.05n

* CHECK dout0_9 Vdout0_9ck142 = 1.8 time = 1430
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=1430.05n

* CHECK dout0_10 Vdout0_10ck142 = 1.8 time = 1430
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=1430.05n

* CHECK dout0_11 Vdout0_11ck142 = 1.8 time = 1430
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=1430.05n

* CHECK dout0_12 Vdout0_12ck142 = 1.8 time = 1430
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=1430.05n

* CHECK dout0_13 Vdout0_13ck142 = 0 time = 1430
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=1430.05n

* CHECK dout0_14 Vdout0_14ck142 = 0 time = 1430
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=1430.05n

* CHECK dout0_15 Vdout0_15ck142 = 1.8 time = 1430
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=1430.05n

* CHECK dout0_16 Vdout0_16ck142 = 0 time = 1430
.meas tran vdout0_16ck142 FIND v(dout0_16) AT=1430.05n

* CHECK dout0_17 Vdout0_17ck142 = 0 time = 1430
.meas tran vdout0_17ck142 FIND v(dout0_17) AT=1430.05n

* CHECK dout0_18 Vdout0_18ck142 = 0 time = 1430
.meas tran vdout0_18ck142 FIND v(dout0_18) AT=1430.05n

* CHECK dout0_19 Vdout0_19ck142 = 0 time = 1430
.meas tran vdout0_19ck142 FIND v(dout0_19) AT=1430.05n

* CHECK dout0_20 Vdout0_20ck142 = 1.8 time = 1430
.meas tran vdout0_20ck142 FIND v(dout0_20) AT=1430.05n

* CHECK dout0_21 Vdout0_21ck142 = 1.8 time = 1430
.meas tran vdout0_21ck142 FIND v(dout0_21) AT=1430.05n

* CHECK dout0_22 Vdout0_22ck142 = 1.8 time = 1430
.meas tran vdout0_22ck142 FIND v(dout0_22) AT=1430.05n

* CHECK dout0_23 Vdout0_23ck142 = 0 time = 1430
.meas tran vdout0_23ck142 FIND v(dout0_23) AT=1430.05n

* CHECK dout0_24 Vdout0_24ck142 = 1.8 time = 1430
.meas tran vdout0_24ck142 FIND v(dout0_24) AT=1430.05n

* CHECK dout0_25 Vdout0_25ck142 = 0 time = 1430
.meas tran vdout0_25ck142 FIND v(dout0_25) AT=1430.05n

* CHECK dout0_26 Vdout0_26ck142 = 0 time = 1430
.meas tran vdout0_26ck142 FIND v(dout0_26) AT=1430.05n

* CHECK dout0_27 Vdout0_27ck142 = 1.8 time = 1430
.meas tran vdout0_27ck142 FIND v(dout0_27) AT=1430.05n

* CHECK dout0_28 Vdout0_28ck142 = 1.8 time = 1430
.meas tran vdout0_28ck142 FIND v(dout0_28) AT=1430.05n

* CHECK dout0_29 Vdout0_29ck142 = 1.8 time = 1430
.meas tran vdout0_29ck142 FIND v(dout0_29) AT=1430.05n

* CHECK dout0_30 Vdout0_30ck142 = 0 time = 1430
.meas tran vdout0_30ck142 FIND v(dout0_30) AT=1430.05n

* CHECK dout0_31 Vdout0_31ck142 = 1.8 time = 1430
.meas tran vdout0_31ck142 FIND v(dout0_31) AT=1430.05n

* CHECK dout0_32 Vdout0_32ck142 = 0 time = 1430
.meas tran vdout0_32ck142 FIND v(dout0_32) AT=1430.05n

* CHECK dout0_33 Vdout0_33ck142 = 0 time = 1430
.meas tran vdout0_33ck142 FIND v(dout0_33) AT=1430.05n

* CHECK dout0_34 Vdout0_34ck142 = 0 time = 1430
.meas tran vdout0_34ck142 FIND v(dout0_34) AT=1430.05n

* CHECK dout0_35 Vdout0_35ck142 = 0 time = 1430
.meas tran vdout0_35ck142 FIND v(dout0_35) AT=1430.05n

* CHECK dout0_36 Vdout0_36ck142 = 0 time = 1430
.meas tran vdout0_36ck142 FIND v(dout0_36) AT=1430.05n

* CHECK dout0_37 Vdout0_37ck142 = 1.8 time = 1430
.meas tran vdout0_37ck142 FIND v(dout0_37) AT=1430.05n

* CHECK dout0_38 Vdout0_38ck142 = 0 time = 1430
.meas tran vdout0_38ck142 FIND v(dout0_38) AT=1430.05n

* CHECK dout0_39 Vdout0_39ck142 = 0 time = 1430
.meas tran vdout0_39ck142 FIND v(dout0_39) AT=1430.05n

* CHECK dout0_40 Vdout0_40ck142 = 1.8 time = 1430
.meas tran vdout0_40ck142 FIND v(dout0_40) AT=1430.05n

* CHECK dout0_41 Vdout0_41ck142 = 0 time = 1430
.meas tran vdout0_41ck142 FIND v(dout0_41) AT=1430.05n

* CHECK dout0_42 Vdout0_42ck142 = 0 time = 1430
.meas tran vdout0_42ck142 FIND v(dout0_42) AT=1430.05n

* CHECK dout0_43 Vdout0_43ck142 = 1.8 time = 1430
.meas tran vdout0_43ck142 FIND v(dout0_43) AT=1430.05n

* CHECK dout0_44 Vdout0_44ck142 = 1.8 time = 1430
.meas tran vdout0_44ck142 FIND v(dout0_44) AT=1430.05n

* CHECK dout0_45 Vdout0_45ck142 = 1.8 time = 1430
.meas tran vdout0_45ck142 FIND v(dout0_45) AT=1430.05n

* CHECK dout0_46 Vdout0_46ck142 = 1.8 time = 1430
.meas tran vdout0_46ck142 FIND v(dout0_46) AT=1430.05n

* CHECK dout0_47 Vdout0_47ck142 = 1.8 time = 1430
.meas tran vdout0_47ck142 FIND v(dout0_47) AT=1430.05n

* CHECK dout0_48 Vdout0_48ck142 = 0 time = 1430
.meas tran vdout0_48ck142 FIND v(dout0_48) AT=1430.05n

* CHECK dout0_49 Vdout0_49ck142 = 0 time = 1430
.meas tran vdout0_49ck142 FIND v(dout0_49) AT=1430.05n

* CHECK dout0_50 Vdout0_50ck142 = 0 time = 1430
.meas tran vdout0_50ck142 FIND v(dout0_50) AT=1430.05n

* CHECK dout0_51 Vdout0_51ck142 = 0 time = 1430
.meas tran vdout0_51ck142 FIND v(dout0_51) AT=1430.05n

* CHECK dout0_52 Vdout0_52ck142 = 1.8 time = 1430
.meas tran vdout0_52ck142 FIND v(dout0_52) AT=1430.05n

* CHECK dout0_53 Vdout0_53ck142 = 1.8 time = 1430
.meas tran vdout0_53ck142 FIND v(dout0_53) AT=1430.05n

* CHECK dout0_54 Vdout0_54ck142 = 0 time = 1430
.meas tran vdout0_54ck142 FIND v(dout0_54) AT=1430.05n

* CHECK dout0_55 Vdout0_55ck142 = 1.8 time = 1430
.meas tran vdout0_55ck142 FIND v(dout0_55) AT=1430.05n

* CHECK dout0_56 Vdout0_56ck142 = 0 time = 1430
.meas tran vdout0_56ck142 FIND v(dout0_56) AT=1430.05n

* CHECK dout0_57 Vdout0_57ck142 = 0 time = 1430
.meas tran vdout0_57ck142 FIND v(dout0_57) AT=1430.05n

* CHECK dout0_58 Vdout0_58ck142 = 1.8 time = 1430
.meas tran vdout0_58ck142 FIND v(dout0_58) AT=1430.05n

* CHECK dout0_59 Vdout0_59ck142 = 0 time = 1430
.meas tran vdout0_59ck142 FIND v(dout0_59) AT=1430.05n

* CHECK dout0_60 Vdout0_60ck142 = 0 time = 1430
.meas tran vdout0_60ck142 FIND v(dout0_60) AT=1430.05n

* CHECK dout0_61 Vdout0_61ck142 = 0 time = 1430
.meas tran vdout0_61ck142 FIND v(dout0_61) AT=1430.05n

* CHECK dout0_62 Vdout0_62ck142 = 1.8 time = 1430
.meas tran vdout0_62ck142 FIND v(dout0_62) AT=1430.05n

* CHECK dout0_63 Vdout0_63ck142 = 0 time = 1430
.meas tran vdout0_63ck142 FIND v(dout0_63) AT=1430.05n

* CHECK dout0_64 Vdout0_64ck142 = 0 time = 1430
.meas tran vdout0_64ck142 FIND v(dout0_64) AT=1430.05n

* CHECK dout0_0 Vdout0_0ck143 = 1.8 time = 1440
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=1440.05n

* CHECK dout0_1 Vdout0_1ck143 = 1.8 time = 1440
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=1440.05n

* CHECK dout0_2 Vdout0_2ck143 = 0 time = 1440
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=1440.05n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 1440
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=1440.05n

* CHECK dout0_4 Vdout0_4ck143 = 1.8 time = 1440
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=1440.05n

* CHECK dout0_5 Vdout0_5ck143 = 1.8 time = 1440
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=1440.05n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 1440
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=1440.05n

* CHECK dout0_7 Vdout0_7ck143 = 0 time = 1440
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=1440.05n

* CHECK dout0_8 Vdout0_8ck143 = 1.8 time = 1440
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=1440.05n

* CHECK dout0_9 Vdout0_9ck143 = 1.8 time = 1440
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=1440.05n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 1440
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=1440.05n

* CHECK dout0_11 Vdout0_11ck143 = 1.8 time = 1440
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=1440.05n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 1440
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=1440.05n

* CHECK dout0_13 Vdout0_13ck143 = 1.8 time = 1440
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=1440.05n

* CHECK dout0_14 Vdout0_14ck143 = 1.8 time = 1440
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=1440.05n

* CHECK dout0_15 Vdout0_15ck143 = 1.8 time = 1440
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=1440.05n

* CHECK dout0_16 Vdout0_16ck143 = 1.8 time = 1440
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=1440.05n

* CHECK dout0_17 Vdout0_17ck143 = 0 time = 1440
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=1440.05n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 1440
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=1440.05n

* CHECK dout0_19 Vdout0_19ck143 = 0 time = 1440
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=1440.05n

* CHECK dout0_20 Vdout0_20ck143 = 1.8 time = 1440
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=1440.05n

* CHECK dout0_21 Vdout0_21ck143 = 1.8 time = 1440
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=1440.05n

* CHECK dout0_22 Vdout0_22ck143 = 1.8 time = 1440
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=1440.05n

* CHECK dout0_23 Vdout0_23ck143 = 0 time = 1440
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=1440.05n

* CHECK dout0_24 Vdout0_24ck143 = 1.8 time = 1440
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=1440.05n

* CHECK dout0_25 Vdout0_25ck143 = 1.8 time = 1440
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=1440.05n

* CHECK dout0_26 Vdout0_26ck143 = 0 time = 1440
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=1440.05n

* CHECK dout0_27 Vdout0_27ck143 = 0 time = 1440
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=1440.05n

* CHECK dout0_28 Vdout0_28ck143 = 0 time = 1440
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=1440.05n

* CHECK dout0_29 Vdout0_29ck143 = 1.8 time = 1440
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=1440.05n

* CHECK dout0_30 Vdout0_30ck143 = 1.8 time = 1440
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=1440.05n

* CHECK dout0_31 Vdout0_31ck143 = 0 time = 1440
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=1440.05n

* CHECK dout0_32 Vdout0_32ck143 = 1.8 time = 1440
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=1440.05n

* CHECK dout0_33 Vdout0_33ck143 = 0 time = 1440
.meas tran vdout0_33ck143 FIND v(dout0_33) AT=1440.05n

* CHECK dout0_34 Vdout0_34ck143 = 0 time = 1440
.meas tran vdout0_34ck143 FIND v(dout0_34) AT=1440.05n

* CHECK dout0_35 Vdout0_35ck143 = 1.8 time = 1440
.meas tran vdout0_35ck143 FIND v(dout0_35) AT=1440.05n

* CHECK dout0_36 Vdout0_36ck143 = 0 time = 1440
.meas tran vdout0_36ck143 FIND v(dout0_36) AT=1440.05n

* CHECK dout0_37 Vdout0_37ck143 = 0 time = 1440
.meas tran vdout0_37ck143 FIND v(dout0_37) AT=1440.05n

* CHECK dout0_38 Vdout0_38ck143 = 0 time = 1440
.meas tran vdout0_38ck143 FIND v(dout0_38) AT=1440.05n

* CHECK dout0_39 Vdout0_39ck143 = 1.8 time = 1440
.meas tran vdout0_39ck143 FIND v(dout0_39) AT=1440.05n

* CHECK dout0_40 Vdout0_40ck143 = 0 time = 1440
.meas tran vdout0_40ck143 FIND v(dout0_40) AT=1440.05n

* CHECK dout0_41 Vdout0_41ck143 = 1.8 time = 1440
.meas tran vdout0_41ck143 FIND v(dout0_41) AT=1440.05n

* CHECK dout0_42 Vdout0_42ck143 = 0 time = 1440
.meas tran vdout0_42ck143 FIND v(dout0_42) AT=1440.05n

* CHECK dout0_43 Vdout0_43ck143 = 1.8 time = 1440
.meas tran vdout0_43ck143 FIND v(dout0_43) AT=1440.05n

* CHECK dout0_44 Vdout0_44ck143 = 1.8 time = 1440
.meas tran vdout0_44ck143 FIND v(dout0_44) AT=1440.05n

* CHECK dout0_45 Vdout0_45ck143 = 1.8 time = 1440
.meas tran vdout0_45ck143 FIND v(dout0_45) AT=1440.05n

* CHECK dout0_46 Vdout0_46ck143 = 0 time = 1440
.meas tran vdout0_46ck143 FIND v(dout0_46) AT=1440.05n

* CHECK dout0_47 Vdout0_47ck143 = 0 time = 1440
.meas tran vdout0_47ck143 FIND v(dout0_47) AT=1440.05n

* CHECK dout0_48 Vdout0_48ck143 = 1.8 time = 1440
.meas tran vdout0_48ck143 FIND v(dout0_48) AT=1440.05n

* CHECK dout0_49 Vdout0_49ck143 = 0 time = 1440
.meas tran vdout0_49ck143 FIND v(dout0_49) AT=1440.05n

* CHECK dout0_50 Vdout0_50ck143 = 1.8 time = 1440
.meas tran vdout0_50ck143 FIND v(dout0_50) AT=1440.05n

* CHECK dout0_51 Vdout0_51ck143 = 1.8 time = 1440
.meas tran vdout0_51ck143 FIND v(dout0_51) AT=1440.05n

* CHECK dout0_52 Vdout0_52ck143 = 0 time = 1440
.meas tran vdout0_52ck143 FIND v(dout0_52) AT=1440.05n

* CHECK dout0_53 Vdout0_53ck143 = 1.8 time = 1440
.meas tran vdout0_53ck143 FIND v(dout0_53) AT=1440.05n

* CHECK dout0_54 Vdout0_54ck143 = 1.8 time = 1440
.meas tran vdout0_54ck143 FIND v(dout0_54) AT=1440.05n

* CHECK dout0_55 Vdout0_55ck143 = 1.8 time = 1440
.meas tran vdout0_55ck143 FIND v(dout0_55) AT=1440.05n

* CHECK dout0_56 Vdout0_56ck143 = 0 time = 1440
.meas tran vdout0_56ck143 FIND v(dout0_56) AT=1440.05n

* CHECK dout0_57 Vdout0_57ck143 = 1.8 time = 1440
.meas tran vdout0_57ck143 FIND v(dout0_57) AT=1440.05n

* CHECK dout0_58 Vdout0_58ck143 = 0 time = 1440
.meas tran vdout0_58ck143 FIND v(dout0_58) AT=1440.05n

* CHECK dout0_59 Vdout0_59ck143 = 1.8 time = 1440
.meas tran vdout0_59ck143 FIND v(dout0_59) AT=1440.05n

* CHECK dout0_60 Vdout0_60ck143 = 1.8 time = 1440
.meas tran vdout0_60ck143 FIND v(dout0_60) AT=1440.05n

* CHECK dout0_61 Vdout0_61ck143 = 0 time = 1440
.meas tran vdout0_61ck143 FIND v(dout0_61) AT=1440.05n

* CHECK dout0_62 Vdout0_62ck143 = 1.8 time = 1440
.meas tran vdout0_62ck143 FIND v(dout0_62) AT=1440.05n

* CHECK dout0_63 Vdout0_63ck143 = 1.8 time = 1440
.meas tran vdout0_63ck143 FIND v(dout0_63) AT=1440.05n

* CHECK dout0_64 Vdout0_64ck143 = 0 time = 1440
.meas tran vdout0_64ck143 FIND v(dout0_64) AT=1440.05n

* CHECK dout0_0 Vdout0_0ck146 = 0 time = 1470
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=1470.05n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 1470
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=1470.05n

* CHECK dout0_2 Vdout0_2ck146 = 1.8 time = 1470
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=1470.05n

* CHECK dout0_3 Vdout0_3ck146 = 1.8 time = 1470
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=1470.05n

* CHECK dout0_4 Vdout0_4ck146 = 1.8 time = 1470
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=1470.05n

* CHECK dout0_5 Vdout0_5ck146 = 1.8 time = 1470
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=1470.05n

* CHECK dout0_6 Vdout0_6ck146 = 1.8 time = 1470
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=1470.05n

* CHECK dout0_7 Vdout0_7ck146 = 0 time = 1470
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=1470.05n

* CHECK dout0_8 Vdout0_8ck146 = 1.8 time = 1470
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=1470.05n

* CHECK dout0_9 Vdout0_9ck146 = 1.8 time = 1470
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=1470.05n

* CHECK dout0_10 Vdout0_10ck146 = 1.8 time = 1470
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=1470.05n

* CHECK dout0_11 Vdout0_11ck146 = 1.8 time = 1470
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=1470.05n

* CHECK dout0_12 Vdout0_12ck146 = 1.8 time = 1470
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=1470.05n

* CHECK dout0_13 Vdout0_13ck146 = 0 time = 1470
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=1470.05n

* CHECK dout0_14 Vdout0_14ck146 = 0 time = 1470
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=1470.05n

* CHECK dout0_15 Vdout0_15ck146 = 1.8 time = 1470
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=1470.05n

* CHECK dout0_16 Vdout0_16ck146 = 0 time = 1470
.meas tran vdout0_16ck146 FIND v(dout0_16) AT=1470.05n

* CHECK dout0_17 Vdout0_17ck146 = 0 time = 1470
.meas tran vdout0_17ck146 FIND v(dout0_17) AT=1470.05n

* CHECK dout0_18 Vdout0_18ck146 = 0 time = 1470
.meas tran vdout0_18ck146 FIND v(dout0_18) AT=1470.05n

* CHECK dout0_19 Vdout0_19ck146 = 0 time = 1470
.meas tran vdout0_19ck146 FIND v(dout0_19) AT=1470.05n

* CHECK dout0_20 Vdout0_20ck146 = 1.8 time = 1470
.meas tran vdout0_20ck146 FIND v(dout0_20) AT=1470.05n

* CHECK dout0_21 Vdout0_21ck146 = 1.8 time = 1470
.meas tran vdout0_21ck146 FIND v(dout0_21) AT=1470.05n

* CHECK dout0_22 Vdout0_22ck146 = 1.8 time = 1470
.meas tran vdout0_22ck146 FIND v(dout0_22) AT=1470.05n

* CHECK dout0_23 Vdout0_23ck146 = 0 time = 1470
.meas tran vdout0_23ck146 FIND v(dout0_23) AT=1470.05n

* CHECK dout0_24 Vdout0_24ck146 = 1.8 time = 1470
.meas tran vdout0_24ck146 FIND v(dout0_24) AT=1470.05n

* CHECK dout0_25 Vdout0_25ck146 = 0 time = 1470
.meas tran vdout0_25ck146 FIND v(dout0_25) AT=1470.05n

* CHECK dout0_26 Vdout0_26ck146 = 0 time = 1470
.meas tran vdout0_26ck146 FIND v(dout0_26) AT=1470.05n

* CHECK dout0_27 Vdout0_27ck146 = 1.8 time = 1470
.meas tran vdout0_27ck146 FIND v(dout0_27) AT=1470.05n

* CHECK dout0_28 Vdout0_28ck146 = 1.8 time = 1470
.meas tran vdout0_28ck146 FIND v(dout0_28) AT=1470.05n

* CHECK dout0_29 Vdout0_29ck146 = 1.8 time = 1470
.meas tran vdout0_29ck146 FIND v(dout0_29) AT=1470.05n

* CHECK dout0_30 Vdout0_30ck146 = 0 time = 1470
.meas tran vdout0_30ck146 FIND v(dout0_30) AT=1470.05n

* CHECK dout0_31 Vdout0_31ck146 = 1.8 time = 1470
.meas tran vdout0_31ck146 FIND v(dout0_31) AT=1470.05n

* CHECK dout0_32 Vdout0_32ck146 = 0 time = 1470
.meas tran vdout0_32ck146 FIND v(dout0_32) AT=1470.05n

* CHECK dout0_33 Vdout0_33ck146 = 0 time = 1470
.meas tran vdout0_33ck146 FIND v(dout0_33) AT=1470.05n

* CHECK dout0_34 Vdout0_34ck146 = 0 time = 1470
.meas tran vdout0_34ck146 FIND v(dout0_34) AT=1470.05n

* CHECK dout0_35 Vdout0_35ck146 = 0 time = 1470
.meas tran vdout0_35ck146 FIND v(dout0_35) AT=1470.05n

* CHECK dout0_36 Vdout0_36ck146 = 0 time = 1470
.meas tran vdout0_36ck146 FIND v(dout0_36) AT=1470.05n

* CHECK dout0_37 Vdout0_37ck146 = 1.8 time = 1470
.meas tran vdout0_37ck146 FIND v(dout0_37) AT=1470.05n

* CHECK dout0_38 Vdout0_38ck146 = 0 time = 1470
.meas tran vdout0_38ck146 FIND v(dout0_38) AT=1470.05n

* CHECK dout0_39 Vdout0_39ck146 = 0 time = 1470
.meas tran vdout0_39ck146 FIND v(dout0_39) AT=1470.05n

* CHECK dout0_40 Vdout0_40ck146 = 1.8 time = 1470
.meas tran vdout0_40ck146 FIND v(dout0_40) AT=1470.05n

* CHECK dout0_41 Vdout0_41ck146 = 0 time = 1470
.meas tran vdout0_41ck146 FIND v(dout0_41) AT=1470.05n

* CHECK dout0_42 Vdout0_42ck146 = 0 time = 1470
.meas tran vdout0_42ck146 FIND v(dout0_42) AT=1470.05n

* CHECK dout0_43 Vdout0_43ck146 = 1.8 time = 1470
.meas tran vdout0_43ck146 FIND v(dout0_43) AT=1470.05n

* CHECK dout0_44 Vdout0_44ck146 = 1.8 time = 1470
.meas tran vdout0_44ck146 FIND v(dout0_44) AT=1470.05n

* CHECK dout0_45 Vdout0_45ck146 = 1.8 time = 1470
.meas tran vdout0_45ck146 FIND v(dout0_45) AT=1470.05n

* CHECK dout0_46 Vdout0_46ck146 = 1.8 time = 1470
.meas tran vdout0_46ck146 FIND v(dout0_46) AT=1470.05n

* CHECK dout0_47 Vdout0_47ck146 = 1.8 time = 1470
.meas tran vdout0_47ck146 FIND v(dout0_47) AT=1470.05n

* CHECK dout0_48 Vdout0_48ck146 = 0 time = 1470
.meas tran vdout0_48ck146 FIND v(dout0_48) AT=1470.05n

* CHECK dout0_49 Vdout0_49ck146 = 0 time = 1470
.meas tran vdout0_49ck146 FIND v(dout0_49) AT=1470.05n

* CHECK dout0_50 Vdout0_50ck146 = 0 time = 1470
.meas tran vdout0_50ck146 FIND v(dout0_50) AT=1470.05n

* CHECK dout0_51 Vdout0_51ck146 = 0 time = 1470
.meas tran vdout0_51ck146 FIND v(dout0_51) AT=1470.05n

* CHECK dout0_52 Vdout0_52ck146 = 1.8 time = 1470
.meas tran vdout0_52ck146 FIND v(dout0_52) AT=1470.05n

* CHECK dout0_53 Vdout0_53ck146 = 1.8 time = 1470
.meas tran vdout0_53ck146 FIND v(dout0_53) AT=1470.05n

* CHECK dout0_54 Vdout0_54ck146 = 0 time = 1470
.meas tran vdout0_54ck146 FIND v(dout0_54) AT=1470.05n

* CHECK dout0_55 Vdout0_55ck146 = 1.8 time = 1470
.meas tran vdout0_55ck146 FIND v(dout0_55) AT=1470.05n

* CHECK dout0_56 Vdout0_56ck146 = 0 time = 1470
.meas tran vdout0_56ck146 FIND v(dout0_56) AT=1470.05n

* CHECK dout0_57 Vdout0_57ck146 = 0 time = 1470
.meas tran vdout0_57ck146 FIND v(dout0_57) AT=1470.05n

* CHECK dout0_58 Vdout0_58ck146 = 1.8 time = 1470
.meas tran vdout0_58ck146 FIND v(dout0_58) AT=1470.05n

* CHECK dout0_59 Vdout0_59ck146 = 0 time = 1470
.meas tran vdout0_59ck146 FIND v(dout0_59) AT=1470.05n

* CHECK dout0_60 Vdout0_60ck146 = 0 time = 1470
.meas tran vdout0_60ck146 FIND v(dout0_60) AT=1470.05n

* CHECK dout0_61 Vdout0_61ck146 = 0 time = 1470
.meas tran vdout0_61ck146 FIND v(dout0_61) AT=1470.05n

* CHECK dout0_62 Vdout0_62ck146 = 1.8 time = 1470
.meas tran vdout0_62ck146 FIND v(dout0_62) AT=1470.05n

* CHECK dout0_63 Vdout0_63ck146 = 0 time = 1470
.meas tran vdout0_63ck146 FIND v(dout0_63) AT=1470.05n

* CHECK dout0_64 Vdout0_64ck146 = 0 time = 1470
.meas tran vdout0_64ck146 FIND v(dout0_64) AT=1470.05n

* CHECK dout0_0 Vdout0_0ck147 = 0 time = 1480
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=1480.05n

* CHECK dout0_1 Vdout0_1ck147 = 1.8 time = 1480
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=1480.05n

* CHECK dout0_2 Vdout0_2ck147 = 0 time = 1480
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=1480.05n

* CHECK dout0_3 Vdout0_3ck147 = 0 time = 1480
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=1480.05n

* CHECK dout0_4 Vdout0_4ck147 = 1.8 time = 1480
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=1480.05n

* CHECK dout0_5 Vdout0_5ck147 = 0 time = 1480
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=1480.05n

* CHECK dout0_6 Vdout0_6ck147 = 1.8 time = 1480
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=1480.05n

* CHECK dout0_7 Vdout0_7ck147 = 0 time = 1480
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=1480.05n

* CHECK dout0_8 Vdout0_8ck147 = 0 time = 1480
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=1480.05n

* CHECK dout0_9 Vdout0_9ck147 = 1.8 time = 1480
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=1480.05n

* CHECK dout0_10 Vdout0_10ck147 = 1.8 time = 1480
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=1480.05n

* CHECK dout0_11 Vdout0_11ck147 = 0 time = 1480
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=1480.05n

* CHECK dout0_12 Vdout0_12ck147 = 0 time = 1480
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=1480.05n

* CHECK dout0_13 Vdout0_13ck147 = 0 time = 1480
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=1480.05n

* CHECK dout0_14 Vdout0_14ck147 = 0 time = 1480
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=1480.05n

* CHECK dout0_15 Vdout0_15ck147 = 0 time = 1480
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=1480.05n

* CHECK dout0_16 Vdout0_16ck147 = 0 time = 1480
.meas tran vdout0_16ck147 FIND v(dout0_16) AT=1480.05n

* CHECK dout0_17 Vdout0_17ck147 = 1.8 time = 1480
.meas tran vdout0_17ck147 FIND v(dout0_17) AT=1480.05n

* CHECK dout0_18 Vdout0_18ck147 = 0 time = 1480
.meas tran vdout0_18ck147 FIND v(dout0_18) AT=1480.05n

* CHECK dout0_19 Vdout0_19ck147 = 0 time = 1480
.meas tran vdout0_19ck147 FIND v(dout0_19) AT=1480.05n

* CHECK dout0_20 Vdout0_20ck147 = 1.8 time = 1480
.meas tran vdout0_20ck147 FIND v(dout0_20) AT=1480.05n

* CHECK dout0_21 Vdout0_21ck147 = 0 time = 1480
.meas tran vdout0_21ck147 FIND v(dout0_21) AT=1480.05n

* CHECK dout0_22 Vdout0_22ck147 = 1.8 time = 1480
.meas tran vdout0_22ck147 FIND v(dout0_22) AT=1480.05n

* CHECK dout0_23 Vdout0_23ck147 = 0 time = 1480
.meas tran vdout0_23ck147 FIND v(dout0_23) AT=1480.05n

* CHECK dout0_24 Vdout0_24ck147 = 0 time = 1480
.meas tran vdout0_24ck147 FIND v(dout0_24) AT=1480.05n

* CHECK dout0_25 Vdout0_25ck147 = 0 time = 1480
.meas tran vdout0_25ck147 FIND v(dout0_25) AT=1480.05n

* CHECK dout0_26 Vdout0_26ck147 = 1.8 time = 1480
.meas tran vdout0_26ck147 FIND v(dout0_26) AT=1480.05n

* CHECK dout0_27 Vdout0_27ck147 = 0 time = 1480
.meas tran vdout0_27ck147 FIND v(dout0_27) AT=1480.05n

* CHECK dout0_28 Vdout0_28ck147 = 0 time = 1480
.meas tran vdout0_28ck147 FIND v(dout0_28) AT=1480.05n

* CHECK dout0_29 Vdout0_29ck147 = 0 time = 1480
.meas tran vdout0_29ck147 FIND v(dout0_29) AT=1480.05n

* CHECK dout0_30 Vdout0_30ck147 = 1.8 time = 1480
.meas tran vdout0_30ck147 FIND v(dout0_30) AT=1480.05n

* CHECK dout0_31 Vdout0_31ck147 = 0 time = 1480
.meas tran vdout0_31ck147 FIND v(dout0_31) AT=1480.05n

* CHECK dout0_32 Vdout0_32ck147 = 1.8 time = 1480
.meas tran vdout0_32ck147 FIND v(dout0_32) AT=1480.05n

* CHECK dout0_33 Vdout0_33ck147 = 0 time = 1480
.meas tran vdout0_33ck147 FIND v(dout0_33) AT=1480.05n

* CHECK dout0_34 Vdout0_34ck147 = 1.8 time = 1480
.meas tran vdout0_34ck147 FIND v(dout0_34) AT=1480.05n

* CHECK dout0_35 Vdout0_35ck147 = 0 time = 1480
.meas tran vdout0_35ck147 FIND v(dout0_35) AT=1480.05n

* CHECK dout0_36 Vdout0_36ck147 = 1.8 time = 1480
.meas tran vdout0_36ck147 FIND v(dout0_36) AT=1480.05n

* CHECK dout0_37 Vdout0_37ck147 = 0 time = 1480
.meas tran vdout0_37ck147 FIND v(dout0_37) AT=1480.05n

* CHECK dout0_38 Vdout0_38ck147 = 0 time = 1480
.meas tran vdout0_38ck147 FIND v(dout0_38) AT=1480.05n

* CHECK dout0_39 Vdout0_39ck147 = 0 time = 1480
.meas tran vdout0_39ck147 FIND v(dout0_39) AT=1480.05n

* CHECK dout0_40 Vdout0_40ck147 = 1.8 time = 1480
.meas tran vdout0_40ck147 FIND v(dout0_40) AT=1480.05n

* CHECK dout0_41 Vdout0_41ck147 = 0 time = 1480
.meas tran vdout0_41ck147 FIND v(dout0_41) AT=1480.05n

* CHECK dout0_42 Vdout0_42ck147 = 1.8 time = 1480
.meas tran vdout0_42ck147 FIND v(dout0_42) AT=1480.05n

* CHECK dout0_43 Vdout0_43ck147 = 1.8 time = 1480
.meas tran vdout0_43ck147 FIND v(dout0_43) AT=1480.05n

* CHECK dout0_44 Vdout0_44ck147 = 0 time = 1480
.meas tran vdout0_44ck147 FIND v(dout0_44) AT=1480.05n

* CHECK dout0_45 Vdout0_45ck147 = 0 time = 1480
.meas tran vdout0_45ck147 FIND v(dout0_45) AT=1480.05n

* CHECK dout0_46 Vdout0_46ck147 = 0 time = 1480
.meas tran vdout0_46ck147 FIND v(dout0_46) AT=1480.05n

* CHECK dout0_47 Vdout0_47ck147 = 0 time = 1480
.meas tran vdout0_47ck147 FIND v(dout0_47) AT=1480.05n

* CHECK dout0_48 Vdout0_48ck147 = 0 time = 1480
.meas tran vdout0_48ck147 FIND v(dout0_48) AT=1480.05n

* CHECK dout0_49 Vdout0_49ck147 = 0 time = 1480
.meas tran vdout0_49ck147 FIND v(dout0_49) AT=1480.05n

* CHECK dout0_50 Vdout0_50ck147 = 0 time = 1480
.meas tran vdout0_50ck147 FIND v(dout0_50) AT=1480.05n

* CHECK dout0_51 Vdout0_51ck147 = 1.8 time = 1480
.meas tran vdout0_51ck147 FIND v(dout0_51) AT=1480.05n

* CHECK dout0_52 Vdout0_52ck147 = 0 time = 1480
.meas tran vdout0_52ck147 FIND v(dout0_52) AT=1480.05n

* CHECK dout0_53 Vdout0_53ck147 = 1.8 time = 1480
.meas tran vdout0_53ck147 FIND v(dout0_53) AT=1480.05n

* CHECK dout0_54 Vdout0_54ck147 = 0 time = 1480
.meas tran vdout0_54ck147 FIND v(dout0_54) AT=1480.05n

* CHECK dout0_55 Vdout0_55ck147 = 1.8 time = 1480
.meas tran vdout0_55ck147 FIND v(dout0_55) AT=1480.05n

* CHECK dout0_56 Vdout0_56ck147 = 0 time = 1480
.meas tran vdout0_56ck147 FIND v(dout0_56) AT=1480.05n

* CHECK dout0_57 Vdout0_57ck147 = 1.8 time = 1480
.meas tran vdout0_57ck147 FIND v(dout0_57) AT=1480.05n

* CHECK dout0_58 Vdout0_58ck147 = 1.8 time = 1480
.meas tran vdout0_58ck147 FIND v(dout0_58) AT=1480.05n

* CHECK dout0_59 Vdout0_59ck147 = 0 time = 1480
.meas tran vdout0_59ck147 FIND v(dout0_59) AT=1480.05n

* CHECK dout0_60 Vdout0_60ck147 = 0 time = 1480
.meas tran vdout0_60ck147 FIND v(dout0_60) AT=1480.05n

* CHECK dout0_61 Vdout0_61ck147 = 1.8 time = 1480
.meas tran vdout0_61ck147 FIND v(dout0_61) AT=1480.05n

* CHECK dout0_62 Vdout0_62ck147 = 0 time = 1480
.meas tran vdout0_62ck147 FIND v(dout0_62) AT=1480.05n

* CHECK dout0_63 Vdout0_63ck147 = 1.8 time = 1480
.meas tran vdout0_63ck147 FIND v(dout0_63) AT=1480.05n

* CHECK dout0_64 Vdout0_64ck147 = 0 time = 1480
.meas tran vdout0_64ck147 FIND v(dout0_64) AT=1480.05n

* CHECK dout0_0 Vdout0_0ck150 = 0 time = 1510
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=1510.05n

* CHECK dout0_1 Vdout0_1ck150 = 1.8 time = 1510
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=1510.05n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 1510
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=1510.05n

* CHECK dout0_3 Vdout0_3ck150 = 1.8 time = 1510
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=1510.05n

* CHECK dout0_4 Vdout0_4ck150 = 1.8 time = 1510
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=1510.05n

* CHECK dout0_5 Vdout0_5ck150 = 1.8 time = 1510
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=1510.05n

* CHECK dout0_6 Vdout0_6ck150 = 0 time = 1510
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=1510.05n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 1510
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=1510.05n

* CHECK dout0_8 Vdout0_8ck150 = 0 time = 1510
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=1510.05n

* CHECK dout0_9 Vdout0_9ck150 = 1.8 time = 1510
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=1510.05n

* CHECK dout0_10 Vdout0_10ck150 = 0 time = 1510
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=1510.05n

* CHECK dout0_11 Vdout0_11ck150 = 0 time = 1510
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=1510.05n

* CHECK dout0_12 Vdout0_12ck150 = 1.8 time = 1510
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=1510.05n

* CHECK dout0_13 Vdout0_13ck150 = 0 time = 1510
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=1510.05n

* CHECK dout0_14 Vdout0_14ck150 = 0 time = 1510
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=1510.05n

* CHECK dout0_15 Vdout0_15ck150 = 0 time = 1510
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=1510.05n

* CHECK dout0_16 Vdout0_16ck150 = 0 time = 1510
.meas tran vdout0_16ck150 FIND v(dout0_16) AT=1510.05n

* CHECK dout0_17 Vdout0_17ck150 = 0 time = 1510
.meas tran vdout0_17ck150 FIND v(dout0_17) AT=1510.05n

* CHECK dout0_18 Vdout0_18ck150 = 0 time = 1510
.meas tran vdout0_18ck150 FIND v(dout0_18) AT=1510.05n

* CHECK dout0_19 Vdout0_19ck150 = 0 time = 1510
.meas tran vdout0_19ck150 FIND v(dout0_19) AT=1510.05n

* CHECK dout0_20 Vdout0_20ck150 = 1.8 time = 1510
.meas tran vdout0_20ck150 FIND v(dout0_20) AT=1510.05n

* CHECK dout0_21 Vdout0_21ck150 = 1.8 time = 1510
.meas tran vdout0_21ck150 FIND v(dout0_21) AT=1510.05n

* CHECK dout0_22 Vdout0_22ck150 = 0 time = 1510
.meas tran vdout0_22ck150 FIND v(dout0_22) AT=1510.05n

* CHECK dout0_23 Vdout0_23ck150 = 0 time = 1510
.meas tran vdout0_23ck150 FIND v(dout0_23) AT=1510.05n

* CHECK dout0_24 Vdout0_24ck150 = 0 time = 1510
.meas tran vdout0_24ck150 FIND v(dout0_24) AT=1510.05n

* CHECK dout0_25 Vdout0_25ck150 = 0 time = 1510
.meas tran vdout0_25ck150 FIND v(dout0_25) AT=1510.05n

* CHECK dout0_26 Vdout0_26ck150 = 1.8 time = 1510
.meas tran vdout0_26ck150 FIND v(dout0_26) AT=1510.05n

* CHECK dout0_27 Vdout0_27ck150 = 1.8 time = 1510
.meas tran vdout0_27ck150 FIND v(dout0_27) AT=1510.05n

* CHECK dout0_28 Vdout0_28ck150 = 0 time = 1510
.meas tran vdout0_28ck150 FIND v(dout0_28) AT=1510.05n

* CHECK dout0_29 Vdout0_29ck150 = 0 time = 1510
.meas tran vdout0_29ck150 FIND v(dout0_29) AT=1510.05n

* CHECK dout0_30 Vdout0_30ck150 = 0 time = 1510
.meas tran vdout0_30ck150 FIND v(dout0_30) AT=1510.05n

* CHECK dout0_31 Vdout0_31ck150 = 1.8 time = 1510
.meas tran vdout0_31ck150 FIND v(dout0_31) AT=1510.05n

* CHECK dout0_32 Vdout0_32ck150 = 1.8 time = 1510
.meas tran vdout0_32ck150 FIND v(dout0_32) AT=1510.05n

* CHECK dout0_33 Vdout0_33ck150 = 0 time = 1510
.meas tran vdout0_33ck150 FIND v(dout0_33) AT=1510.05n

* CHECK dout0_34 Vdout0_34ck150 = 1.8 time = 1510
.meas tran vdout0_34ck150 FIND v(dout0_34) AT=1510.05n

* CHECK dout0_35 Vdout0_35ck150 = 0 time = 1510
.meas tran vdout0_35ck150 FIND v(dout0_35) AT=1510.05n

* CHECK dout0_36 Vdout0_36ck150 = 0 time = 1510
.meas tran vdout0_36ck150 FIND v(dout0_36) AT=1510.05n

* CHECK dout0_37 Vdout0_37ck150 = 1.8 time = 1510
.meas tran vdout0_37ck150 FIND v(dout0_37) AT=1510.05n

* CHECK dout0_38 Vdout0_38ck150 = 0 time = 1510
.meas tran vdout0_38ck150 FIND v(dout0_38) AT=1510.05n

* CHECK dout0_39 Vdout0_39ck150 = 0 time = 1510
.meas tran vdout0_39ck150 FIND v(dout0_39) AT=1510.05n

* CHECK dout0_40 Vdout0_40ck150 = 1.8 time = 1510
.meas tran vdout0_40ck150 FIND v(dout0_40) AT=1510.05n

* CHECK dout0_41 Vdout0_41ck150 = 1.8 time = 1510
.meas tran vdout0_41ck150 FIND v(dout0_41) AT=1510.05n

* CHECK dout0_42 Vdout0_42ck150 = 1.8 time = 1510
.meas tran vdout0_42ck150 FIND v(dout0_42) AT=1510.05n

* CHECK dout0_43 Vdout0_43ck150 = 0 time = 1510
.meas tran vdout0_43ck150 FIND v(dout0_43) AT=1510.05n

* CHECK dout0_44 Vdout0_44ck150 = 1.8 time = 1510
.meas tran vdout0_44ck150 FIND v(dout0_44) AT=1510.05n

* CHECK dout0_45 Vdout0_45ck150 = 1.8 time = 1510
.meas tran vdout0_45ck150 FIND v(dout0_45) AT=1510.05n

* CHECK dout0_46 Vdout0_46ck150 = 1.8 time = 1510
.meas tran vdout0_46ck150 FIND v(dout0_46) AT=1510.05n

* CHECK dout0_47 Vdout0_47ck150 = 0 time = 1510
.meas tran vdout0_47ck150 FIND v(dout0_47) AT=1510.05n

* CHECK dout0_48 Vdout0_48ck150 = 1.8 time = 1510
.meas tran vdout0_48ck150 FIND v(dout0_48) AT=1510.05n

* CHECK dout0_49 Vdout0_49ck150 = 1.8 time = 1510
.meas tran vdout0_49ck150 FIND v(dout0_49) AT=1510.05n

* CHECK dout0_50 Vdout0_50ck150 = 0 time = 1510
.meas tran vdout0_50ck150 FIND v(dout0_50) AT=1510.05n

* CHECK dout0_51 Vdout0_51ck150 = 0 time = 1510
.meas tran vdout0_51ck150 FIND v(dout0_51) AT=1510.05n

* CHECK dout0_52 Vdout0_52ck150 = 0 time = 1510
.meas tran vdout0_52ck150 FIND v(dout0_52) AT=1510.05n

* CHECK dout0_53 Vdout0_53ck150 = 1.8 time = 1510
.meas tran vdout0_53ck150 FIND v(dout0_53) AT=1510.05n

* CHECK dout0_54 Vdout0_54ck150 = 0 time = 1510
.meas tran vdout0_54ck150 FIND v(dout0_54) AT=1510.05n

* CHECK dout0_55 Vdout0_55ck150 = 0 time = 1510
.meas tran vdout0_55ck150 FIND v(dout0_55) AT=1510.05n

* CHECK dout0_56 Vdout0_56ck150 = 1.8 time = 1510
.meas tran vdout0_56ck150 FIND v(dout0_56) AT=1510.05n

* CHECK dout0_57 Vdout0_57ck150 = 0 time = 1510
.meas tran vdout0_57ck150 FIND v(dout0_57) AT=1510.05n

* CHECK dout0_58 Vdout0_58ck150 = 1.8 time = 1510
.meas tran vdout0_58ck150 FIND v(dout0_58) AT=1510.05n

* CHECK dout0_59 Vdout0_59ck150 = 1.8 time = 1510
.meas tran vdout0_59ck150 FIND v(dout0_59) AT=1510.05n

* CHECK dout0_60 Vdout0_60ck150 = 1.8 time = 1510
.meas tran vdout0_60ck150 FIND v(dout0_60) AT=1510.05n

* CHECK dout0_61 Vdout0_61ck150 = 1.8 time = 1510
.meas tran vdout0_61ck150 FIND v(dout0_61) AT=1510.05n

* CHECK dout0_62 Vdout0_62ck150 = 1.8 time = 1510
.meas tran vdout0_62ck150 FIND v(dout0_62) AT=1510.05n

* CHECK dout0_63 Vdout0_63ck150 = 1.8 time = 1510
.meas tran vdout0_63ck150 FIND v(dout0_63) AT=1510.05n

* CHECK dout0_64 Vdout0_64ck150 = 0 time = 1510
.meas tran vdout0_64ck150 FIND v(dout0_64) AT=1510.05n

* CHECK dout0_0 Vdout0_0ck151 = 1.8 time = 1520
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=1520.05n

* CHECK dout0_1 Vdout0_1ck151 = 1.8 time = 1520
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=1520.05n

* CHECK dout0_2 Vdout0_2ck151 = 1.8 time = 1520
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=1520.05n

* CHECK dout0_3 Vdout0_3ck151 = 1.8 time = 1520
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=1520.05n

* CHECK dout0_4 Vdout0_4ck151 = 0 time = 1520
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=1520.05n

* CHECK dout0_5 Vdout0_5ck151 = 1.8 time = 1520
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=1520.05n

* CHECK dout0_6 Vdout0_6ck151 = 1.8 time = 1520
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=1520.05n

* CHECK dout0_7 Vdout0_7ck151 = 1.8 time = 1520
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=1520.05n

* CHECK dout0_8 Vdout0_8ck151 = 1.8 time = 1520
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=1520.05n

* CHECK dout0_9 Vdout0_9ck151 = 0 time = 1520
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=1520.05n

* CHECK dout0_10 Vdout0_10ck151 = 0 time = 1520
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=1520.05n

* CHECK dout0_11 Vdout0_11ck151 = 0 time = 1520
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=1520.05n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 1520
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=1520.05n

* CHECK dout0_13 Vdout0_13ck151 = 1.8 time = 1520
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=1520.05n

* CHECK dout0_14 Vdout0_14ck151 = 1.8 time = 1520
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=1520.05n

* CHECK dout0_15 Vdout0_15ck151 = 1.8 time = 1520
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=1520.05n

* CHECK dout0_16 Vdout0_16ck151 = 1.8 time = 1520
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=1520.05n

* CHECK dout0_17 Vdout0_17ck151 = 1.8 time = 1520
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=1520.05n

* CHECK dout0_18 Vdout0_18ck151 = 0 time = 1520
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=1520.05n

* CHECK dout0_19 Vdout0_19ck151 = 1.8 time = 1520
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=1520.05n

* CHECK dout0_20 Vdout0_20ck151 = 1.8 time = 1520
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=1520.05n

* CHECK dout0_21 Vdout0_21ck151 = 0 time = 1520
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=1520.05n

* CHECK dout0_22 Vdout0_22ck151 = 0 time = 1520
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=1520.05n

* CHECK dout0_23 Vdout0_23ck151 = 1.8 time = 1520
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=1520.05n

* CHECK dout0_24 Vdout0_24ck151 = 0 time = 1520
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=1520.05n

* CHECK dout0_25 Vdout0_25ck151 = 1.8 time = 1520
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=1520.05n

* CHECK dout0_26 Vdout0_26ck151 = 1.8 time = 1520
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=1520.05n

* CHECK dout0_27 Vdout0_27ck151 = 1.8 time = 1520
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=1520.05n

* CHECK dout0_28 Vdout0_28ck151 = 0 time = 1520
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=1520.05n

* CHECK dout0_29 Vdout0_29ck151 = 1.8 time = 1520
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=1520.05n

* CHECK dout0_30 Vdout0_30ck151 = 1.8 time = 1520
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=1520.05n

* CHECK dout0_31 Vdout0_31ck151 = 0 time = 1520
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=1520.05n

* CHECK dout0_32 Vdout0_32ck151 = 0 time = 1520
.meas tran vdout0_32ck151 FIND v(dout0_32) AT=1520.05n

* CHECK dout0_33 Vdout0_33ck151 = 1.8 time = 1520
.meas tran vdout0_33ck151 FIND v(dout0_33) AT=1520.05n

* CHECK dout0_34 Vdout0_34ck151 = 1.8 time = 1520
.meas tran vdout0_34ck151 FIND v(dout0_34) AT=1520.05n

* CHECK dout0_35 Vdout0_35ck151 = 1.8 time = 1520
.meas tran vdout0_35ck151 FIND v(dout0_35) AT=1520.05n

* CHECK dout0_36 Vdout0_36ck151 = 0 time = 1520
.meas tran vdout0_36ck151 FIND v(dout0_36) AT=1520.05n

* CHECK dout0_37 Vdout0_37ck151 = 1.8 time = 1520
.meas tran vdout0_37ck151 FIND v(dout0_37) AT=1520.05n

* CHECK dout0_38 Vdout0_38ck151 = 1.8 time = 1520
.meas tran vdout0_38ck151 FIND v(dout0_38) AT=1520.05n

* CHECK dout0_39 Vdout0_39ck151 = 1.8 time = 1520
.meas tran vdout0_39ck151 FIND v(dout0_39) AT=1520.05n

* CHECK dout0_40 Vdout0_40ck151 = 0 time = 1520
.meas tran vdout0_40ck151 FIND v(dout0_40) AT=1520.05n

* CHECK dout0_41 Vdout0_41ck151 = 0 time = 1520
.meas tran vdout0_41ck151 FIND v(dout0_41) AT=1520.05n

* CHECK dout0_42 Vdout0_42ck151 = 1.8 time = 1520
.meas tran vdout0_42ck151 FIND v(dout0_42) AT=1520.05n

* CHECK dout0_43 Vdout0_43ck151 = 0 time = 1520
.meas tran vdout0_43ck151 FIND v(dout0_43) AT=1520.05n

* CHECK dout0_44 Vdout0_44ck151 = 1.8 time = 1520
.meas tran vdout0_44ck151 FIND v(dout0_44) AT=1520.05n

* CHECK dout0_45 Vdout0_45ck151 = 0 time = 1520
.meas tran vdout0_45ck151 FIND v(dout0_45) AT=1520.05n

* CHECK dout0_46 Vdout0_46ck151 = 1.8 time = 1520
.meas tran vdout0_46ck151 FIND v(dout0_46) AT=1520.05n

* CHECK dout0_47 Vdout0_47ck151 = 1.8 time = 1520
.meas tran vdout0_47ck151 FIND v(dout0_47) AT=1520.05n

* CHECK dout0_48 Vdout0_48ck151 = 0 time = 1520
.meas tran vdout0_48ck151 FIND v(dout0_48) AT=1520.05n

* CHECK dout0_49 Vdout0_49ck151 = 0 time = 1520
.meas tran vdout0_49ck151 FIND v(dout0_49) AT=1520.05n

* CHECK dout0_50 Vdout0_50ck151 = 1.8 time = 1520
.meas tran vdout0_50ck151 FIND v(dout0_50) AT=1520.05n

* CHECK dout0_51 Vdout0_51ck151 = 1.8 time = 1520
.meas tran vdout0_51ck151 FIND v(dout0_51) AT=1520.05n

* CHECK dout0_52 Vdout0_52ck151 = 1.8 time = 1520
.meas tran vdout0_52ck151 FIND v(dout0_52) AT=1520.05n

* CHECK dout0_53 Vdout0_53ck151 = 0 time = 1520
.meas tran vdout0_53ck151 FIND v(dout0_53) AT=1520.05n

* CHECK dout0_54 Vdout0_54ck151 = 0 time = 1520
.meas tran vdout0_54ck151 FIND v(dout0_54) AT=1520.05n

* CHECK dout0_55 Vdout0_55ck151 = 1.8 time = 1520
.meas tran vdout0_55ck151 FIND v(dout0_55) AT=1520.05n

* CHECK dout0_56 Vdout0_56ck151 = 0 time = 1520
.meas tran vdout0_56ck151 FIND v(dout0_56) AT=1520.05n

* CHECK dout0_57 Vdout0_57ck151 = 0 time = 1520
.meas tran vdout0_57ck151 FIND v(dout0_57) AT=1520.05n

* CHECK dout0_58 Vdout0_58ck151 = 0 time = 1520
.meas tran vdout0_58ck151 FIND v(dout0_58) AT=1520.05n

* CHECK dout0_59 Vdout0_59ck151 = 0 time = 1520
.meas tran vdout0_59ck151 FIND v(dout0_59) AT=1520.05n

* CHECK dout0_60 Vdout0_60ck151 = 1.8 time = 1520
.meas tran vdout0_60ck151 FIND v(dout0_60) AT=1520.05n

* CHECK dout0_61 Vdout0_61ck151 = 0 time = 1520
.meas tran vdout0_61ck151 FIND v(dout0_61) AT=1520.05n

* CHECK dout0_62 Vdout0_62ck151 = 0 time = 1520
.meas tran vdout0_62ck151 FIND v(dout0_62) AT=1520.05n

* CHECK dout0_63 Vdout0_63ck151 = 1.8 time = 1520
.meas tran vdout0_63ck151 FIND v(dout0_63) AT=1520.05n

* CHECK dout0_64 Vdout0_64ck151 = 0 time = 1520
.meas tran vdout0_64ck151 FIND v(dout0_64) AT=1520.05n

* CHECK dout0_0 Vdout0_0ck154 = 0 time = 1550
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=1550.05n

* CHECK dout0_1 Vdout0_1ck154 = 1.8 time = 1550
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=1550.05n

* CHECK dout0_2 Vdout0_2ck154 = 0 time = 1550
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=1550.05n

* CHECK dout0_3 Vdout0_3ck154 = 0 time = 1550
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=1550.05n

* CHECK dout0_4 Vdout0_4ck154 = 1.8 time = 1550
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=1550.05n

* CHECK dout0_5 Vdout0_5ck154 = 0 time = 1550
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=1550.05n

* CHECK dout0_6 Vdout0_6ck154 = 1.8 time = 1550
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=1550.05n

* CHECK dout0_7 Vdout0_7ck154 = 0 time = 1550
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=1550.05n

* CHECK dout0_8 Vdout0_8ck154 = 0 time = 1550
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=1550.05n

* CHECK dout0_9 Vdout0_9ck154 = 1.8 time = 1550
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=1550.05n

* CHECK dout0_10 Vdout0_10ck154 = 1.8 time = 1550
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=1550.05n

* CHECK dout0_11 Vdout0_11ck154 = 0 time = 1550
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=1550.05n

* CHECK dout0_12 Vdout0_12ck154 = 0 time = 1550
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=1550.05n

* CHECK dout0_13 Vdout0_13ck154 = 0 time = 1550
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=1550.05n

* CHECK dout0_14 Vdout0_14ck154 = 0 time = 1550
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=1550.05n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 1550
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=1550.05n

* CHECK dout0_16 Vdout0_16ck154 = 0 time = 1550
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=1550.05n

* CHECK dout0_17 Vdout0_17ck154 = 1.8 time = 1550
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=1550.05n

* CHECK dout0_18 Vdout0_18ck154 = 0 time = 1550
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=1550.05n

* CHECK dout0_19 Vdout0_19ck154 = 0 time = 1550
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=1550.05n

* CHECK dout0_20 Vdout0_20ck154 = 1.8 time = 1550
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=1550.05n

* CHECK dout0_21 Vdout0_21ck154 = 0 time = 1550
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=1550.05n

* CHECK dout0_22 Vdout0_22ck154 = 1.8 time = 1550
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=1550.05n

* CHECK dout0_23 Vdout0_23ck154 = 0 time = 1550
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=1550.05n

* CHECK dout0_24 Vdout0_24ck154 = 0 time = 1550
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=1550.05n

* CHECK dout0_25 Vdout0_25ck154 = 0 time = 1550
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=1550.05n

* CHECK dout0_26 Vdout0_26ck154 = 1.8 time = 1550
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=1550.05n

* CHECK dout0_27 Vdout0_27ck154 = 0 time = 1550
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=1550.05n

* CHECK dout0_28 Vdout0_28ck154 = 0 time = 1550
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=1550.05n

* CHECK dout0_29 Vdout0_29ck154 = 0 time = 1550
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=1550.05n

* CHECK dout0_30 Vdout0_30ck154 = 1.8 time = 1550
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=1550.05n

* CHECK dout0_31 Vdout0_31ck154 = 0 time = 1550
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=1550.05n

* CHECK dout0_32 Vdout0_32ck154 = 1.8 time = 1550
.meas tran vdout0_32ck154 FIND v(dout0_32) AT=1550.05n

* CHECK dout0_33 Vdout0_33ck154 = 0 time = 1550
.meas tran vdout0_33ck154 FIND v(dout0_33) AT=1550.05n

* CHECK dout0_34 Vdout0_34ck154 = 1.8 time = 1550
.meas tran vdout0_34ck154 FIND v(dout0_34) AT=1550.05n

* CHECK dout0_35 Vdout0_35ck154 = 0 time = 1550
.meas tran vdout0_35ck154 FIND v(dout0_35) AT=1550.05n

* CHECK dout0_36 Vdout0_36ck154 = 1.8 time = 1550
.meas tran vdout0_36ck154 FIND v(dout0_36) AT=1550.05n

* CHECK dout0_37 Vdout0_37ck154 = 0 time = 1550
.meas tran vdout0_37ck154 FIND v(dout0_37) AT=1550.05n

* CHECK dout0_38 Vdout0_38ck154 = 0 time = 1550
.meas tran vdout0_38ck154 FIND v(dout0_38) AT=1550.05n

* CHECK dout0_39 Vdout0_39ck154 = 0 time = 1550
.meas tran vdout0_39ck154 FIND v(dout0_39) AT=1550.05n

* CHECK dout0_40 Vdout0_40ck154 = 1.8 time = 1550
.meas tran vdout0_40ck154 FIND v(dout0_40) AT=1550.05n

* CHECK dout0_41 Vdout0_41ck154 = 0 time = 1550
.meas tran vdout0_41ck154 FIND v(dout0_41) AT=1550.05n

* CHECK dout0_42 Vdout0_42ck154 = 1.8 time = 1550
.meas tran vdout0_42ck154 FIND v(dout0_42) AT=1550.05n

* CHECK dout0_43 Vdout0_43ck154 = 1.8 time = 1550
.meas tran vdout0_43ck154 FIND v(dout0_43) AT=1550.05n

* CHECK dout0_44 Vdout0_44ck154 = 0 time = 1550
.meas tran vdout0_44ck154 FIND v(dout0_44) AT=1550.05n

* CHECK dout0_45 Vdout0_45ck154 = 0 time = 1550
.meas tran vdout0_45ck154 FIND v(dout0_45) AT=1550.05n

* CHECK dout0_46 Vdout0_46ck154 = 0 time = 1550
.meas tran vdout0_46ck154 FIND v(dout0_46) AT=1550.05n

* CHECK dout0_47 Vdout0_47ck154 = 0 time = 1550
.meas tran vdout0_47ck154 FIND v(dout0_47) AT=1550.05n

* CHECK dout0_48 Vdout0_48ck154 = 0 time = 1550
.meas tran vdout0_48ck154 FIND v(dout0_48) AT=1550.05n

* CHECK dout0_49 Vdout0_49ck154 = 0 time = 1550
.meas tran vdout0_49ck154 FIND v(dout0_49) AT=1550.05n

* CHECK dout0_50 Vdout0_50ck154 = 0 time = 1550
.meas tran vdout0_50ck154 FIND v(dout0_50) AT=1550.05n

* CHECK dout0_51 Vdout0_51ck154 = 1.8 time = 1550
.meas tran vdout0_51ck154 FIND v(dout0_51) AT=1550.05n

* CHECK dout0_52 Vdout0_52ck154 = 0 time = 1550
.meas tran vdout0_52ck154 FIND v(dout0_52) AT=1550.05n

* CHECK dout0_53 Vdout0_53ck154 = 1.8 time = 1550
.meas tran vdout0_53ck154 FIND v(dout0_53) AT=1550.05n

* CHECK dout0_54 Vdout0_54ck154 = 0 time = 1550
.meas tran vdout0_54ck154 FIND v(dout0_54) AT=1550.05n

* CHECK dout0_55 Vdout0_55ck154 = 1.8 time = 1550
.meas tran vdout0_55ck154 FIND v(dout0_55) AT=1550.05n

* CHECK dout0_56 Vdout0_56ck154 = 0 time = 1550
.meas tran vdout0_56ck154 FIND v(dout0_56) AT=1550.05n

* CHECK dout0_57 Vdout0_57ck154 = 1.8 time = 1550
.meas tran vdout0_57ck154 FIND v(dout0_57) AT=1550.05n

* CHECK dout0_58 Vdout0_58ck154 = 1.8 time = 1550
.meas tran vdout0_58ck154 FIND v(dout0_58) AT=1550.05n

* CHECK dout0_59 Vdout0_59ck154 = 0 time = 1550
.meas tran vdout0_59ck154 FIND v(dout0_59) AT=1550.05n

* CHECK dout0_60 Vdout0_60ck154 = 0 time = 1550
.meas tran vdout0_60ck154 FIND v(dout0_60) AT=1550.05n

* CHECK dout0_61 Vdout0_61ck154 = 1.8 time = 1550
.meas tran vdout0_61ck154 FIND v(dout0_61) AT=1550.05n

* CHECK dout0_62 Vdout0_62ck154 = 0 time = 1550
.meas tran vdout0_62ck154 FIND v(dout0_62) AT=1550.05n

* CHECK dout0_63 Vdout0_63ck154 = 1.8 time = 1550
.meas tran vdout0_63ck154 FIND v(dout0_63) AT=1550.05n

* CHECK dout0_64 Vdout0_64ck154 = 0 time = 1550
.meas tran vdout0_64ck154 FIND v(dout0_64) AT=1550.05n

* CHECK dout0_0 Vdout0_0ck157 = 0 time = 1580
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=1580.05n

* CHECK dout0_1 Vdout0_1ck157 = 1.8 time = 1580
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=1580.05n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 1580
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=1580.05n

* CHECK dout0_3 Vdout0_3ck157 = 0 time = 1580
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=1580.05n

* CHECK dout0_4 Vdout0_4ck157 = 1.8 time = 1580
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=1580.05n

* CHECK dout0_5 Vdout0_5ck157 = 1.8 time = 1580
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=1580.05n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 1580
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=1580.05n

* CHECK dout0_7 Vdout0_7ck157 = 1.8 time = 1580
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=1580.05n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 1580
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=1580.05n

* CHECK dout0_9 Vdout0_9ck157 = 1.8 time = 1580
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=1580.05n

* CHECK dout0_10 Vdout0_10ck157 = 0 time = 1580
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=1580.05n

* CHECK dout0_11 Vdout0_11ck157 = 1.8 time = 1580
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=1580.05n

* CHECK dout0_12 Vdout0_12ck157 = 1.8 time = 1580
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=1580.05n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 1580
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=1580.05n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 1580
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=1580.05n

* CHECK dout0_15 Vdout0_15ck157 = 1.8 time = 1580
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=1580.05n

* CHECK dout0_16 Vdout0_16ck157 = 0 time = 1580
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=1580.05n

* CHECK dout0_17 Vdout0_17ck157 = 1.8 time = 1580
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=1580.05n

* CHECK dout0_18 Vdout0_18ck157 = 1.8 time = 1580
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=1580.05n

* CHECK dout0_19 Vdout0_19ck157 = 0 time = 1580
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=1580.05n

* CHECK dout0_20 Vdout0_20ck157 = 0 time = 1580
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=1580.05n

* CHECK dout0_21 Vdout0_21ck157 = 0 time = 1580
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=1580.05n

* CHECK dout0_22 Vdout0_22ck157 = 0 time = 1580
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=1580.05n

* CHECK dout0_23 Vdout0_23ck157 = 1.8 time = 1580
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=1580.05n

* CHECK dout0_24 Vdout0_24ck157 = 1.8 time = 1580
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=1580.05n

* CHECK dout0_25 Vdout0_25ck157 = 1.8 time = 1580
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=1580.05n

* CHECK dout0_26 Vdout0_26ck157 = 1.8 time = 1580
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=1580.05n

* CHECK dout0_27 Vdout0_27ck157 = 1.8 time = 1580
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=1580.05n

* CHECK dout0_28 Vdout0_28ck157 = 0 time = 1580
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=1580.05n

* CHECK dout0_29 Vdout0_29ck157 = 0 time = 1580
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=1580.05n

* CHECK dout0_30 Vdout0_30ck157 = 1.8 time = 1580
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=1580.05n

* CHECK dout0_31 Vdout0_31ck157 = 1.8 time = 1580
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=1580.05n

* CHECK dout0_32 Vdout0_32ck157 = 0 time = 1580
.meas tran vdout0_32ck157 FIND v(dout0_32) AT=1580.05n

* CHECK dout0_33 Vdout0_33ck157 = 1.8 time = 1580
.meas tran vdout0_33ck157 FIND v(dout0_33) AT=1580.05n

* CHECK dout0_34 Vdout0_34ck157 = 0 time = 1580
.meas tran vdout0_34ck157 FIND v(dout0_34) AT=1580.05n

* CHECK dout0_35 Vdout0_35ck157 = 1.8 time = 1580
.meas tran vdout0_35ck157 FIND v(dout0_35) AT=1580.05n

* CHECK dout0_36 Vdout0_36ck157 = 1.8 time = 1580
.meas tran vdout0_36ck157 FIND v(dout0_36) AT=1580.05n

* CHECK dout0_37 Vdout0_37ck157 = 1.8 time = 1580
.meas tran vdout0_37ck157 FIND v(dout0_37) AT=1580.05n

* CHECK dout0_38 Vdout0_38ck157 = 0 time = 1580
.meas tran vdout0_38ck157 FIND v(dout0_38) AT=1580.05n

* CHECK dout0_39 Vdout0_39ck157 = 0 time = 1580
.meas tran vdout0_39ck157 FIND v(dout0_39) AT=1580.05n

* CHECK dout0_40 Vdout0_40ck157 = 0 time = 1580
.meas tran vdout0_40ck157 FIND v(dout0_40) AT=1580.05n

* CHECK dout0_41 Vdout0_41ck157 = 1.8 time = 1580
.meas tran vdout0_41ck157 FIND v(dout0_41) AT=1580.05n

* CHECK dout0_42 Vdout0_42ck157 = 0 time = 1580
.meas tran vdout0_42ck157 FIND v(dout0_42) AT=1580.05n

* CHECK dout0_43 Vdout0_43ck157 = 0 time = 1580
.meas tran vdout0_43ck157 FIND v(dout0_43) AT=1580.05n

* CHECK dout0_44 Vdout0_44ck157 = 1.8 time = 1580
.meas tran vdout0_44ck157 FIND v(dout0_44) AT=1580.05n

* CHECK dout0_45 Vdout0_45ck157 = 0 time = 1580
.meas tran vdout0_45ck157 FIND v(dout0_45) AT=1580.05n

* CHECK dout0_46 Vdout0_46ck157 = 0 time = 1580
.meas tran vdout0_46ck157 FIND v(dout0_46) AT=1580.05n

* CHECK dout0_47 Vdout0_47ck157 = 0 time = 1580
.meas tran vdout0_47ck157 FIND v(dout0_47) AT=1580.05n

* CHECK dout0_48 Vdout0_48ck157 = 0 time = 1580
.meas tran vdout0_48ck157 FIND v(dout0_48) AT=1580.05n

* CHECK dout0_49 Vdout0_49ck157 = 1.8 time = 1580
.meas tran vdout0_49ck157 FIND v(dout0_49) AT=1580.05n

* CHECK dout0_50 Vdout0_50ck157 = 1.8 time = 1580
.meas tran vdout0_50ck157 FIND v(dout0_50) AT=1580.05n

* CHECK dout0_51 Vdout0_51ck157 = 0 time = 1580
.meas tran vdout0_51ck157 FIND v(dout0_51) AT=1580.05n

* CHECK dout0_52 Vdout0_52ck157 = 0 time = 1580
.meas tran vdout0_52ck157 FIND v(dout0_52) AT=1580.05n

* CHECK dout0_53 Vdout0_53ck157 = 0 time = 1580
.meas tran vdout0_53ck157 FIND v(dout0_53) AT=1580.05n

* CHECK dout0_54 Vdout0_54ck157 = 0 time = 1580
.meas tran vdout0_54ck157 FIND v(dout0_54) AT=1580.05n

* CHECK dout0_55 Vdout0_55ck157 = 1.8 time = 1580
.meas tran vdout0_55ck157 FIND v(dout0_55) AT=1580.05n

* CHECK dout0_56 Vdout0_56ck157 = 1.8 time = 1580
.meas tran vdout0_56ck157 FIND v(dout0_56) AT=1580.05n

* CHECK dout0_57 Vdout0_57ck157 = 0 time = 1580
.meas tran vdout0_57ck157 FIND v(dout0_57) AT=1580.05n

* CHECK dout0_58 Vdout0_58ck157 = 1.8 time = 1580
.meas tran vdout0_58ck157 FIND v(dout0_58) AT=1580.05n

* CHECK dout0_59 Vdout0_59ck157 = 1.8 time = 1580
.meas tran vdout0_59ck157 FIND v(dout0_59) AT=1580.05n

* CHECK dout0_60 Vdout0_60ck157 = 0 time = 1580
.meas tran vdout0_60ck157 FIND v(dout0_60) AT=1580.05n

* CHECK dout0_61 Vdout0_61ck157 = 1.8 time = 1580
.meas tran vdout0_61ck157 FIND v(dout0_61) AT=1580.05n

* CHECK dout0_62 Vdout0_62ck157 = 0 time = 1580
.meas tran vdout0_62ck157 FIND v(dout0_62) AT=1580.05n

* CHECK dout0_63 Vdout0_63ck157 = 0 time = 1580
.meas tran vdout0_63ck157 FIND v(dout0_63) AT=1580.05n

* CHECK dout0_64 Vdout0_64ck157 = 0 time = 1580
.meas tran vdout0_64ck157 FIND v(dout0_64) AT=1580.05n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 1610
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=1610.05n

* CHECK dout0_1 Vdout0_1ck160 = 1.8 time = 1610
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=1610.05n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 1610
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=1610.05n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 1610
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=1610.05n

* CHECK dout0_4 Vdout0_4ck160 = 1.8 time = 1610
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=1610.05n

* CHECK dout0_5 Vdout0_5ck160 = 0 time = 1610
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=1610.05n

* CHECK dout0_6 Vdout0_6ck160 = 1.8 time = 1610
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=1610.05n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 1610
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=1610.05n

* CHECK dout0_8 Vdout0_8ck160 = 0 time = 1610
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=1610.05n

* CHECK dout0_9 Vdout0_9ck160 = 1.8 time = 1610
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=1610.05n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 1610
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=1610.05n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 1610
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=1610.05n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 1610
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=1610.05n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 1610
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=1610.05n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 1610
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=1610.05n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 1610
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=1610.05n

* CHECK dout0_16 Vdout0_16ck160 = 0 time = 1610
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=1610.05n

* CHECK dout0_17 Vdout0_17ck160 = 1.8 time = 1610
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=1610.05n

* CHECK dout0_18 Vdout0_18ck160 = 0 time = 1610
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=1610.05n

* CHECK dout0_19 Vdout0_19ck160 = 0 time = 1610
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=1610.05n

* CHECK dout0_20 Vdout0_20ck160 = 1.8 time = 1610
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=1610.05n

* CHECK dout0_21 Vdout0_21ck160 = 0 time = 1610
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=1610.05n

* CHECK dout0_22 Vdout0_22ck160 = 1.8 time = 1610
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=1610.05n

* CHECK dout0_23 Vdout0_23ck160 = 0 time = 1610
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=1610.05n

* CHECK dout0_24 Vdout0_24ck160 = 0 time = 1610
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=1610.05n

* CHECK dout0_25 Vdout0_25ck160 = 0 time = 1610
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=1610.05n

* CHECK dout0_26 Vdout0_26ck160 = 1.8 time = 1610
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=1610.05n

* CHECK dout0_27 Vdout0_27ck160 = 0 time = 1610
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=1610.05n

* CHECK dout0_28 Vdout0_28ck160 = 0 time = 1610
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=1610.05n

* CHECK dout0_29 Vdout0_29ck160 = 0 time = 1610
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=1610.05n

* CHECK dout0_30 Vdout0_30ck160 = 1.8 time = 1610
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=1610.05n

* CHECK dout0_31 Vdout0_31ck160 = 0 time = 1610
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=1610.05n

* CHECK dout0_32 Vdout0_32ck160 = 1.8 time = 1610
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=1610.05n

* CHECK dout0_33 Vdout0_33ck160 = 0 time = 1610
.meas tran vdout0_33ck160 FIND v(dout0_33) AT=1610.05n

* CHECK dout0_34 Vdout0_34ck160 = 1.8 time = 1610
.meas tran vdout0_34ck160 FIND v(dout0_34) AT=1610.05n

* CHECK dout0_35 Vdout0_35ck160 = 0 time = 1610
.meas tran vdout0_35ck160 FIND v(dout0_35) AT=1610.05n

* CHECK dout0_36 Vdout0_36ck160 = 1.8 time = 1610
.meas tran vdout0_36ck160 FIND v(dout0_36) AT=1610.05n

* CHECK dout0_37 Vdout0_37ck160 = 0 time = 1610
.meas tran vdout0_37ck160 FIND v(dout0_37) AT=1610.05n

* CHECK dout0_38 Vdout0_38ck160 = 0 time = 1610
.meas tran vdout0_38ck160 FIND v(dout0_38) AT=1610.05n

* CHECK dout0_39 Vdout0_39ck160 = 0 time = 1610
.meas tran vdout0_39ck160 FIND v(dout0_39) AT=1610.05n

* CHECK dout0_40 Vdout0_40ck160 = 1.8 time = 1610
.meas tran vdout0_40ck160 FIND v(dout0_40) AT=1610.05n

* CHECK dout0_41 Vdout0_41ck160 = 0 time = 1610
.meas tran vdout0_41ck160 FIND v(dout0_41) AT=1610.05n

* CHECK dout0_42 Vdout0_42ck160 = 1.8 time = 1610
.meas tran vdout0_42ck160 FIND v(dout0_42) AT=1610.05n

* CHECK dout0_43 Vdout0_43ck160 = 1.8 time = 1610
.meas tran vdout0_43ck160 FIND v(dout0_43) AT=1610.05n

* CHECK dout0_44 Vdout0_44ck160 = 0 time = 1610
.meas tran vdout0_44ck160 FIND v(dout0_44) AT=1610.05n

* CHECK dout0_45 Vdout0_45ck160 = 0 time = 1610
.meas tran vdout0_45ck160 FIND v(dout0_45) AT=1610.05n

* CHECK dout0_46 Vdout0_46ck160 = 0 time = 1610
.meas tran vdout0_46ck160 FIND v(dout0_46) AT=1610.05n

* CHECK dout0_47 Vdout0_47ck160 = 0 time = 1610
.meas tran vdout0_47ck160 FIND v(dout0_47) AT=1610.05n

* CHECK dout0_48 Vdout0_48ck160 = 0 time = 1610
.meas tran vdout0_48ck160 FIND v(dout0_48) AT=1610.05n

* CHECK dout0_49 Vdout0_49ck160 = 0 time = 1610
.meas tran vdout0_49ck160 FIND v(dout0_49) AT=1610.05n

* CHECK dout0_50 Vdout0_50ck160 = 0 time = 1610
.meas tran vdout0_50ck160 FIND v(dout0_50) AT=1610.05n

* CHECK dout0_51 Vdout0_51ck160 = 1.8 time = 1610
.meas tran vdout0_51ck160 FIND v(dout0_51) AT=1610.05n

* CHECK dout0_52 Vdout0_52ck160 = 0 time = 1610
.meas tran vdout0_52ck160 FIND v(dout0_52) AT=1610.05n

* CHECK dout0_53 Vdout0_53ck160 = 1.8 time = 1610
.meas tran vdout0_53ck160 FIND v(dout0_53) AT=1610.05n

* CHECK dout0_54 Vdout0_54ck160 = 0 time = 1610
.meas tran vdout0_54ck160 FIND v(dout0_54) AT=1610.05n

* CHECK dout0_55 Vdout0_55ck160 = 1.8 time = 1610
.meas tran vdout0_55ck160 FIND v(dout0_55) AT=1610.05n

* CHECK dout0_56 Vdout0_56ck160 = 0 time = 1610
.meas tran vdout0_56ck160 FIND v(dout0_56) AT=1610.05n

* CHECK dout0_57 Vdout0_57ck160 = 1.8 time = 1610
.meas tran vdout0_57ck160 FIND v(dout0_57) AT=1610.05n

* CHECK dout0_58 Vdout0_58ck160 = 1.8 time = 1610
.meas tran vdout0_58ck160 FIND v(dout0_58) AT=1610.05n

* CHECK dout0_59 Vdout0_59ck160 = 0 time = 1610
.meas tran vdout0_59ck160 FIND v(dout0_59) AT=1610.05n

* CHECK dout0_60 Vdout0_60ck160 = 0 time = 1610
.meas tran vdout0_60ck160 FIND v(dout0_60) AT=1610.05n

* CHECK dout0_61 Vdout0_61ck160 = 1.8 time = 1610
.meas tran vdout0_61ck160 FIND v(dout0_61) AT=1610.05n

* CHECK dout0_62 Vdout0_62ck160 = 0 time = 1610
.meas tran vdout0_62ck160 FIND v(dout0_62) AT=1610.05n

* CHECK dout0_63 Vdout0_63ck160 = 1.8 time = 1610
.meas tran vdout0_63ck160 FIND v(dout0_63) AT=1610.05n

* CHECK dout0_64 Vdout0_64ck160 = 0 time = 1610
.meas tran vdout0_64ck160 FIND v(dout0_64) AT=1610.05n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 1660
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=1660.05n

* CHECK dout0_1 Vdout0_1ck165 = 1.8 time = 1660
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=1660.05n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 1660
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=1660.05n

* CHECK dout0_3 Vdout0_3ck165 = 0 time = 1660
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=1660.05n

* CHECK dout0_4 Vdout0_4ck165 = 1.8 time = 1660
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=1660.05n

* CHECK dout0_5 Vdout0_5ck165 = 1.8 time = 1660
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=1660.05n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 1660
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=1660.05n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 1660
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=1660.05n

* CHECK dout0_8 Vdout0_8ck165 = 1.8 time = 1660
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=1660.05n

* CHECK dout0_9 Vdout0_9ck165 = 1.8 time = 1660
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=1660.05n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 1660
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=1660.05n

* CHECK dout0_11 Vdout0_11ck165 = 1.8 time = 1660
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=1660.05n

* CHECK dout0_12 Vdout0_12ck165 = 1.8 time = 1660
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=1660.05n

* CHECK dout0_13 Vdout0_13ck165 = 0 time = 1660
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=1660.05n

* CHECK dout0_14 Vdout0_14ck165 = 1.8 time = 1660
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=1660.05n

* CHECK dout0_15 Vdout0_15ck165 = 1.8 time = 1660
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=1660.05n

* CHECK dout0_16 Vdout0_16ck165 = 0 time = 1660
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=1660.05n

* CHECK dout0_17 Vdout0_17ck165 = 1.8 time = 1660
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=1660.05n

* CHECK dout0_18 Vdout0_18ck165 = 1.8 time = 1660
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=1660.05n

* CHECK dout0_19 Vdout0_19ck165 = 0 time = 1660
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=1660.05n

* CHECK dout0_20 Vdout0_20ck165 = 0 time = 1660
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=1660.05n

* CHECK dout0_21 Vdout0_21ck165 = 0 time = 1660
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=1660.05n

* CHECK dout0_22 Vdout0_22ck165 = 0 time = 1660
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=1660.05n

* CHECK dout0_23 Vdout0_23ck165 = 1.8 time = 1660
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=1660.05n

* CHECK dout0_24 Vdout0_24ck165 = 1.8 time = 1660
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=1660.05n

* CHECK dout0_25 Vdout0_25ck165 = 1.8 time = 1660
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=1660.05n

* CHECK dout0_26 Vdout0_26ck165 = 1.8 time = 1660
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=1660.05n

* CHECK dout0_27 Vdout0_27ck165 = 1.8 time = 1660
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=1660.05n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 1660
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=1660.05n

* CHECK dout0_29 Vdout0_29ck165 = 0 time = 1660
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=1660.05n

* CHECK dout0_30 Vdout0_30ck165 = 1.8 time = 1660
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=1660.05n

* CHECK dout0_31 Vdout0_31ck165 = 1.8 time = 1660
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=1660.05n

* CHECK dout0_32 Vdout0_32ck165 = 0 time = 1660
.meas tran vdout0_32ck165 FIND v(dout0_32) AT=1660.05n

* CHECK dout0_33 Vdout0_33ck165 = 1.8 time = 1660
.meas tran vdout0_33ck165 FIND v(dout0_33) AT=1660.05n

* CHECK dout0_34 Vdout0_34ck165 = 0 time = 1660
.meas tran vdout0_34ck165 FIND v(dout0_34) AT=1660.05n

* CHECK dout0_35 Vdout0_35ck165 = 1.8 time = 1660
.meas tran vdout0_35ck165 FIND v(dout0_35) AT=1660.05n

* CHECK dout0_36 Vdout0_36ck165 = 1.8 time = 1660
.meas tran vdout0_36ck165 FIND v(dout0_36) AT=1660.05n

* CHECK dout0_37 Vdout0_37ck165 = 1.8 time = 1660
.meas tran vdout0_37ck165 FIND v(dout0_37) AT=1660.05n

* CHECK dout0_38 Vdout0_38ck165 = 0 time = 1660
.meas tran vdout0_38ck165 FIND v(dout0_38) AT=1660.05n

* CHECK dout0_39 Vdout0_39ck165 = 0 time = 1660
.meas tran vdout0_39ck165 FIND v(dout0_39) AT=1660.05n

* CHECK dout0_40 Vdout0_40ck165 = 0 time = 1660
.meas tran vdout0_40ck165 FIND v(dout0_40) AT=1660.05n

* CHECK dout0_41 Vdout0_41ck165 = 1.8 time = 1660
.meas tran vdout0_41ck165 FIND v(dout0_41) AT=1660.05n

* CHECK dout0_42 Vdout0_42ck165 = 0 time = 1660
.meas tran vdout0_42ck165 FIND v(dout0_42) AT=1660.05n

* CHECK dout0_43 Vdout0_43ck165 = 0 time = 1660
.meas tran vdout0_43ck165 FIND v(dout0_43) AT=1660.05n

* CHECK dout0_44 Vdout0_44ck165 = 1.8 time = 1660
.meas tran vdout0_44ck165 FIND v(dout0_44) AT=1660.05n

* CHECK dout0_45 Vdout0_45ck165 = 0 time = 1660
.meas tran vdout0_45ck165 FIND v(dout0_45) AT=1660.05n

* CHECK dout0_46 Vdout0_46ck165 = 0 time = 1660
.meas tran vdout0_46ck165 FIND v(dout0_46) AT=1660.05n

* CHECK dout0_47 Vdout0_47ck165 = 0 time = 1660
.meas tran vdout0_47ck165 FIND v(dout0_47) AT=1660.05n

* CHECK dout0_48 Vdout0_48ck165 = 0 time = 1660
.meas tran vdout0_48ck165 FIND v(dout0_48) AT=1660.05n

* CHECK dout0_49 Vdout0_49ck165 = 1.8 time = 1660
.meas tran vdout0_49ck165 FIND v(dout0_49) AT=1660.05n

* CHECK dout0_50 Vdout0_50ck165 = 1.8 time = 1660
.meas tran vdout0_50ck165 FIND v(dout0_50) AT=1660.05n

* CHECK dout0_51 Vdout0_51ck165 = 0 time = 1660
.meas tran vdout0_51ck165 FIND v(dout0_51) AT=1660.05n

* CHECK dout0_52 Vdout0_52ck165 = 0 time = 1660
.meas tran vdout0_52ck165 FIND v(dout0_52) AT=1660.05n

* CHECK dout0_53 Vdout0_53ck165 = 0 time = 1660
.meas tran vdout0_53ck165 FIND v(dout0_53) AT=1660.05n

* CHECK dout0_54 Vdout0_54ck165 = 0 time = 1660
.meas tran vdout0_54ck165 FIND v(dout0_54) AT=1660.05n

* CHECK dout0_55 Vdout0_55ck165 = 1.8 time = 1660
.meas tran vdout0_55ck165 FIND v(dout0_55) AT=1660.05n

* CHECK dout0_56 Vdout0_56ck165 = 1.8 time = 1660
.meas tran vdout0_56ck165 FIND v(dout0_56) AT=1660.05n

* CHECK dout0_57 Vdout0_57ck165 = 0 time = 1660
.meas tran vdout0_57ck165 FIND v(dout0_57) AT=1660.05n

* CHECK dout0_58 Vdout0_58ck165 = 1.8 time = 1660
.meas tran vdout0_58ck165 FIND v(dout0_58) AT=1660.05n

* CHECK dout0_59 Vdout0_59ck165 = 1.8 time = 1660
.meas tran vdout0_59ck165 FIND v(dout0_59) AT=1660.05n

* CHECK dout0_60 Vdout0_60ck165 = 0 time = 1660
.meas tran vdout0_60ck165 FIND v(dout0_60) AT=1660.05n

* CHECK dout0_61 Vdout0_61ck165 = 1.8 time = 1660
.meas tran vdout0_61ck165 FIND v(dout0_61) AT=1660.05n

* CHECK dout0_62 Vdout0_62ck165 = 0 time = 1660
.meas tran vdout0_62ck165 FIND v(dout0_62) AT=1660.05n

* CHECK dout0_63 Vdout0_63ck165 = 0 time = 1660
.meas tran vdout0_63ck165 FIND v(dout0_63) AT=1660.05n

* CHECK dout0_64 Vdout0_64ck165 = 0 time = 1660
.meas tran vdout0_64ck165 FIND v(dout0_64) AT=1660.05n

* CHECK dout0_0 Vdout0_0ck168 = 1.8 time = 1690
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=1690.05n

* CHECK dout0_1 Vdout0_1ck168 = 1.8 time = 1690
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=1690.05n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 1690
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=1690.05n

* CHECK dout0_3 Vdout0_3ck168 = 1.8 time = 1690
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=1690.05n

* CHECK dout0_4 Vdout0_4ck168 = 0 time = 1690
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=1690.05n

* CHECK dout0_5 Vdout0_5ck168 = 0 time = 1690
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=1690.05n

* CHECK dout0_6 Vdout0_6ck168 = 1.8 time = 1690
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=1690.05n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 1690
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=1690.05n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 1690
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=1690.05n

* CHECK dout0_9 Vdout0_9ck168 = 0 time = 1690
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=1690.05n

* CHECK dout0_10 Vdout0_10ck168 = 1.8 time = 1690
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=1690.05n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 1690
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=1690.05n

* CHECK dout0_12 Vdout0_12ck168 = 1.8 time = 1690
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=1690.05n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 1690
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=1690.05n

* CHECK dout0_14 Vdout0_14ck168 = 1.8 time = 1690
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=1690.05n

* CHECK dout0_15 Vdout0_15ck168 = 0 time = 1690
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=1690.05n

* CHECK dout0_16 Vdout0_16ck168 = 0 time = 1690
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=1690.05n

* CHECK dout0_17 Vdout0_17ck168 = 1.8 time = 1690
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=1690.05n

* CHECK dout0_18 Vdout0_18ck168 = 1.8 time = 1690
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=1690.05n

* CHECK dout0_19 Vdout0_19ck168 = 1.8 time = 1690
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=1690.05n

* CHECK dout0_20 Vdout0_20ck168 = 1.8 time = 1690
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=1690.05n

* CHECK dout0_21 Vdout0_21ck168 = 0 time = 1690
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=1690.05n

* CHECK dout0_22 Vdout0_22ck168 = 1.8 time = 1690
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=1690.05n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 1690
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=1690.05n

* CHECK dout0_24 Vdout0_24ck168 = 0 time = 1690
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=1690.05n

* CHECK dout0_25 Vdout0_25ck168 = 0 time = 1690
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=1690.05n

* CHECK dout0_26 Vdout0_26ck168 = 0 time = 1690
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=1690.05n

* CHECK dout0_27 Vdout0_27ck168 = 1.8 time = 1690
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=1690.05n

* CHECK dout0_28 Vdout0_28ck168 = 1.8 time = 1690
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=1690.05n

* CHECK dout0_29 Vdout0_29ck168 = 1.8 time = 1690
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=1690.05n

* CHECK dout0_30 Vdout0_30ck168 = 0 time = 1690
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=1690.05n

* CHECK dout0_31 Vdout0_31ck168 = 0 time = 1690
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=1690.05n

* CHECK dout0_32 Vdout0_32ck168 = 0 time = 1690
.meas tran vdout0_32ck168 FIND v(dout0_32) AT=1690.05n

* CHECK dout0_33 Vdout0_33ck168 = 1.8 time = 1690
.meas tran vdout0_33ck168 FIND v(dout0_33) AT=1690.05n

* CHECK dout0_34 Vdout0_34ck168 = 0 time = 1690
.meas tran vdout0_34ck168 FIND v(dout0_34) AT=1690.05n

* CHECK dout0_35 Vdout0_35ck168 = 1.8 time = 1690
.meas tran vdout0_35ck168 FIND v(dout0_35) AT=1690.05n

* CHECK dout0_36 Vdout0_36ck168 = 1.8 time = 1690
.meas tran vdout0_36ck168 FIND v(dout0_36) AT=1690.05n

* CHECK dout0_37 Vdout0_37ck168 = 0 time = 1690
.meas tran vdout0_37ck168 FIND v(dout0_37) AT=1690.05n

* CHECK dout0_38 Vdout0_38ck168 = 1.8 time = 1690
.meas tran vdout0_38ck168 FIND v(dout0_38) AT=1690.05n

* CHECK dout0_39 Vdout0_39ck168 = 1.8 time = 1690
.meas tran vdout0_39ck168 FIND v(dout0_39) AT=1690.05n

* CHECK dout0_40 Vdout0_40ck168 = 0 time = 1690
.meas tran vdout0_40ck168 FIND v(dout0_40) AT=1690.05n

* CHECK dout0_41 Vdout0_41ck168 = 0 time = 1690
.meas tran vdout0_41ck168 FIND v(dout0_41) AT=1690.05n

* CHECK dout0_42 Vdout0_42ck168 = 1.8 time = 1690
.meas tran vdout0_42ck168 FIND v(dout0_42) AT=1690.05n

* CHECK dout0_43 Vdout0_43ck168 = 1.8 time = 1690
.meas tran vdout0_43ck168 FIND v(dout0_43) AT=1690.05n

* CHECK dout0_44 Vdout0_44ck168 = 0 time = 1690
.meas tran vdout0_44ck168 FIND v(dout0_44) AT=1690.05n

* CHECK dout0_45 Vdout0_45ck168 = 1.8 time = 1690
.meas tran vdout0_45ck168 FIND v(dout0_45) AT=1690.05n

* CHECK dout0_46 Vdout0_46ck168 = 1.8 time = 1690
.meas tran vdout0_46ck168 FIND v(dout0_46) AT=1690.05n

* CHECK dout0_47 Vdout0_47ck168 = 0 time = 1690
.meas tran vdout0_47ck168 FIND v(dout0_47) AT=1690.05n

* CHECK dout0_48 Vdout0_48ck168 = 0 time = 1690
.meas tran vdout0_48ck168 FIND v(dout0_48) AT=1690.05n

* CHECK dout0_49 Vdout0_49ck168 = 1.8 time = 1690
.meas tran vdout0_49ck168 FIND v(dout0_49) AT=1690.05n

* CHECK dout0_50 Vdout0_50ck168 = 1.8 time = 1690
.meas tran vdout0_50ck168 FIND v(dout0_50) AT=1690.05n

* CHECK dout0_51 Vdout0_51ck168 = 0 time = 1690
.meas tran vdout0_51ck168 FIND v(dout0_51) AT=1690.05n

* CHECK dout0_52 Vdout0_52ck168 = 0 time = 1690
.meas tran vdout0_52ck168 FIND v(dout0_52) AT=1690.05n

* CHECK dout0_53 Vdout0_53ck168 = 1.8 time = 1690
.meas tran vdout0_53ck168 FIND v(dout0_53) AT=1690.05n

* CHECK dout0_54 Vdout0_54ck168 = 0 time = 1690
.meas tran vdout0_54ck168 FIND v(dout0_54) AT=1690.05n

* CHECK dout0_55 Vdout0_55ck168 = 1.8 time = 1690
.meas tran vdout0_55ck168 FIND v(dout0_55) AT=1690.05n

* CHECK dout0_56 Vdout0_56ck168 = 1.8 time = 1690
.meas tran vdout0_56ck168 FIND v(dout0_56) AT=1690.05n

* CHECK dout0_57 Vdout0_57ck168 = 1.8 time = 1690
.meas tran vdout0_57ck168 FIND v(dout0_57) AT=1690.05n

* CHECK dout0_58 Vdout0_58ck168 = 0 time = 1690
.meas tran vdout0_58ck168 FIND v(dout0_58) AT=1690.05n

* CHECK dout0_59 Vdout0_59ck168 = 0 time = 1690
.meas tran vdout0_59ck168 FIND v(dout0_59) AT=1690.05n

* CHECK dout0_60 Vdout0_60ck168 = 1.8 time = 1690
.meas tran vdout0_60ck168 FIND v(dout0_60) AT=1690.05n

* CHECK dout0_61 Vdout0_61ck168 = 1.8 time = 1690
.meas tran vdout0_61ck168 FIND v(dout0_61) AT=1690.05n

* CHECK dout0_62 Vdout0_62ck168 = 1.8 time = 1690
.meas tran vdout0_62ck168 FIND v(dout0_62) AT=1690.05n

* CHECK dout0_63 Vdout0_63ck168 = 1.8 time = 1690
.meas tran vdout0_63ck168 FIND v(dout0_63) AT=1690.05n

* CHECK dout0_64 Vdout0_64ck168 = 0 time = 1690
.meas tran vdout0_64ck168 FIND v(dout0_64) AT=1690.05n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 1700
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=1700.05n

* CHECK dout0_1 Vdout0_1ck169 = 1.8 time = 1700
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=1700.05n

* CHECK dout0_2 Vdout0_2ck169 = 1.8 time = 1700
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=1700.05n

* CHECK dout0_3 Vdout0_3ck169 = 0 time = 1700
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=1700.05n

* CHECK dout0_4 Vdout0_4ck169 = 1.8 time = 1700
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=1700.05n

* CHECK dout0_5 Vdout0_5ck169 = 1.8 time = 1700
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=1700.05n

* CHECK dout0_6 Vdout0_6ck169 = 1.8 time = 1700
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=1700.05n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 1700
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=1700.05n

* CHECK dout0_8 Vdout0_8ck169 = 1.8 time = 1700
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=1700.05n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 1700
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=1700.05n

* CHECK dout0_10 Vdout0_10ck169 = 1.8 time = 1700
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=1700.05n

* CHECK dout0_11 Vdout0_11ck169 = 0 time = 1700
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=1700.05n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 1700
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=1700.05n

* CHECK dout0_13 Vdout0_13ck169 = 1.8 time = 1700
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=1700.05n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 1700
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=1700.05n

* CHECK dout0_15 Vdout0_15ck169 = 0 time = 1700
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=1700.05n

* CHECK dout0_16 Vdout0_16ck169 = 0 time = 1700
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=1700.05n

* CHECK dout0_17 Vdout0_17ck169 = 1.8 time = 1700
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=1700.05n

* CHECK dout0_18 Vdout0_18ck169 = 1.8 time = 1700
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=1700.05n

* CHECK dout0_19 Vdout0_19ck169 = 0 time = 1700
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=1700.05n

* CHECK dout0_20 Vdout0_20ck169 = 1.8 time = 1700
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=1700.05n

* CHECK dout0_21 Vdout0_21ck169 = 1.8 time = 1700
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=1700.05n

* CHECK dout0_22 Vdout0_22ck169 = 1.8 time = 1700
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=1700.05n

* CHECK dout0_23 Vdout0_23ck169 = 1.8 time = 1700
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=1700.05n

* CHECK dout0_24 Vdout0_24ck169 = 0 time = 1700
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=1700.05n

* CHECK dout0_25 Vdout0_25ck169 = 0 time = 1700
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=1700.05n

* CHECK dout0_26 Vdout0_26ck169 = 1.8 time = 1700
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=1700.05n

* CHECK dout0_27 Vdout0_27ck169 = 0 time = 1700
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=1700.05n

* CHECK dout0_28 Vdout0_28ck169 = 1.8 time = 1700
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=1700.05n

* CHECK dout0_29 Vdout0_29ck169 = 1.8 time = 1700
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=1700.05n

* CHECK dout0_30 Vdout0_30ck169 = 1.8 time = 1700
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=1700.05n

* CHECK dout0_31 Vdout0_31ck169 = 0 time = 1700
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=1700.05n

* CHECK dout0_32 Vdout0_32ck169 = 1.8 time = 1700
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=1700.05n

* CHECK dout0_33 Vdout0_33ck169 = 0 time = 1700
.meas tran vdout0_33ck169 FIND v(dout0_33) AT=1700.05n

* CHECK dout0_34 Vdout0_34ck169 = 1.8 time = 1700
.meas tran vdout0_34ck169 FIND v(dout0_34) AT=1700.05n

* CHECK dout0_35 Vdout0_35ck169 = 0 time = 1700
.meas tran vdout0_35ck169 FIND v(dout0_35) AT=1700.05n

* CHECK dout0_36 Vdout0_36ck169 = 0 time = 1700
.meas tran vdout0_36ck169 FIND v(dout0_36) AT=1700.05n

* CHECK dout0_37 Vdout0_37ck169 = 1.8 time = 1700
.meas tran vdout0_37ck169 FIND v(dout0_37) AT=1700.05n

* CHECK dout0_38 Vdout0_38ck169 = 0 time = 1700
.meas tran vdout0_38ck169 FIND v(dout0_38) AT=1700.05n

* CHECK dout0_39 Vdout0_39ck169 = 0 time = 1700
.meas tran vdout0_39ck169 FIND v(dout0_39) AT=1700.05n

* CHECK dout0_40 Vdout0_40ck169 = 0 time = 1700
.meas tran vdout0_40ck169 FIND v(dout0_40) AT=1700.05n

* CHECK dout0_41 Vdout0_41ck169 = 0 time = 1700
.meas tran vdout0_41ck169 FIND v(dout0_41) AT=1700.05n

* CHECK dout0_42 Vdout0_42ck169 = 0 time = 1700
.meas tran vdout0_42ck169 FIND v(dout0_42) AT=1700.05n

* CHECK dout0_43 Vdout0_43ck169 = 1.8 time = 1700
.meas tran vdout0_43ck169 FIND v(dout0_43) AT=1700.05n

* CHECK dout0_44 Vdout0_44ck169 = 1.8 time = 1700
.meas tran vdout0_44ck169 FIND v(dout0_44) AT=1700.05n

* CHECK dout0_45 Vdout0_45ck169 = 0 time = 1700
.meas tran vdout0_45ck169 FIND v(dout0_45) AT=1700.05n

* CHECK dout0_46 Vdout0_46ck169 = 1.8 time = 1700
.meas tran vdout0_46ck169 FIND v(dout0_46) AT=1700.05n

* CHECK dout0_47 Vdout0_47ck169 = 1.8 time = 1700
.meas tran vdout0_47ck169 FIND v(dout0_47) AT=1700.05n

* CHECK dout0_48 Vdout0_48ck169 = 1.8 time = 1700
.meas tran vdout0_48ck169 FIND v(dout0_48) AT=1700.05n

* CHECK dout0_49 Vdout0_49ck169 = 1.8 time = 1700
.meas tran vdout0_49ck169 FIND v(dout0_49) AT=1700.05n

* CHECK dout0_50 Vdout0_50ck169 = 1.8 time = 1700
.meas tran vdout0_50ck169 FIND v(dout0_50) AT=1700.05n

* CHECK dout0_51 Vdout0_51ck169 = 0 time = 1700
.meas tran vdout0_51ck169 FIND v(dout0_51) AT=1700.05n

* CHECK dout0_52 Vdout0_52ck169 = 1.8 time = 1700
.meas tran vdout0_52ck169 FIND v(dout0_52) AT=1700.05n

* CHECK dout0_53 Vdout0_53ck169 = 1.8 time = 1700
.meas tran vdout0_53ck169 FIND v(dout0_53) AT=1700.05n

* CHECK dout0_54 Vdout0_54ck169 = 0 time = 1700
.meas tran vdout0_54ck169 FIND v(dout0_54) AT=1700.05n

* CHECK dout0_55 Vdout0_55ck169 = 1.8 time = 1700
.meas tran vdout0_55ck169 FIND v(dout0_55) AT=1700.05n

* CHECK dout0_56 Vdout0_56ck169 = 0 time = 1700
.meas tran vdout0_56ck169 FIND v(dout0_56) AT=1700.05n

* CHECK dout0_57 Vdout0_57ck169 = 1.8 time = 1700
.meas tran vdout0_57ck169 FIND v(dout0_57) AT=1700.05n

* CHECK dout0_58 Vdout0_58ck169 = 0 time = 1700
.meas tran vdout0_58ck169 FIND v(dout0_58) AT=1700.05n

* CHECK dout0_59 Vdout0_59ck169 = 1.8 time = 1700
.meas tran vdout0_59ck169 FIND v(dout0_59) AT=1700.05n

* CHECK dout0_60 Vdout0_60ck169 = 0 time = 1700
.meas tran vdout0_60ck169 FIND v(dout0_60) AT=1700.05n

* CHECK dout0_61 Vdout0_61ck169 = 1.8 time = 1700
.meas tran vdout0_61ck169 FIND v(dout0_61) AT=1700.05n

* CHECK dout0_62 Vdout0_62ck169 = 0 time = 1700
.meas tran vdout0_62ck169 FIND v(dout0_62) AT=1700.05n

* CHECK dout0_63 Vdout0_63ck169 = 0 time = 1700
.meas tran vdout0_63ck169 FIND v(dout0_63) AT=1700.05n

* CHECK dout0_64 Vdout0_64ck169 = 0 time = 1700
.meas tran vdout0_64ck169 FIND v(dout0_64) AT=1700.05n

* CHECK dout0_0 Vdout0_0ck171 = 0 time = 1720
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=1720.05n

* CHECK dout0_1 Vdout0_1ck171 = 1.8 time = 1720
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=1720.05n

* CHECK dout0_2 Vdout0_2ck171 = 1.8 time = 1720
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=1720.05n

* CHECK dout0_3 Vdout0_3ck171 = 0 time = 1720
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=1720.05n

* CHECK dout0_4 Vdout0_4ck171 = 1.8 time = 1720
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=1720.05n

* CHECK dout0_5 Vdout0_5ck171 = 1.8 time = 1720
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=1720.05n

* CHECK dout0_6 Vdout0_6ck171 = 1.8 time = 1720
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=1720.05n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 1720
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=1720.05n

* CHECK dout0_8 Vdout0_8ck171 = 1.8 time = 1720
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=1720.05n

* CHECK dout0_9 Vdout0_9ck171 = 0 time = 1720
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=1720.05n

* CHECK dout0_10 Vdout0_10ck171 = 1.8 time = 1720
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=1720.05n

* CHECK dout0_11 Vdout0_11ck171 = 0 time = 1720
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=1720.05n

* CHECK dout0_12 Vdout0_12ck171 = 0 time = 1720
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=1720.05n

* CHECK dout0_13 Vdout0_13ck171 = 1.8 time = 1720
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=1720.05n

* CHECK dout0_14 Vdout0_14ck171 = 0 time = 1720
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=1720.05n

* CHECK dout0_15 Vdout0_15ck171 = 0 time = 1720
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=1720.05n

* CHECK dout0_16 Vdout0_16ck171 = 0 time = 1720
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=1720.05n

* CHECK dout0_17 Vdout0_17ck171 = 1.8 time = 1720
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=1720.05n

* CHECK dout0_18 Vdout0_18ck171 = 1.8 time = 1720
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=1720.05n

* CHECK dout0_19 Vdout0_19ck171 = 0 time = 1720
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=1720.05n

* CHECK dout0_20 Vdout0_20ck171 = 1.8 time = 1720
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=1720.05n

* CHECK dout0_21 Vdout0_21ck171 = 1.8 time = 1720
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=1720.05n

* CHECK dout0_22 Vdout0_22ck171 = 1.8 time = 1720
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=1720.05n

* CHECK dout0_23 Vdout0_23ck171 = 1.8 time = 1720
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=1720.05n

* CHECK dout0_24 Vdout0_24ck171 = 0 time = 1720
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=1720.05n

* CHECK dout0_25 Vdout0_25ck171 = 0 time = 1720
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=1720.05n

* CHECK dout0_26 Vdout0_26ck171 = 1.8 time = 1720
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=1720.05n

* CHECK dout0_27 Vdout0_27ck171 = 0 time = 1720
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=1720.05n

* CHECK dout0_28 Vdout0_28ck171 = 1.8 time = 1720
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=1720.05n

* CHECK dout0_29 Vdout0_29ck171 = 1.8 time = 1720
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=1720.05n

* CHECK dout0_30 Vdout0_30ck171 = 1.8 time = 1720
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=1720.05n

* CHECK dout0_31 Vdout0_31ck171 = 0 time = 1720
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=1720.05n

* CHECK dout0_32 Vdout0_32ck171 = 1.8 time = 1720
.meas tran vdout0_32ck171 FIND v(dout0_32) AT=1720.05n

* CHECK dout0_33 Vdout0_33ck171 = 0 time = 1720
.meas tran vdout0_33ck171 FIND v(dout0_33) AT=1720.05n

* CHECK dout0_34 Vdout0_34ck171 = 1.8 time = 1720
.meas tran vdout0_34ck171 FIND v(dout0_34) AT=1720.05n

* CHECK dout0_35 Vdout0_35ck171 = 0 time = 1720
.meas tran vdout0_35ck171 FIND v(dout0_35) AT=1720.05n

* CHECK dout0_36 Vdout0_36ck171 = 0 time = 1720
.meas tran vdout0_36ck171 FIND v(dout0_36) AT=1720.05n

* CHECK dout0_37 Vdout0_37ck171 = 1.8 time = 1720
.meas tran vdout0_37ck171 FIND v(dout0_37) AT=1720.05n

* CHECK dout0_38 Vdout0_38ck171 = 0 time = 1720
.meas tran vdout0_38ck171 FIND v(dout0_38) AT=1720.05n

* CHECK dout0_39 Vdout0_39ck171 = 0 time = 1720
.meas tran vdout0_39ck171 FIND v(dout0_39) AT=1720.05n

* CHECK dout0_40 Vdout0_40ck171 = 0 time = 1720
.meas tran vdout0_40ck171 FIND v(dout0_40) AT=1720.05n

* CHECK dout0_41 Vdout0_41ck171 = 0 time = 1720
.meas tran vdout0_41ck171 FIND v(dout0_41) AT=1720.05n

* CHECK dout0_42 Vdout0_42ck171 = 0 time = 1720
.meas tran vdout0_42ck171 FIND v(dout0_42) AT=1720.05n

* CHECK dout0_43 Vdout0_43ck171 = 1.8 time = 1720
.meas tran vdout0_43ck171 FIND v(dout0_43) AT=1720.05n

* CHECK dout0_44 Vdout0_44ck171 = 1.8 time = 1720
.meas tran vdout0_44ck171 FIND v(dout0_44) AT=1720.05n

* CHECK dout0_45 Vdout0_45ck171 = 0 time = 1720
.meas tran vdout0_45ck171 FIND v(dout0_45) AT=1720.05n

* CHECK dout0_46 Vdout0_46ck171 = 1.8 time = 1720
.meas tran vdout0_46ck171 FIND v(dout0_46) AT=1720.05n

* CHECK dout0_47 Vdout0_47ck171 = 1.8 time = 1720
.meas tran vdout0_47ck171 FIND v(dout0_47) AT=1720.05n

* CHECK dout0_48 Vdout0_48ck171 = 1.8 time = 1720
.meas tran vdout0_48ck171 FIND v(dout0_48) AT=1720.05n

* CHECK dout0_49 Vdout0_49ck171 = 1.8 time = 1720
.meas tran vdout0_49ck171 FIND v(dout0_49) AT=1720.05n

* CHECK dout0_50 Vdout0_50ck171 = 1.8 time = 1720
.meas tran vdout0_50ck171 FIND v(dout0_50) AT=1720.05n

* CHECK dout0_51 Vdout0_51ck171 = 0 time = 1720
.meas tran vdout0_51ck171 FIND v(dout0_51) AT=1720.05n

* CHECK dout0_52 Vdout0_52ck171 = 1.8 time = 1720
.meas tran vdout0_52ck171 FIND v(dout0_52) AT=1720.05n

* CHECK dout0_53 Vdout0_53ck171 = 1.8 time = 1720
.meas tran vdout0_53ck171 FIND v(dout0_53) AT=1720.05n

* CHECK dout0_54 Vdout0_54ck171 = 0 time = 1720
.meas tran vdout0_54ck171 FIND v(dout0_54) AT=1720.05n

* CHECK dout0_55 Vdout0_55ck171 = 1.8 time = 1720
.meas tran vdout0_55ck171 FIND v(dout0_55) AT=1720.05n

* CHECK dout0_56 Vdout0_56ck171 = 0 time = 1720
.meas tran vdout0_56ck171 FIND v(dout0_56) AT=1720.05n

* CHECK dout0_57 Vdout0_57ck171 = 1.8 time = 1720
.meas tran vdout0_57ck171 FIND v(dout0_57) AT=1720.05n

* CHECK dout0_58 Vdout0_58ck171 = 0 time = 1720
.meas tran vdout0_58ck171 FIND v(dout0_58) AT=1720.05n

* CHECK dout0_59 Vdout0_59ck171 = 1.8 time = 1720
.meas tran vdout0_59ck171 FIND v(dout0_59) AT=1720.05n

* CHECK dout0_60 Vdout0_60ck171 = 0 time = 1720
.meas tran vdout0_60ck171 FIND v(dout0_60) AT=1720.05n

* CHECK dout0_61 Vdout0_61ck171 = 1.8 time = 1720
.meas tran vdout0_61ck171 FIND v(dout0_61) AT=1720.05n

* CHECK dout0_62 Vdout0_62ck171 = 0 time = 1720
.meas tran vdout0_62ck171 FIND v(dout0_62) AT=1720.05n

* CHECK dout0_63 Vdout0_63ck171 = 0 time = 1720
.meas tran vdout0_63ck171 FIND v(dout0_63) AT=1720.05n

* CHECK dout0_64 Vdout0_64ck171 = 0 time = 1720
.meas tran vdout0_64ck171 FIND v(dout0_64) AT=1720.05n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 1730
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=1730.05n

* CHECK dout0_1 Vdout0_1ck172 = 1.8 time = 1730
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=1730.05n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 1730
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=1730.05n

* CHECK dout0_3 Vdout0_3ck172 = 1.8 time = 1730
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=1730.05n

* CHECK dout0_4 Vdout0_4ck172 = 1.8 time = 1730
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=1730.05n

* CHECK dout0_5 Vdout0_5ck172 = 1.8 time = 1730
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=1730.05n

* CHECK dout0_6 Vdout0_6ck172 = 0 time = 1730
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=1730.05n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 1730
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=1730.05n

* CHECK dout0_8 Vdout0_8ck172 = 0 time = 1730
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=1730.05n

* CHECK dout0_9 Vdout0_9ck172 = 1.8 time = 1730
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=1730.05n

* CHECK dout0_10 Vdout0_10ck172 = 0 time = 1730
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=1730.05n

* CHECK dout0_11 Vdout0_11ck172 = 0 time = 1730
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=1730.05n

* CHECK dout0_12 Vdout0_12ck172 = 1.8 time = 1730
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=1730.05n

* CHECK dout0_13 Vdout0_13ck172 = 0 time = 1730
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=1730.05n

* CHECK dout0_14 Vdout0_14ck172 = 0 time = 1730
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=1730.05n

* CHECK dout0_15 Vdout0_15ck172 = 0 time = 1730
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=1730.05n

* CHECK dout0_16 Vdout0_16ck172 = 0 time = 1730
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=1730.05n

* CHECK dout0_17 Vdout0_17ck172 = 0 time = 1730
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=1730.05n

* CHECK dout0_18 Vdout0_18ck172 = 0 time = 1730
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=1730.05n

* CHECK dout0_19 Vdout0_19ck172 = 0 time = 1730
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=1730.05n

* CHECK dout0_20 Vdout0_20ck172 = 1.8 time = 1730
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=1730.05n

* CHECK dout0_21 Vdout0_21ck172 = 1.8 time = 1730
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=1730.05n

* CHECK dout0_22 Vdout0_22ck172 = 0 time = 1730
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=1730.05n

* CHECK dout0_23 Vdout0_23ck172 = 0 time = 1730
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=1730.05n

* CHECK dout0_24 Vdout0_24ck172 = 0 time = 1730
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=1730.05n

* CHECK dout0_25 Vdout0_25ck172 = 0 time = 1730
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=1730.05n

* CHECK dout0_26 Vdout0_26ck172 = 1.8 time = 1730
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=1730.05n

* CHECK dout0_27 Vdout0_27ck172 = 1.8 time = 1730
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=1730.05n

* CHECK dout0_28 Vdout0_28ck172 = 0 time = 1730
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=1730.05n

* CHECK dout0_29 Vdout0_29ck172 = 0 time = 1730
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=1730.05n

* CHECK dout0_30 Vdout0_30ck172 = 0 time = 1730
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=1730.05n

* CHECK dout0_31 Vdout0_31ck172 = 1.8 time = 1730
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=1730.05n

* CHECK dout0_32 Vdout0_32ck172 = 1.8 time = 1730
.meas tran vdout0_32ck172 FIND v(dout0_32) AT=1730.05n

* CHECK dout0_33 Vdout0_33ck172 = 0 time = 1730
.meas tran vdout0_33ck172 FIND v(dout0_33) AT=1730.05n

* CHECK dout0_34 Vdout0_34ck172 = 1.8 time = 1730
.meas tran vdout0_34ck172 FIND v(dout0_34) AT=1730.05n

* CHECK dout0_35 Vdout0_35ck172 = 0 time = 1730
.meas tran vdout0_35ck172 FIND v(dout0_35) AT=1730.05n

* CHECK dout0_36 Vdout0_36ck172 = 0 time = 1730
.meas tran vdout0_36ck172 FIND v(dout0_36) AT=1730.05n

* CHECK dout0_37 Vdout0_37ck172 = 1.8 time = 1730
.meas tran vdout0_37ck172 FIND v(dout0_37) AT=1730.05n

* CHECK dout0_38 Vdout0_38ck172 = 0 time = 1730
.meas tran vdout0_38ck172 FIND v(dout0_38) AT=1730.05n

* CHECK dout0_39 Vdout0_39ck172 = 0 time = 1730
.meas tran vdout0_39ck172 FIND v(dout0_39) AT=1730.05n

* CHECK dout0_40 Vdout0_40ck172 = 1.8 time = 1730
.meas tran vdout0_40ck172 FIND v(dout0_40) AT=1730.05n

* CHECK dout0_41 Vdout0_41ck172 = 1.8 time = 1730
.meas tran vdout0_41ck172 FIND v(dout0_41) AT=1730.05n

* CHECK dout0_42 Vdout0_42ck172 = 1.8 time = 1730
.meas tran vdout0_42ck172 FIND v(dout0_42) AT=1730.05n

* CHECK dout0_43 Vdout0_43ck172 = 0 time = 1730
.meas tran vdout0_43ck172 FIND v(dout0_43) AT=1730.05n

* CHECK dout0_44 Vdout0_44ck172 = 1.8 time = 1730
.meas tran vdout0_44ck172 FIND v(dout0_44) AT=1730.05n

* CHECK dout0_45 Vdout0_45ck172 = 1.8 time = 1730
.meas tran vdout0_45ck172 FIND v(dout0_45) AT=1730.05n

* CHECK dout0_46 Vdout0_46ck172 = 1.8 time = 1730
.meas tran vdout0_46ck172 FIND v(dout0_46) AT=1730.05n

* CHECK dout0_47 Vdout0_47ck172 = 0 time = 1730
.meas tran vdout0_47ck172 FIND v(dout0_47) AT=1730.05n

* CHECK dout0_48 Vdout0_48ck172 = 1.8 time = 1730
.meas tran vdout0_48ck172 FIND v(dout0_48) AT=1730.05n

* CHECK dout0_49 Vdout0_49ck172 = 1.8 time = 1730
.meas tran vdout0_49ck172 FIND v(dout0_49) AT=1730.05n

* CHECK dout0_50 Vdout0_50ck172 = 0 time = 1730
.meas tran vdout0_50ck172 FIND v(dout0_50) AT=1730.05n

* CHECK dout0_51 Vdout0_51ck172 = 0 time = 1730
.meas tran vdout0_51ck172 FIND v(dout0_51) AT=1730.05n

* CHECK dout0_52 Vdout0_52ck172 = 0 time = 1730
.meas tran vdout0_52ck172 FIND v(dout0_52) AT=1730.05n

* CHECK dout0_53 Vdout0_53ck172 = 1.8 time = 1730
.meas tran vdout0_53ck172 FIND v(dout0_53) AT=1730.05n

* CHECK dout0_54 Vdout0_54ck172 = 0 time = 1730
.meas tran vdout0_54ck172 FIND v(dout0_54) AT=1730.05n

* CHECK dout0_55 Vdout0_55ck172 = 0 time = 1730
.meas tran vdout0_55ck172 FIND v(dout0_55) AT=1730.05n

* CHECK dout0_56 Vdout0_56ck172 = 1.8 time = 1730
.meas tran vdout0_56ck172 FIND v(dout0_56) AT=1730.05n

* CHECK dout0_57 Vdout0_57ck172 = 0 time = 1730
.meas tran vdout0_57ck172 FIND v(dout0_57) AT=1730.05n

* CHECK dout0_58 Vdout0_58ck172 = 1.8 time = 1730
.meas tran vdout0_58ck172 FIND v(dout0_58) AT=1730.05n

* CHECK dout0_59 Vdout0_59ck172 = 1.8 time = 1730
.meas tran vdout0_59ck172 FIND v(dout0_59) AT=1730.05n

* CHECK dout0_60 Vdout0_60ck172 = 1.8 time = 1730
.meas tran vdout0_60ck172 FIND v(dout0_60) AT=1730.05n

* CHECK dout0_61 Vdout0_61ck172 = 1.8 time = 1730
.meas tran vdout0_61ck172 FIND v(dout0_61) AT=1730.05n

* CHECK dout0_62 Vdout0_62ck172 = 1.8 time = 1730
.meas tran vdout0_62ck172 FIND v(dout0_62) AT=1730.05n

* CHECK dout0_63 Vdout0_63ck172 = 1.8 time = 1730
.meas tran vdout0_63ck172 FIND v(dout0_63) AT=1730.05n

* CHECK dout0_64 Vdout0_64ck172 = 0 time = 1730
.meas tran vdout0_64ck172 FIND v(dout0_64) AT=1730.05n

* CHECK dout0_0 Vdout0_0ck173 = 0 time = 1740
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=1740.05n

* CHECK dout0_1 Vdout0_1ck173 = 1.8 time = 1740
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=1740.05n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 1740
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=1740.05n

* CHECK dout0_3 Vdout0_3ck173 = 0 time = 1740
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=1740.05n

* CHECK dout0_4 Vdout0_4ck173 = 1.8 time = 1740
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=1740.05n

* CHECK dout0_5 Vdout0_5ck173 = 1.8 time = 1740
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=1740.05n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 1740
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=1740.05n

* CHECK dout0_7 Vdout0_7ck173 = 1.8 time = 1740
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=1740.05n

* CHECK dout0_8 Vdout0_8ck173 = 1.8 time = 1740
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=1740.05n

* CHECK dout0_9 Vdout0_9ck173 = 1.8 time = 1740
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=1740.05n

* CHECK dout0_10 Vdout0_10ck173 = 0 time = 1740
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=1740.05n

* CHECK dout0_11 Vdout0_11ck173 = 1.8 time = 1740
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=1740.05n

* CHECK dout0_12 Vdout0_12ck173 = 1.8 time = 1740
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=1740.05n

* CHECK dout0_13 Vdout0_13ck173 = 0 time = 1740
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=1740.05n

* CHECK dout0_14 Vdout0_14ck173 = 1.8 time = 1740
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=1740.05n

* CHECK dout0_15 Vdout0_15ck173 = 1.8 time = 1740
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=1740.05n

* CHECK dout0_16 Vdout0_16ck173 = 0 time = 1740
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=1740.05n

* CHECK dout0_17 Vdout0_17ck173 = 1.8 time = 1740
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=1740.05n

* CHECK dout0_18 Vdout0_18ck173 = 1.8 time = 1740
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=1740.05n

* CHECK dout0_19 Vdout0_19ck173 = 0 time = 1740
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=1740.05n

* CHECK dout0_20 Vdout0_20ck173 = 0 time = 1740
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=1740.05n

* CHECK dout0_21 Vdout0_21ck173 = 0 time = 1740
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=1740.05n

* CHECK dout0_22 Vdout0_22ck173 = 0 time = 1740
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=1740.05n

* CHECK dout0_23 Vdout0_23ck173 = 1.8 time = 1740
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=1740.05n

* CHECK dout0_24 Vdout0_24ck173 = 1.8 time = 1740
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=1740.05n

* CHECK dout0_25 Vdout0_25ck173 = 1.8 time = 1740
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=1740.05n

* CHECK dout0_26 Vdout0_26ck173 = 1.8 time = 1740
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=1740.05n

* CHECK dout0_27 Vdout0_27ck173 = 1.8 time = 1740
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=1740.05n

* CHECK dout0_28 Vdout0_28ck173 = 0 time = 1740
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=1740.05n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 1740
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=1740.05n

* CHECK dout0_30 Vdout0_30ck173 = 1.8 time = 1740
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=1740.05n

* CHECK dout0_31 Vdout0_31ck173 = 1.8 time = 1740
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=1740.05n

* CHECK dout0_32 Vdout0_32ck173 = 0 time = 1740
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=1740.05n

* CHECK dout0_33 Vdout0_33ck173 = 1.8 time = 1740
.meas tran vdout0_33ck173 FIND v(dout0_33) AT=1740.05n

* CHECK dout0_34 Vdout0_34ck173 = 0 time = 1740
.meas tran vdout0_34ck173 FIND v(dout0_34) AT=1740.05n

* CHECK dout0_35 Vdout0_35ck173 = 1.8 time = 1740
.meas tran vdout0_35ck173 FIND v(dout0_35) AT=1740.05n

* CHECK dout0_36 Vdout0_36ck173 = 1.8 time = 1740
.meas tran vdout0_36ck173 FIND v(dout0_36) AT=1740.05n

* CHECK dout0_37 Vdout0_37ck173 = 1.8 time = 1740
.meas tran vdout0_37ck173 FIND v(dout0_37) AT=1740.05n

* CHECK dout0_38 Vdout0_38ck173 = 0 time = 1740
.meas tran vdout0_38ck173 FIND v(dout0_38) AT=1740.05n

* CHECK dout0_39 Vdout0_39ck173 = 0 time = 1740
.meas tran vdout0_39ck173 FIND v(dout0_39) AT=1740.05n

* CHECK dout0_40 Vdout0_40ck173 = 0 time = 1740
.meas tran vdout0_40ck173 FIND v(dout0_40) AT=1740.05n

* CHECK dout0_41 Vdout0_41ck173 = 1.8 time = 1740
.meas tran vdout0_41ck173 FIND v(dout0_41) AT=1740.05n

* CHECK dout0_42 Vdout0_42ck173 = 0 time = 1740
.meas tran vdout0_42ck173 FIND v(dout0_42) AT=1740.05n

* CHECK dout0_43 Vdout0_43ck173 = 0 time = 1740
.meas tran vdout0_43ck173 FIND v(dout0_43) AT=1740.05n

* CHECK dout0_44 Vdout0_44ck173 = 1.8 time = 1740
.meas tran vdout0_44ck173 FIND v(dout0_44) AT=1740.05n

* CHECK dout0_45 Vdout0_45ck173 = 0 time = 1740
.meas tran vdout0_45ck173 FIND v(dout0_45) AT=1740.05n

* CHECK dout0_46 Vdout0_46ck173 = 0 time = 1740
.meas tran vdout0_46ck173 FIND v(dout0_46) AT=1740.05n

* CHECK dout0_47 Vdout0_47ck173 = 0 time = 1740
.meas tran vdout0_47ck173 FIND v(dout0_47) AT=1740.05n

* CHECK dout0_48 Vdout0_48ck173 = 0 time = 1740
.meas tran vdout0_48ck173 FIND v(dout0_48) AT=1740.05n

* CHECK dout0_49 Vdout0_49ck173 = 1.8 time = 1740
.meas tran vdout0_49ck173 FIND v(dout0_49) AT=1740.05n

* CHECK dout0_50 Vdout0_50ck173 = 1.8 time = 1740
.meas tran vdout0_50ck173 FIND v(dout0_50) AT=1740.05n

* CHECK dout0_51 Vdout0_51ck173 = 0 time = 1740
.meas tran vdout0_51ck173 FIND v(dout0_51) AT=1740.05n

* CHECK dout0_52 Vdout0_52ck173 = 0 time = 1740
.meas tran vdout0_52ck173 FIND v(dout0_52) AT=1740.05n

* CHECK dout0_53 Vdout0_53ck173 = 0 time = 1740
.meas tran vdout0_53ck173 FIND v(dout0_53) AT=1740.05n

* CHECK dout0_54 Vdout0_54ck173 = 0 time = 1740
.meas tran vdout0_54ck173 FIND v(dout0_54) AT=1740.05n

* CHECK dout0_55 Vdout0_55ck173 = 1.8 time = 1740
.meas tran vdout0_55ck173 FIND v(dout0_55) AT=1740.05n

* CHECK dout0_56 Vdout0_56ck173 = 1.8 time = 1740
.meas tran vdout0_56ck173 FIND v(dout0_56) AT=1740.05n

* CHECK dout0_57 Vdout0_57ck173 = 0 time = 1740
.meas tran vdout0_57ck173 FIND v(dout0_57) AT=1740.05n

* CHECK dout0_58 Vdout0_58ck173 = 1.8 time = 1740
.meas tran vdout0_58ck173 FIND v(dout0_58) AT=1740.05n

* CHECK dout0_59 Vdout0_59ck173 = 1.8 time = 1740
.meas tran vdout0_59ck173 FIND v(dout0_59) AT=1740.05n

* CHECK dout0_60 Vdout0_60ck173 = 0 time = 1740
.meas tran vdout0_60ck173 FIND v(dout0_60) AT=1740.05n

* CHECK dout0_61 Vdout0_61ck173 = 1.8 time = 1740
.meas tran vdout0_61ck173 FIND v(dout0_61) AT=1740.05n

* CHECK dout0_62 Vdout0_62ck173 = 0 time = 1740
.meas tran vdout0_62ck173 FIND v(dout0_62) AT=1740.05n

* CHECK dout0_63 Vdout0_63ck173 = 0 time = 1740
.meas tran vdout0_63ck173 FIND v(dout0_63) AT=1740.05n

* CHECK dout0_64 Vdout0_64ck173 = 0 time = 1740
.meas tran vdout0_64ck173 FIND v(dout0_64) AT=1740.05n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 1750
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=1750.05n

* CHECK dout0_1 Vdout0_1ck174 = 0 time = 1750
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=1750.05n

* CHECK dout0_2 Vdout0_2ck174 = 1.8 time = 1750
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=1750.05n

* CHECK dout0_3 Vdout0_3ck174 = 1.8 time = 1750
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=1750.05n

* CHECK dout0_4 Vdout0_4ck174 = 1.8 time = 1750
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=1750.05n

* CHECK dout0_5 Vdout0_5ck174 = 1.8 time = 1750
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=1750.05n

* CHECK dout0_6 Vdout0_6ck174 = 1.8 time = 1750
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=1750.05n

* CHECK dout0_7 Vdout0_7ck174 = 0 time = 1750
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=1750.05n

* CHECK dout0_8 Vdout0_8ck174 = 1.8 time = 1750
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=1750.05n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 1750
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=1750.05n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 1750
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=1750.05n

* CHECK dout0_11 Vdout0_11ck174 = 1.8 time = 1750
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=1750.05n

* CHECK dout0_12 Vdout0_12ck174 = 0 time = 1750
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=1750.05n

* CHECK dout0_13 Vdout0_13ck174 = 1.8 time = 1750
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=1750.05n

* CHECK dout0_14 Vdout0_14ck174 = 0 time = 1750
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=1750.05n

* CHECK dout0_15 Vdout0_15ck174 = 0 time = 1750
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=1750.05n

* CHECK dout0_16 Vdout0_16ck174 = 1.8 time = 1750
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=1750.05n

* CHECK dout0_17 Vdout0_17ck174 = 0 time = 1750
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=1750.05n

* CHECK dout0_18 Vdout0_18ck174 = 1.8 time = 1750
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=1750.05n

* CHECK dout0_19 Vdout0_19ck174 = 0 time = 1750
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=1750.05n

* CHECK dout0_20 Vdout0_20ck174 = 1.8 time = 1750
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=1750.05n

* CHECK dout0_21 Vdout0_21ck174 = 1.8 time = 1750
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=1750.05n

* CHECK dout0_22 Vdout0_22ck174 = 1.8 time = 1750
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=1750.05n

* CHECK dout0_23 Vdout0_23ck174 = 1.8 time = 1750
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=1750.05n

* CHECK dout0_24 Vdout0_24ck174 = 0 time = 1750
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=1750.05n

* CHECK dout0_25 Vdout0_25ck174 = 0 time = 1750
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=1750.05n

* CHECK dout0_26 Vdout0_26ck174 = 0 time = 1750
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=1750.05n

* CHECK dout0_27 Vdout0_27ck174 = 0 time = 1750
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=1750.05n

* CHECK dout0_28 Vdout0_28ck174 = 0 time = 1750
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=1750.05n

* CHECK dout0_29 Vdout0_29ck174 = 1.8 time = 1750
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=1750.05n

* CHECK dout0_30 Vdout0_30ck174 = 1.8 time = 1750
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=1750.05n

* CHECK dout0_31 Vdout0_31ck174 = 0 time = 1750
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=1750.05n

* CHECK dout0_32 Vdout0_32ck174 = 1.8 time = 1750
.meas tran vdout0_32ck174 FIND v(dout0_32) AT=1750.05n

* CHECK dout0_33 Vdout0_33ck174 = 1.8 time = 1750
.meas tran vdout0_33ck174 FIND v(dout0_33) AT=1750.05n

* CHECK dout0_34 Vdout0_34ck174 = 0 time = 1750
.meas tran vdout0_34ck174 FIND v(dout0_34) AT=1750.05n

* CHECK dout0_35 Vdout0_35ck174 = 1.8 time = 1750
.meas tran vdout0_35ck174 FIND v(dout0_35) AT=1750.05n

* CHECK dout0_36 Vdout0_36ck174 = 1.8 time = 1750
.meas tran vdout0_36ck174 FIND v(dout0_36) AT=1750.05n

* CHECK dout0_37 Vdout0_37ck174 = 0 time = 1750
.meas tran vdout0_37ck174 FIND v(dout0_37) AT=1750.05n

* CHECK dout0_38 Vdout0_38ck174 = 1.8 time = 1750
.meas tran vdout0_38ck174 FIND v(dout0_38) AT=1750.05n

* CHECK dout0_39 Vdout0_39ck174 = 1.8 time = 1750
.meas tran vdout0_39ck174 FIND v(dout0_39) AT=1750.05n

* CHECK dout0_40 Vdout0_40ck174 = 1.8 time = 1750
.meas tran vdout0_40ck174 FIND v(dout0_40) AT=1750.05n

* CHECK dout0_41 Vdout0_41ck174 = 1.8 time = 1750
.meas tran vdout0_41ck174 FIND v(dout0_41) AT=1750.05n

* CHECK dout0_42 Vdout0_42ck174 = 1.8 time = 1750
.meas tran vdout0_42ck174 FIND v(dout0_42) AT=1750.05n

* CHECK dout0_43 Vdout0_43ck174 = 0 time = 1750
.meas tran vdout0_43ck174 FIND v(dout0_43) AT=1750.05n

* CHECK dout0_44 Vdout0_44ck174 = 1.8 time = 1750
.meas tran vdout0_44ck174 FIND v(dout0_44) AT=1750.05n

* CHECK dout0_45 Vdout0_45ck174 = 1.8 time = 1750
.meas tran vdout0_45ck174 FIND v(dout0_45) AT=1750.05n

* CHECK dout0_46 Vdout0_46ck174 = 0 time = 1750
.meas tran vdout0_46ck174 FIND v(dout0_46) AT=1750.05n

* CHECK dout0_47 Vdout0_47ck174 = 1.8 time = 1750
.meas tran vdout0_47ck174 FIND v(dout0_47) AT=1750.05n

* CHECK dout0_48 Vdout0_48ck174 = 1.8 time = 1750
.meas tran vdout0_48ck174 FIND v(dout0_48) AT=1750.05n

* CHECK dout0_49 Vdout0_49ck174 = 0 time = 1750
.meas tran vdout0_49ck174 FIND v(dout0_49) AT=1750.05n

* CHECK dout0_50 Vdout0_50ck174 = 1.8 time = 1750
.meas tran vdout0_50ck174 FIND v(dout0_50) AT=1750.05n

* CHECK dout0_51 Vdout0_51ck174 = 1.8 time = 1750
.meas tran vdout0_51ck174 FIND v(dout0_51) AT=1750.05n

* CHECK dout0_52 Vdout0_52ck174 = 1.8 time = 1750
.meas tran vdout0_52ck174 FIND v(dout0_52) AT=1750.05n

* CHECK dout0_53 Vdout0_53ck174 = 1.8 time = 1750
.meas tran vdout0_53ck174 FIND v(dout0_53) AT=1750.05n

* CHECK dout0_54 Vdout0_54ck174 = 1.8 time = 1750
.meas tran vdout0_54ck174 FIND v(dout0_54) AT=1750.05n

* CHECK dout0_55 Vdout0_55ck174 = 0 time = 1750
.meas tran vdout0_55ck174 FIND v(dout0_55) AT=1750.05n

* CHECK dout0_56 Vdout0_56ck174 = 0 time = 1750
.meas tran vdout0_56ck174 FIND v(dout0_56) AT=1750.05n

* CHECK dout0_57 Vdout0_57ck174 = 0 time = 1750
.meas tran vdout0_57ck174 FIND v(dout0_57) AT=1750.05n

* CHECK dout0_58 Vdout0_58ck174 = 1.8 time = 1750
.meas tran vdout0_58ck174 FIND v(dout0_58) AT=1750.05n

* CHECK dout0_59 Vdout0_59ck174 = 1.8 time = 1750
.meas tran vdout0_59ck174 FIND v(dout0_59) AT=1750.05n

* CHECK dout0_60 Vdout0_60ck174 = 0 time = 1750
.meas tran vdout0_60ck174 FIND v(dout0_60) AT=1750.05n

* CHECK dout0_61 Vdout0_61ck174 = 1.8 time = 1750
.meas tran vdout0_61ck174 FIND v(dout0_61) AT=1750.05n

* CHECK dout0_62 Vdout0_62ck174 = 1.8 time = 1750
.meas tran vdout0_62ck174 FIND v(dout0_62) AT=1750.05n

* CHECK dout0_63 Vdout0_63ck174 = 0 time = 1750
.meas tran vdout0_63ck174 FIND v(dout0_63) AT=1750.05n

* CHECK dout0_64 Vdout0_64ck174 = 0 time = 1750
.meas tran vdout0_64ck174 FIND v(dout0_64) AT=1750.05n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 1760
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=1760.05n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 1760
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=1760.05n

* CHECK dout0_2 Vdout0_2ck175 = 1.8 time = 1760
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=1760.05n

* CHECK dout0_3 Vdout0_3ck175 = 1.8 time = 1760
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=1760.05n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 1760
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=1760.05n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 1760
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=1760.05n

* CHECK dout0_6 Vdout0_6ck175 = 1.8 time = 1760
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=1760.05n

* CHECK dout0_7 Vdout0_7ck175 = 1.8 time = 1760
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=1760.05n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 1760
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=1760.05n

* CHECK dout0_9 Vdout0_9ck175 = 1.8 time = 1760
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=1760.05n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 1760
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=1760.05n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 1760
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=1760.05n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 1760
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=1760.05n

* CHECK dout0_13 Vdout0_13ck175 = 0 time = 1760
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=1760.05n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 1760
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=1760.05n

* CHECK dout0_15 Vdout0_15ck175 = 1.8 time = 1760
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=1760.05n

* CHECK dout0_16 Vdout0_16ck175 = 1.8 time = 1760
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=1760.05n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 1760
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=1760.05n

* CHECK dout0_18 Vdout0_18ck175 = 1.8 time = 1760
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=1760.05n

* CHECK dout0_19 Vdout0_19ck175 = 1.8 time = 1760
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=1760.05n

* CHECK dout0_20 Vdout0_20ck175 = 1.8 time = 1760
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=1760.05n

* CHECK dout0_21 Vdout0_21ck175 = 1.8 time = 1760
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=1760.05n

* CHECK dout0_22 Vdout0_22ck175 = 1.8 time = 1760
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=1760.05n

* CHECK dout0_23 Vdout0_23ck175 = 0 time = 1760
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=1760.05n

* CHECK dout0_24 Vdout0_24ck175 = 1.8 time = 1760
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=1760.05n

* CHECK dout0_25 Vdout0_25ck175 = 1.8 time = 1760
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=1760.05n

* CHECK dout0_26 Vdout0_26ck175 = 0 time = 1760
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=1760.05n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 1760
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=1760.05n

* CHECK dout0_28 Vdout0_28ck175 = 0 time = 1760
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=1760.05n

* CHECK dout0_29 Vdout0_29ck175 = 0 time = 1760
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=1760.05n

* CHECK dout0_30 Vdout0_30ck175 = 0 time = 1760
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=1760.05n

* CHECK dout0_31 Vdout0_31ck175 = 1.8 time = 1760
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=1760.05n

* CHECK dout0_32 Vdout0_32ck175 = 1.8 time = 1760
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=1760.05n

* CHECK dout0_33 Vdout0_33ck175 = 0 time = 1760
.meas tran vdout0_33ck175 FIND v(dout0_33) AT=1760.05n

* CHECK dout0_34 Vdout0_34ck175 = 1.8 time = 1760
.meas tran vdout0_34ck175 FIND v(dout0_34) AT=1760.05n

* CHECK dout0_35 Vdout0_35ck175 = 0 time = 1760
.meas tran vdout0_35ck175 FIND v(dout0_35) AT=1760.05n

* CHECK dout0_36 Vdout0_36ck175 = 0 time = 1760
.meas tran vdout0_36ck175 FIND v(dout0_36) AT=1760.05n

* CHECK dout0_37 Vdout0_37ck175 = 1.8 time = 1760
.meas tran vdout0_37ck175 FIND v(dout0_37) AT=1760.05n

* CHECK dout0_38 Vdout0_38ck175 = 0 time = 1760
.meas tran vdout0_38ck175 FIND v(dout0_38) AT=1760.05n

* CHECK dout0_39 Vdout0_39ck175 = 0 time = 1760
.meas tran vdout0_39ck175 FIND v(dout0_39) AT=1760.05n

* CHECK dout0_40 Vdout0_40ck175 = 0 time = 1760
.meas tran vdout0_40ck175 FIND v(dout0_40) AT=1760.05n

* CHECK dout0_41 Vdout0_41ck175 = 0 time = 1760
.meas tran vdout0_41ck175 FIND v(dout0_41) AT=1760.05n

* CHECK dout0_42 Vdout0_42ck175 = 1.8 time = 1760
.meas tran vdout0_42ck175 FIND v(dout0_42) AT=1760.05n

* CHECK dout0_43 Vdout0_43ck175 = 1.8 time = 1760
.meas tran vdout0_43ck175 FIND v(dout0_43) AT=1760.05n

* CHECK dout0_44 Vdout0_44ck175 = 0 time = 1760
.meas tran vdout0_44ck175 FIND v(dout0_44) AT=1760.05n

* CHECK dout0_45 Vdout0_45ck175 = 0 time = 1760
.meas tran vdout0_45ck175 FIND v(dout0_45) AT=1760.05n

* CHECK dout0_46 Vdout0_46ck175 = 1.8 time = 1760
.meas tran vdout0_46ck175 FIND v(dout0_46) AT=1760.05n

* CHECK dout0_47 Vdout0_47ck175 = 1.8 time = 1760
.meas tran vdout0_47ck175 FIND v(dout0_47) AT=1760.05n

* CHECK dout0_48 Vdout0_48ck175 = 0 time = 1760
.meas tran vdout0_48ck175 FIND v(dout0_48) AT=1760.05n

* CHECK dout0_49 Vdout0_49ck175 = 1.8 time = 1760
.meas tran vdout0_49ck175 FIND v(dout0_49) AT=1760.05n

* CHECK dout0_50 Vdout0_50ck175 = 1.8 time = 1760
.meas tran vdout0_50ck175 FIND v(dout0_50) AT=1760.05n

* CHECK dout0_51 Vdout0_51ck175 = 0 time = 1760
.meas tran vdout0_51ck175 FIND v(dout0_51) AT=1760.05n

* CHECK dout0_52 Vdout0_52ck175 = 1.8 time = 1760
.meas tran vdout0_52ck175 FIND v(dout0_52) AT=1760.05n

* CHECK dout0_53 Vdout0_53ck175 = 0 time = 1760
.meas tran vdout0_53ck175 FIND v(dout0_53) AT=1760.05n

* CHECK dout0_54 Vdout0_54ck175 = 0 time = 1760
.meas tran vdout0_54ck175 FIND v(dout0_54) AT=1760.05n

* CHECK dout0_55 Vdout0_55ck175 = 0 time = 1760
.meas tran vdout0_55ck175 FIND v(dout0_55) AT=1760.05n

* CHECK dout0_56 Vdout0_56ck175 = 0 time = 1760
.meas tran vdout0_56ck175 FIND v(dout0_56) AT=1760.05n

* CHECK dout0_57 Vdout0_57ck175 = 0 time = 1760
.meas tran vdout0_57ck175 FIND v(dout0_57) AT=1760.05n

* CHECK dout0_58 Vdout0_58ck175 = 1.8 time = 1760
.meas tran vdout0_58ck175 FIND v(dout0_58) AT=1760.05n

* CHECK dout0_59 Vdout0_59ck175 = 0 time = 1760
.meas tran vdout0_59ck175 FIND v(dout0_59) AT=1760.05n

* CHECK dout0_60 Vdout0_60ck175 = 0 time = 1760
.meas tran vdout0_60ck175 FIND v(dout0_60) AT=1760.05n

* CHECK dout0_61 Vdout0_61ck175 = 0 time = 1760
.meas tran vdout0_61ck175 FIND v(dout0_61) AT=1760.05n

* CHECK dout0_62 Vdout0_62ck175 = 1.8 time = 1760
.meas tran vdout0_62ck175 FIND v(dout0_62) AT=1760.05n

* CHECK dout0_63 Vdout0_63ck175 = 0 time = 1760
.meas tran vdout0_63ck175 FIND v(dout0_63) AT=1760.05n

* CHECK dout0_64 Vdout0_64ck175 = 0 time = 1760
.meas tran vdout0_64ck175 FIND v(dout0_64) AT=1760.05n

* CHECK dout0_0 Vdout0_0ck178 = 1.8 time = 1790
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=1790.05n

* CHECK dout0_1 Vdout0_1ck178 = 1.8 time = 1790
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=1790.05n

* CHECK dout0_2 Vdout0_2ck178 = 0 time = 1790
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=1790.05n

* CHECK dout0_3 Vdout0_3ck178 = 1.8 time = 1790
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=1790.05n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 1790
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=1790.05n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 1790
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=1790.05n

* CHECK dout0_6 Vdout0_6ck178 = 1.8 time = 1790
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=1790.05n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 1790
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=1790.05n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 1790
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=1790.05n

* CHECK dout0_9 Vdout0_9ck178 = 0 time = 1790
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=1790.05n

* CHECK dout0_10 Vdout0_10ck178 = 1.8 time = 1790
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=1790.05n

* CHECK dout0_11 Vdout0_11ck178 = 1.8 time = 1790
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=1790.05n

* CHECK dout0_12 Vdout0_12ck178 = 1.8 time = 1790
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=1790.05n

* CHECK dout0_13 Vdout0_13ck178 = 0 time = 1790
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=1790.05n

* CHECK dout0_14 Vdout0_14ck178 = 1.8 time = 1790
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=1790.05n

* CHECK dout0_15 Vdout0_15ck178 = 0 time = 1790
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=1790.05n

* CHECK dout0_16 Vdout0_16ck178 = 0 time = 1790
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=1790.05n

* CHECK dout0_17 Vdout0_17ck178 = 1.8 time = 1790
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=1790.05n

* CHECK dout0_18 Vdout0_18ck178 = 1.8 time = 1790
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=1790.05n

* CHECK dout0_19 Vdout0_19ck178 = 1.8 time = 1790
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=1790.05n

* CHECK dout0_20 Vdout0_20ck178 = 1.8 time = 1790
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=1790.05n

* CHECK dout0_21 Vdout0_21ck178 = 0 time = 1790
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=1790.05n

* CHECK dout0_22 Vdout0_22ck178 = 1.8 time = 1790
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=1790.05n

* CHECK dout0_23 Vdout0_23ck178 = 0 time = 1790
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=1790.05n

* CHECK dout0_24 Vdout0_24ck178 = 0 time = 1790
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=1790.05n

* CHECK dout0_25 Vdout0_25ck178 = 0 time = 1790
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=1790.05n

* CHECK dout0_26 Vdout0_26ck178 = 0 time = 1790
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=1790.05n

* CHECK dout0_27 Vdout0_27ck178 = 1.8 time = 1790
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=1790.05n

* CHECK dout0_28 Vdout0_28ck178 = 1.8 time = 1790
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=1790.05n

* CHECK dout0_29 Vdout0_29ck178 = 1.8 time = 1790
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=1790.05n

* CHECK dout0_30 Vdout0_30ck178 = 0 time = 1790
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=1790.05n

* CHECK dout0_31 Vdout0_31ck178 = 0 time = 1790
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=1790.05n

* CHECK dout0_32 Vdout0_32ck178 = 0 time = 1790
.meas tran vdout0_32ck178 FIND v(dout0_32) AT=1790.05n

* CHECK dout0_33 Vdout0_33ck178 = 1.8 time = 1790
.meas tran vdout0_33ck178 FIND v(dout0_33) AT=1790.05n

* CHECK dout0_34 Vdout0_34ck178 = 0 time = 1790
.meas tran vdout0_34ck178 FIND v(dout0_34) AT=1790.05n

* CHECK dout0_35 Vdout0_35ck178 = 1.8 time = 1790
.meas tran vdout0_35ck178 FIND v(dout0_35) AT=1790.05n

* CHECK dout0_36 Vdout0_36ck178 = 1.8 time = 1790
.meas tran vdout0_36ck178 FIND v(dout0_36) AT=1790.05n

* CHECK dout0_37 Vdout0_37ck178 = 0 time = 1790
.meas tran vdout0_37ck178 FIND v(dout0_37) AT=1790.05n

* CHECK dout0_38 Vdout0_38ck178 = 1.8 time = 1790
.meas tran vdout0_38ck178 FIND v(dout0_38) AT=1790.05n

* CHECK dout0_39 Vdout0_39ck178 = 1.8 time = 1790
.meas tran vdout0_39ck178 FIND v(dout0_39) AT=1790.05n

* CHECK dout0_40 Vdout0_40ck178 = 0 time = 1790
.meas tran vdout0_40ck178 FIND v(dout0_40) AT=1790.05n

* CHECK dout0_41 Vdout0_41ck178 = 0 time = 1790
.meas tran vdout0_41ck178 FIND v(dout0_41) AT=1790.05n

* CHECK dout0_42 Vdout0_42ck178 = 1.8 time = 1790
.meas tran vdout0_42ck178 FIND v(dout0_42) AT=1790.05n

* CHECK dout0_43 Vdout0_43ck178 = 1.8 time = 1790
.meas tran vdout0_43ck178 FIND v(dout0_43) AT=1790.05n

* CHECK dout0_44 Vdout0_44ck178 = 0 time = 1790
.meas tran vdout0_44ck178 FIND v(dout0_44) AT=1790.05n

* CHECK dout0_45 Vdout0_45ck178 = 1.8 time = 1790
.meas tran vdout0_45ck178 FIND v(dout0_45) AT=1790.05n

* CHECK dout0_46 Vdout0_46ck178 = 1.8 time = 1790
.meas tran vdout0_46ck178 FIND v(dout0_46) AT=1790.05n

* CHECK dout0_47 Vdout0_47ck178 = 0 time = 1790
.meas tran vdout0_47ck178 FIND v(dout0_47) AT=1790.05n

* CHECK dout0_48 Vdout0_48ck178 = 0 time = 1790
.meas tran vdout0_48ck178 FIND v(dout0_48) AT=1790.05n

* CHECK dout0_49 Vdout0_49ck178 = 1.8 time = 1790
.meas tran vdout0_49ck178 FIND v(dout0_49) AT=1790.05n

* CHECK dout0_50 Vdout0_50ck178 = 1.8 time = 1790
.meas tran vdout0_50ck178 FIND v(dout0_50) AT=1790.05n

* CHECK dout0_51 Vdout0_51ck178 = 0 time = 1790
.meas tran vdout0_51ck178 FIND v(dout0_51) AT=1790.05n

* CHECK dout0_52 Vdout0_52ck178 = 0 time = 1790
.meas tran vdout0_52ck178 FIND v(dout0_52) AT=1790.05n

* CHECK dout0_53 Vdout0_53ck178 = 1.8 time = 1790
.meas tran vdout0_53ck178 FIND v(dout0_53) AT=1790.05n

* CHECK dout0_54 Vdout0_54ck178 = 0 time = 1790
.meas tran vdout0_54ck178 FIND v(dout0_54) AT=1790.05n

* CHECK dout0_55 Vdout0_55ck178 = 1.8 time = 1790
.meas tran vdout0_55ck178 FIND v(dout0_55) AT=1790.05n

* CHECK dout0_56 Vdout0_56ck178 = 1.8 time = 1790
.meas tran vdout0_56ck178 FIND v(dout0_56) AT=1790.05n

* CHECK dout0_57 Vdout0_57ck178 = 1.8 time = 1790
.meas tran vdout0_57ck178 FIND v(dout0_57) AT=1790.05n

* CHECK dout0_58 Vdout0_58ck178 = 0 time = 1790
.meas tran vdout0_58ck178 FIND v(dout0_58) AT=1790.05n

* CHECK dout0_59 Vdout0_59ck178 = 0 time = 1790
.meas tran vdout0_59ck178 FIND v(dout0_59) AT=1790.05n

* CHECK dout0_60 Vdout0_60ck178 = 1.8 time = 1790
.meas tran vdout0_60ck178 FIND v(dout0_60) AT=1790.05n

* CHECK dout0_61 Vdout0_61ck178 = 1.8 time = 1790
.meas tran vdout0_61ck178 FIND v(dout0_61) AT=1790.05n

* CHECK dout0_62 Vdout0_62ck178 = 1.8 time = 1790
.meas tran vdout0_62ck178 FIND v(dout0_62) AT=1790.05n

* CHECK dout0_63 Vdout0_63ck178 = 1.8 time = 1790
.meas tran vdout0_63ck178 FIND v(dout0_63) AT=1790.05n

* CHECK dout0_64 Vdout0_64ck178 = 0 time = 1790
.meas tran vdout0_64ck178 FIND v(dout0_64) AT=1790.05n

* CHECK dout0_0 Vdout0_0ck179 = 1.8 time = 1800
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=1800.05n

* CHECK dout0_1 Vdout0_1ck179 = 0 time = 1800
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=1800.05n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 1800
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=1800.05n

* CHECK dout0_3 Vdout0_3ck179 = 0 time = 1800
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=1800.05n

* CHECK dout0_4 Vdout0_4ck179 = 0 time = 1800
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=1800.05n

* CHECK dout0_5 Vdout0_5ck179 = 0 time = 1800
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=1800.05n

* CHECK dout0_6 Vdout0_6ck179 = 1.8 time = 1800
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=1800.05n

* CHECK dout0_7 Vdout0_7ck179 = 1.8 time = 1800
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=1800.05n

* CHECK dout0_8 Vdout0_8ck179 = 1.8 time = 1800
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=1800.05n

* CHECK dout0_9 Vdout0_9ck179 = 0 time = 1800
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=1800.05n

* CHECK dout0_10 Vdout0_10ck179 = 0 time = 1800
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=1800.05n

* CHECK dout0_11 Vdout0_11ck179 = 1.8 time = 1800
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=1800.05n

* CHECK dout0_12 Vdout0_12ck179 = 0 time = 1800
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=1800.05n

* CHECK dout0_13 Vdout0_13ck179 = 1.8 time = 1800
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=1800.05n

* CHECK dout0_14 Vdout0_14ck179 = 1.8 time = 1800
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=1800.05n

* CHECK dout0_15 Vdout0_15ck179 = 1.8 time = 1800
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=1800.05n

* CHECK dout0_16 Vdout0_16ck179 = 0 time = 1800
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=1800.05n

* CHECK dout0_17 Vdout0_17ck179 = 0 time = 1800
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=1800.05n

* CHECK dout0_18 Vdout0_18ck179 = 0 time = 1800
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=1800.05n

* CHECK dout0_19 Vdout0_19ck179 = 1.8 time = 1800
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=1800.05n

* CHECK dout0_20 Vdout0_20ck179 = 0 time = 1800
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=1800.05n

* CHECK dout0_21 Vdout0_21ck179 = 0 time = 1800
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=1800.05n

* CHECK dout0_22 Vdout0_22ck179 = 1.8 time = 1800
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=1800.05n

* CHECK dout0_23 Vdout0_23ck179 = 0 time = 1800
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=1800.05n

* CHECK dout0_24 Vdout0_24ck179 = 0 time = 1800
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=1800.05n

* CHECK dout0_25 Vdout0_25ck179 = 1.8 time = 1800
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=1800.05n

* CHECK dout0_26 Vdout0_26ck179 = 0 time = 1800
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=1800.05n

* CHECK dout0_27 Vdout0_27ck179 = 1.8 time = 1800
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=1800.05n

* CHECK dout0_28 Vdout0_28ck179 = 0 time = 1800
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=1800.05n

* CHECK dout0_29 Vdout0_29ck179 = 0 time = 1800
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=1800.05n

* CHECK dout0_30 Vdout0_30ck179 = 1.8 time = 1800
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=1800.05n

* CHECK dout0_31 Vdout0_31ck179 = 1.8 time = 1800
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=1800.05n

* CHECK dout0_32 Vdout0_32ck179 = 1.8 time = 1800
.meas tran vdout0_32ck179 FIND v(dout0_32) AT=1800.05n

* CHECK dout0_33 Vdout0_33ck179 = 1.8 time = 1800
.meas tran vdout0_33ck179 FIND v(dout0_33) AT=1800.05n

* CHECK dout0_34 Vdout0_34ck179 = 0 time = 1800
.meas tran vdout0_34ck179 FIND v(dout0_34) AT=1800.05n

* CHECK dout0_35 Vdout0_35ck179 = 1.8 time = 1800
.meas tran vdout0_35ck179 FIND v(dout0_35) AT=1800.05n

* CHECK dout0_36 Vdout0_36ck179 = 1.8 time = 1800
.meas tran vdout0_36ck179 FIND v(dout0_36) AT=1800.05n

* CHECK dout0_37 Vdout0_37ck179 = 0 time = 1800
.meas tran vdout0_37ck179 FIND v(dout0_37) AT=1800.05n

* CHECK dout0_38 Vdout0_38ck179 = 0 time = 1800
.meas tran vdout0_38ck179 FIND v(dout0_38) AT=1800.05n

* CHECK dout0_39 Vdout0_39ck179 = 0 time = 1800
.meas tran vdout0_39ck179 FIND v(dout0_39) AT=1800.05n

* CHECK dout0_40 Vdout0_40ck179 = 0 time = 1800
.meas tran vdout0_40ck179 FIND v(dout0_40) AT=1800.05n

* CHECK dout0_41 Vdout0_41ck179 = 0 time = 1800
.meas tran vdout0_41ck179 FIND v(dout0_41) AT=1800.05n

* CHECK dout0_42 Vdout0_42ck179 = 0 time = 1800
.meas tran vdout0_42ck179 FIND v(dout0_42) AT=1800.05n

* CHECK dout0_43 Vdout0_43ck179 = 1.8 time = 1800
.meas tran vdout0_43ck179 FIND v(dout0_43) AT=1800.05n

* CHECK dout0_44 Vdout0_44ck179 = 1.8 time = 1800
.meas tran vdout0_44ck179 FIND v(dout0_44) AT=1800.05n

* CHECK dout0_45 Vdout0_45ck179 = 1.8 time = 1800
.meas tran vdout0_45ck179 FIND v(dout0_45) AT=1800.05n

* CHECK dout0_46 Vdout0_46ck179 = 1.8 time = 1800
.meas tran vdout0_46ck179 FIND v(dout0_46) AT=1800.05n

* CHECK dout0_47 Vdout0_47ck179 = 1.8 time = 1800
.meas tran vdout0_47ck179 FIND v(dout0_47) AT=1800.05n

* CHECK dout0_48 Vdout0_48ck179 = 0 time = 1800
.meas tran vdout0_48ck179 FIND v(dout0_48) AT=1800.05n

* CHECK dout0_49 Vdout0_49ck179 = 1.8 time = 1800
.meas tran vdout0_49ck179 FIND v(dout0_49) AT=1800.05n

* CHECK dout0_50 Vdout0_50ck179 = 1.8 time = 1800
.meas tran vdout0_50ck179 FIND v(dout0_50) AT=1800.05n

* CHECK dout0_51 Vdout0_51ck179 = 1.8 time = 1800
.meas tran vdout0_51ck179 FIND v(dout0_51) AT=1800.05n

* CHECK dout0_52 Vdout0_52ck179 = 1.8 time = 1800
.meas tran vdout0_52ck179 FIND v(dout0_52) AT=1800.05n

* CHECK dout0_53 Vdout0_53ck179 = 1.8 time = 1800
.meas tran vdout0_53ck179 FIND v(dout0_53) AT=1800.05n

* CHECK dout0_54 Vdout0_54ck179 = 0 time = 1800
.meas tran vdout0_54ck179 FIND v(dout0_54) AT=1800.05n

* CHECK dout0_55 Vdout0_55ck179 = 1.8 time = 1800
.meas tran vdout0_55ck179 FIND v(dout0_55) AT=1800.05n

* CHECK dout0_56 Vdout0_56ck179 = 1.8 time = 1800
.meas tran vdout0_56ck179 FIND v(dout0_56) AT=1800.05n

* CHECK dout0_57 Vdout0_57ck179 = 1.8 time = 1800
.meas tran vdout0_57ck179 FIND v(dout0_57) AT=1800.05n

* CHECK dout0_58 Vdout0_58ck179 = 0 time = 1800
.meas tran vdout0_58ck179 FIND v(dout0_58) AT=1800.05n

* CHECK dout0_59 Vdout0_59ck179 = 0 time = 1800
.meas tran vdout0_59ck179 FIND v(dout0_59) AT=1800.05n

* CHECK dout0_60 Vdout0_60ck179 = 0 time = 1800
.meas tran vdout0_60ck179 FIND v(dout0_60) AT=1800.05n

* CHECK dout0_61 Vdout0_61ck179 = 1.8 time = 1800
.meas tran vdout0_61ck179 FIND v(dout0_61) AT=1800.05n

* CHECK dout0_62 Vdout0_62ck179 = 1.8 time = 1800
.meas tran vdout0_62ck179 FIND v(dout0_62) AT=1800.05n

* CHECK dout0_63 Vdout0_63ck179 = 0 time = 1800
.meas tran vdout0_63ck179 FIND v(dout0_63) AT=1800.05n

* CHECK dout0_64 Vdout0_64ck179 = 0 time = 1800
.meas tran vdout0_64ck179 FIND v(dout0_64) AT=1800.05n

* CHECK dout0_0 Vdout0_0ck180 = 1.8 time = 1810
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=1810.05n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 1810
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=1810.05n

* CHECK dout0_2 Vdout0_2ck180 = 0 time = 1810
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=1810.05n

* CHECK dout0_3 Vdout0_3ck180 = 0 time = 1810
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=1810.05n

* CHECK dout0_4 Vdout0_4ck180 = 0 time = 1810
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=1810.05n

* CHECK dout0_5 Vdout0_5ck180 = 0 time = 1810
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=1810.05n

* CHECK dout0_6 Vdout0_6ck180 = 1.8 time = 1810
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=1810.05n

* CHECK dout0_7 Vdout0_7ck180 = 1.8 time = 1810
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=1810.05n

* CHECK dout0_8 Vdout0_8ck180 = 1.8 time = 1810
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=1810.05n

* CHECK dout0_9 Vdout0_9ck180 = 0 time = 1810
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=1810.05n

* CHECK dout0_10 Vdout0_10ck180 = 0 time = 1810
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=1810.05n

* CHECK dout0_11 Vdout0_11ck180 = 1.8 time = 1810
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=1810.05n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 1810
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=1810.05n

* CHECK dout0_13 Vdout0_13ck180 = 1.8 time = 1810
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=1810.05n

* CHECK dout0_14 Vdout0_14ck180 = 1.8 time = 1810
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=1810.05n

* CHECK dout0_15 Vdout0_15ck180 = 1.8 time = 1810
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=1810.05n

* CHECK dout0_16 Vdout0_16ck180 = 0 time = 1810
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=1810.05n

* CHECK dout0_17 Vdout0_17ck180 = 0 time = 1810
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=1810.05n

* CHECK dout0_18 Vdout0_18ck180 = 0 time = 1810
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=1810.05n

* CHECK dout0_19 Vdout0_19ck180 = 1.8 time = 1810
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=1810.05n

* CHECK dout0_20 Vdout0_20ck180 = 0 time = 1810
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=1810.05n

* CHECK dout0_21 Vdout0_21ck180 = 0 time = 1810
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=1810.05n

* CHECK dout0_22 Vdout0_22ck180 = 1.8 time = 1810
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=1810.05n

* CHECK dout0_23 Vdout0_23ck180 = 0 time = 1810
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=1810.05n

* CHECK dout0_24 Vdout0_24ck180 = 0 time = 1810
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=1810.05n

* CHECK dout0_25 Vdout0_25ck180 = 1.8 time = 1810
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=1810.05n

* CHECK dout0_26 Vdout0_26ck180 = 0 time = 1810
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=1810.05n

* CHECK dout0_27 Vdout0_27ck180 = 1.8 time = 1810
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=1810.05n

* CHECK dout0_28 Vdout0_28ck180 = 0 time = 1810
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=1810.05n

* CHECK dout0_29 Vdout0_29ck180 = 0 time = 1810
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=1810.05n

* CHECK dout0_30 Vdout0_30ck180 = 1.8 time = 1810
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=1810.05n

* CHECK dout0_31 Vdout0_31ck180 = 1.8 time = 1810
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=1810.05n

* CHECK dout0_32 Vdout0_32ck180 = 1.8 time = 1810
.meas tran vdout0_32ck180 FIND v(dout0_32) AT=1810.05n

* CHECK dout0_33 Vdout0_33ck180 = 1.8 time = 1810
.meas tran vdout0_33ck180 FIND v(dout0_33) AT=1810.05n

* CHECK dout0_34 Vdout0_34ck180 = 0 time = 1810
.meas tran vdout0_34ck180 FIND v(dout0_34) AT=1810.05n

* CHECK dout0_35 Vdout0_35ck180 = 1.8 time = 1810
.meas tran vdout0_35ck180 FIND v(dout0_35) AT=1810.05n

* CHECK dout0_36 Vdout0_36ck180 = 1.8 time = 1810
.meas tran vdout0_36ck180 FIND v(dout0_36) AT=1810.05n

* CHECK dout0_37 Vdout0_37ck180 = 0 time = 1810
.meas tran vdout0_37ck180 FIND v(dout0_37) AT=1810.05n

* CHECK dout0_38 Vdout0_38ck180 = 0 time = 1810
.meas tran vdout0_38ck180 FIND v(dout0_38) AT=1810.05n

* CHECK dout0_39 Vdout0_39ck180 = 0 time = 1810
.meas tran vdout0_39ck180 FIND v(dout0_39) AT=1810.05n

* CHECK dout0_40 Vdout0_40ck180 = 0 time = 1810
.meas tran vdout0_40ck180 FIND v(dout0_40) AT=1810.05n

* CHECK dout0_41 Vdout0_41ck180 = 0 time = 1810
.meas tran vdout0_41ck180 FIND v(dout0_41) AT=1810.05n

* CHECK dout0_42 Vdout0_42ck180 = 0 time = 1810
.meas tran vdout0_42ck180 FIND v(dout0_42) AT=1810.05n

* CHECK dout0_43 Vdout0_43ck180 = 1.8 time = 1810
.meas tran vdout0_43ck180 FIND v(dout0_43) AT=1810.05n

* CHECK dout0_44 Vdout0_44ck180 = 1.8 time = 1810
.meas tran vdout0_44ck180 FIND v(dout0_44) AT=1810.05n

* CHECK dout0_45 Vdout0_45ck180 = 1.8 time = 1810
.meas tran vdout0_45ck180 FIND v(dout0_45) AT=1810.05n

* CHECK dout0_46 Vdout0_46ck180 = 1.8 time = 1810
.meas tran vdout0_46ck180 FIND v(dout0_46) AT=1810.05n

* CHECK dout0_47 Vdout0_47ck180 = 1.8 time = 1810
.meas tran vdout0_47ck180 FIND v(dout0_47) AT=1810.05n

* CHECK dout0_48 Vdout0_48ck180 = 0 time = 1810
.meas tran vdout0_48ck180 FIND v(dout0_48) AT=1810.05n

* CHECK dout0_49 Vdout0_49ck180 = 1.8 time = 1810
.meas tran vdout0_49ck180 FIND v(dout0_49) AT=1810.05n

* CHECK dout0_50 Vdout0_50ck180 = 1.8 time = 1810
.meas tran vdout0_50ck180 FIND v(dout0_50) AT=1810.05n

* CHECK dout0_51 Vdout0_51ck180 = 1.8 time = 1810
.meas tran vdout0_51ck180 FIND v(dout0_51) AT=1810.05n

* CHECK dout0_52 Vdout0_52ck180 = 1.8 time = 1810
.meas tran vdout0_52ck180 FIND v(dout0_52) AT=1810.05n

* CHECK dout0_53 Vdout0_53ck180 = 1.8 time = 1810
.meas tran vdout0_53ck180 FIND v(dout0_53) AT=1810.05n

* CHECK dout0_54 Vdout0_54ck180 = 0 time = 1810
.meas tran vdout0_54ck180 FIND v(dout0_54) AT=1810.05n

* CHECK dout0_55 Vdout0_55ck180 = 1.8 time = 1810
.meas tran vdout0_55ck180 FIND v(dout0_55) AT=1810.05n

* CHECK dout0_56 Vdout0_56ck180 = 1.8 time = 1810
.meas tran vdout0_56ck180 FIND v(dout0_56) AT=1810.05n

* CHECK dout0_57 Vdout0_57ck180 = 1.8 time = 1810
.meas tran vdout0_57ck180 FIND v(dout0_57) AT=1810.05n

* CHECK dout0_58 Vdout0_58ck180 = 0 time = 1810
.meas tran vdout0_58ck180 FIND v(dout0_58) AT=1810.05n

* CHECK dout0_59 Vdout0_59ck180 = 0 time = 1810
.meas tran vdout0_59ck180 FIND v(dout0_59) AT=1810.05n

* CHECK dout0_60 Vdout0_60ck180 = 0 time = 1810
.meas tran vdout0_60ck180 FIND v(dout0_60) AT=1810.05n

* CHECK dout0_61 Vdout0_61ck180 = 1.8 time = 1810
.meas tran vdout0_61ck180 FIND v(dout0_61) AT=1810.05n

* CHECK dout0_62 Vdout0_62ck180 = 1.8 time = 1810
.meas tran vdout0_62ck180 FIND v(dout0_62) AT=1810.05n

* CHECK dout0_63 Vdout0_63ck180 = 0 time = 1810
.meas tran vdout0_63ck180 FIND v(dout0_63) AT=1810.05n

* CHECK dout0_64 Vdout0_64ck180 = 0 time = 1810
.meas tran vdout0_64ck180 FIND v(dout0_64) AT=1810.05n

* CHECK dout0_0 Vdout0_0ck182 = 0 time = 1830
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=1830.05n

* CHECK dout0_1 Vdout0_1ck182 = 0 time = 1830
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=1830.05n

* CHECK dout0_2 Vdout0_2ck182 = 1.8 time = 1830
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=1830.05n

* CHECK dout0_3 Vdout0_3ck182 = 1.8 time = 1830
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=1830.05n

* CHECK dout0_4 Vdout0_4ck182 = 1.8 time = 1830
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=1830.05n

* CHECK dout0_5 Vdout0_5ck182 = 1.8 time = 1830
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=1830.05n

* CHECK dout0_6 Vdout0_6ck182 = 1.8 time = 1830
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=1830.05n

* CHECK dout0_7 Vdout0_7ck182 = 0 time = 1830
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=1830.05n

* CHECK dout0_8 Vdout0_8ck182 = 1.8 time = 1830
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=1830.05n

* CHECK dout0_9 Vdout0_9ck182 = 0 time = 1830
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=1830.05n

* CHECK dout0_10 Vdout0_10ck182 = 0 time = 1830
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=1830.05n

* CHECK dout0_11 Vdout0_11ck182 = 1.8 time = 1830
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=1830.05n

* CHECK dout0_12 Vdout0_12ck182 = 0 time = 1830
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=1830.05n

* CHECK dout0_13 Vdout0_13ck182 = 1.8 time = 1830
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=1830.05n

* CHECK dout0_14 Vdout0_14ck182 = 0 time = 1830
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=1830.05n

* CHECK dout0_15 Vdout0_15ck182 = 0 time = 1830
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=1830.05n

* CHECK dout0_16 Vdout0_16ck182 = 1.8 time = 1830
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=1830.05n

* CHECK dout0_17 Vdout0_17ck182 = 0 time = 1830
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=1830.05n

* CHECK dout0_18 Vdout0_18ck182 = 1.8 time = 1830
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=1830.05n

* CHECK dout0_19 Vdout0_19ck182 = 0 time = 1830
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=1830.05n

* CHECK dout0_20 Vdout0_20ck182 = 1.8 time = 1830
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=1830.05n

* CHECK dout0_21 Vdout0_21ck182 = 1.8 time = 1830
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=1830.05n

* CHECK dout0_22 Vdout0_22ck182 = 1.8 time = 1830
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=1830.05n

* CHECK dout0_23 Vdout0_23ck182 = 1.8 time = 1830
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=1830.05n

* CHECK dout0_24 Vdout0_24ck182 = 0 time = 1830
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=1830.05n

* CHECK dout0_25 Vdout0_25ck182 = 0 time = 1830
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=1830.05n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 1830
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=1830.05n

* CHECK dout0_27 Vdout0_27ck182 = 0 time = 1830
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=1830.05n

* CHECK dout0_28 Vdout0_28ck182 = 0 time = 1830
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=1830.05n

* CHECK dout0_29 Vdout0_29ck182 = 1.8 time = 1830
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=1830.05n

* CHECK dout0_30 Vdout0_30ck182 = 1.8 time = 1830
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=1830.05n

* CHECK dout0_31 Vdout0_31ck182 = 0 time = 1830
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=1830.05n

* CHECK dout0_32 Vdout0_32ck182 = 1.8 time = 1830
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=1830.05n

* CHECK dout0_33 Vdout0_33ck182 = 1.8 time = 1830
.meas tran vdout0_33ck182 FIND v(dout0_33) AT=1830.05n

* CHECK dout0_34 Vdout0_34ck182 = 0 time = 1830
.meas tran vdout0_34ck182 FIND v(dout0_34) AT=1830.05n

* CHECK dout0_35 Vdout0_35ck182 = 1.8 time = 1830
.meas tran vdout0_35ck182 FIND v(dout0_35) AT=1830.05n

* CHECK dout0_36 Vdout0_36ck182 = 1.8 time = 1830
.meas tran vdout0_36ck182 FIND v(dout0_36) AT=1830.05n

* CHECK dout0_37 Vdout0_37ck182 = 0 time = 1830
.meas tran vdout0_37ck182 FIND v(dout0_37) AT=1830.05n

* CHECK dout0_38 Vdout0_38ck182 = 1.8 time = 1830
.meas tran vdout0_38ck182 FIND v(dout0_38) AT=1830.05n

* CHECK dout0_39 Vdout0_39ck182 = 1.8 time = 1830
.meas tran vdout0_39ck182 FIND v(dout0_39) AT=1830.05n

* CHECK dout0_40 Vdout0_40ck182 = 1.8 time = 1830
.meas tran vdout0_40ck182 FIND v(dout0_40) AT=1830.05n

* CHECK dout0_41 Vdout0_41ck182 = 1.8 time = 1830
.meas tran vdout0_41ck182 FIND v(dout0_41) AT=1830.05n

* CHECK dout0_42 Vdout0_42ck182 = 1.8 time = 1830
.meas tran vdout0_42ck182 FIND v(dout0_42) AT=1830.05n

* CHECK dout0_43 Vdout0_43ck182 = 0 time = 1830
.meas tran vdout0_43ck182 FIND v(dout0_43) AT=1830.05n

* CHECK dout0_44 Vdout0_44ck182 = 1.8 time = 1830
.meas tran vdout0_44ck182 FIND v(dout0_44) AT=1830.05n

* CHECK dout0_45 Vdout0_45ck182 = 1.8 time = 1830
.meas tran vdout0_45ck182 FIND v(dout0_45) AT=1830.05n

* CHECK dout0_46 Vdout0_46ck182 = 0 time = 1830
.meas tran vdout0_46ck182 FIND v(dout0_46) AT=1830.05n

* CHECK dout0_47 Vdout0_47ck182 = 1.8 time = 1830
.meas tran vdout0_47ck182 FIND v(dout0_47) AT=1830.05n

* CHECK dout0_48 Vdout0_48ck182 = 1.8 time = 1830
.meas tran vdout0_48ck182 FIND v(dout0_48) AT=1830.05n

* CHECK dout0_49 Vdout0_49ck182 = 0 time = 1830
.meas tran vdout0_49ck182 FIND v(dout0_49) AT=1830.05n

* CHECK dout0_50 Vdout0_50ck182 = 1.8 time = 1830
.meas tran vdout0_50ck182 FIND v(dout0_50) AT=1830.05n

* CHECK dout0_51 Vdout0_51ck182 = 1.8 time = 1830
.meas tran vdout0_51ck182 FIND v(dout0_51) AT=1830.05n

* CHECK dout0_52 Vdout0_52ck182 = 1.8 time = 1830
.meas tran vdout0_52ck182 FIND v(dout0_52) AT=1830.05n

* CHECK dout0_53 Vdout0_53ck182 = 1.8 time = 1830
.meas tran vdout0_53ck182 FIND v(dout0_53) AT=1830.05n

* CHECK dout0_54 Vdout0_54ck182 = 1.8 time = 1830
.meas tran vdout0_54ck182 FIND v(dout0_54) AT=1830.05n

* CHECK dout0_55 Vdout0_55ck182 = 0 time = 1830
.meas tran vdout0_55ck182 FIND v(dout0_55) AT=1830.05n

* CHECK dout0_56 Vdout0_56ck182 = 0 time = 1830
.meas tran vdout0_56ck182 FIND v(dout0_56) AT=1830.05n

* CHECK dout0_57 Vdout0_57ck182 = 0 time = 1830
.meas tran vdout0_57ck182 FIND v(dout0_57) AT=1830.05n

* CHECK dout0_58 Vdout0_58ck182 = 1.8 time = 1830
.meas tran vdout0_58ck182 FIND v(dout0_58) AT=1830.05n

* CHECK dout0_59 Vdout0_59ck182 = 1.8 time = 1830
.meas tran vdout0_59ck182 FIND v(dout0_59) AT=1830.05n

* CHECK dout0_60 Vdout0_60ck182 = 0 time = 1830
.meas tran vdout0_60ck182 FIND v(dout0_60) AT=1830.05n

* CHECK dout0_61 Vdout0_61ck182 = 1.8 time = 1830
.meas tran vdout0_61ck182 FIND v(dout0_61) AT=1830.05n

* CHECK dout0_62 Vdout0_62ck182 = 1.8 time = 1830
.meas tran vdout0_62ck182 FIND v(dout0_62) AT=1830.05n

* CHECK dout0_63 Vdout0_63ck182 = 0 time = 1830
.meas tran vdout0_63ck182 FIND v(dout0_63) AT=1830.05n

* CHECK dout0_64 Vdout0_64ck182 = 0 time = 1830
.meas tran vdout0_64ck182 FIND v(dout0_64) AT=1830.05n

* CHECK dout0_0 Vdout0_0ck183 = 1.8 time = 1840
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=1840.05n

* CHECK dout0_1 Vdout0_1ck183 = 1.8 time = 1840
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=1840.05n

* CHECK dout0_2 Vdout0_2ck183 = 0 time = 1840
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=1840.05n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 1840
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=1840.05n

* CHECK dout0_4 Vdout0_4ck183 = 0 time = 1840
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=1840.05n

* CHECK dout0_5 Vdout0_5ck183 = 0 time = 1840
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=1840.05n

* CHECK dout0_6 Vdout0_6ck183 = 1.8 time = 1840
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=1840.05n

* CHECK dout0_7 Vdout0_7ck183 = 0 time = 1840
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=1840.05n

* CHECK dout0_8 Vdout0_8ck183 = 0 time = 1840
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=1840.05n

* CHECK dout0_9 Vdout0_9ck183 = 0 time = 1840
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=1840.05n

* CHECK dout0_10 Vdout0_10ck183 = 1.8 time = 1840
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=1840.05n

* CHECK dout0_11 Vdout0_11ck183 = 1.8 time = 1840
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=1840.05n

* CHECK dout0_12 Vdout0_12ck183 = 1.8 time = 1840
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=1840.05n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 1840
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=1840.05n

* CHECK dout0_14 Vdout0_14ck183 = 1.8 time = 1840
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=1840.05n

* CHECK dout0_15 Vdout0_15ck183 = 0 time = 1840
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=1840.05n

* CHECK dout0_16 Vdout0_16ck183 = 0 time = 1840
.meas tran vdout0_16ck183 FIND v(dout0_16) AT=1840.05n

* CHECK dout0_17 Vdout0_17ck183 = 1.8 time = 1840
.meas tran vdout0_17ck183 FIND v(dout0_17) AT=1840.05n

* CHECK dout0_18 Vdout0_18ck183 = 1.8 time = 1840
.meas tran vdout0_18ck183 FIND v(dout0_18) AT=1840.05n

* CHECK dout0_19 Vdout0_19ck183 = 1.8 time = 1840
.meas tran vdout0_19ck183 FIND v(dout0_19) AT=1840.05n

* CHECK dout0_20 Vdout0_20ck183 = 1.8 time = 1840
.meas tran vdout0_20ck183 FIND v(dout0_20) AT=1840.05n

* CHECK dout0_21 Vdout0_21ck183 = 0 time = 1840
.meas tran vdout0_21ck183 FIND v(dout0_21) AT=1840.05n

* CHECK dout0_22 Vdout0_22ck183 = 1.8 time = 1840
.meas tran vdout0_22ck183 FIND v(dout0_22) AT=1840.05n

* CHECK dout0_23 Vdout0_23ck183 = 0 time = 1840
.meas tran vdout0_23ck183 FIND v(dout0_23) AT=1840.05n

* CHECK dout0_24 Vdout0_24ck183 = 0 time = 1840
.meas tran vdout0_24ck183 FIND v(dout0_24) AT=1840.05n

* CHECK dout0_25 Vdout0_25ck183 = 0 time = 1840
.meas tran vdout0_25ck183 FIND v(dout0_25) AT=1840.05n

* CHECK dout0_26 Vdout0_26ck183 = 0 time = 1840
.meas tran vdout0_26ck183 FIND v(dout0_26) AT=1840.05n

* CHECK dout0_27 Vdout0_27ck183 = 1.8 time = 1840
.meas tran vdout0_27ck183 FIND v(dout0_27) AT=1840.05n

* CHECK dout0_28 Vdout0_28ck183 = 1.8 time = 1840
.meas tran vdout0_28ck183 FIND v(dout0_28) AT=1840.05n

* CHECK dout0_29 Vdout0_29ck183 = 1.8 time = 1840
.meas tran vdout0_29ck183 FIND v(dout0_29) AT=1840.05n

* CHECK dout0_30 Vdout0_30ck183 = 0 time = 1840
.meas tran vdout0_30ck183 FIND v(dout0_30) AT=1840.05n

* CHECK dout0_31 Vdout0_31ck183 = 0 time = 1840
.meas tran vdout0_31ck183 FIND v(dout0_31) AT=1840.05n

* CHECK dout0_32 Vdout0_32ck183 = 0 time = 1840
.meas tran vdout0_32ck183 FIND v(dout0_32) AT=1840.05n

* CHECK dout0_33 Vdout0_33ck183 = 1.8 time = 1840
.meas tran vdout0_33ck183 FIND v(dout0_33) AT=1840.05n

* CHECK dout0_34 Vdout0_34ck183 = 0 time = 1840
.meas tran vdout0_34ck183 FIND v(dout0_34) AT=1840.05n

* CHECK dout0_35 Vdout0_35ck183 = 1.8 time = 1840
.meas tran vdout0_35ck183 FIND v(dout0_35) AT=1840.05n

* CHECK dout0_36 Vdout0_36ck183 = 1.8 time = 1840
.meas tran vdout0_36ck183 FIND v(dout0_36) AT=1840.05n

* CHECK dout0_37 Vdout0_37ck183 = 0 time = 1840
.meas tran vdout0_37ck183 FIND v(dout0_37) AT=1840.05n

* CHECK dout0_38 Vdout0_38ck183 = 1.8 time = 1840
.meas tran vdout0_38ck183 FIND v(dout0_38) AT=1840.05n

* CHECK dout0_39 Vdout0_39ck183 = 1.8 time = 1840
.meas tran vdout0_39ck183 FIND v(dout0_39) AT=1840.05n

* CHECK dout0_40 Vdout0_40ck183 = 0 time = 1840
.meas tran vdout0_40ck183 FIND v(dout0_40) AT=1840.05n

* CHECK dout0_41 Vdout0_41ck183 = 0 time = 1840
.meas tran vdout0_41ck183 FIND v(dout0_41) AT=1840.05n

* CHECK dout0_42 Vdout0_42ck183 = 1.8 time = 1840
.meas tran vdout0_42ck183 FIND v(dout0_42) AT=1840.05n

* CHECK dout0_43 Vdout0_43ck183 = 1.8 time = 1840
.meas tran vdout0_43ck183 FIND v(dout0_43) AT=1840.05n

* CHECK dout0_44 Vdout0_44ck183 = 0 time = 1840
.meas tran vdout0_44ck183 FIND v(dout0_44) AT=1840.05n

* CHECK dout0_45 Vdout0_45ck183 = 1.8 time = 1840
.meas tran vdout0_45ck183 FIND v(dout0_45) AT=1840.05n

* CHECK dout0_46 Vdout0_46ck183 = 1.8 time = 1840
.meas tran vdout0_46ck183 FIND v(dout0_46) AT=1840.05n

* CHECK dout0_47 Vdout0_47ck183 = 0 time = 1840
.meas tran vdout0_47ck183 FIND v(dout0_47) AT=1840.05n

* CHECK dout0_48 Vdout0_48ck183 = 0 time = 1840
.meas tran vdout0_48ck183 FIND v(dout0_48) AT=1840.05n

* CHECK dout0_49 Vdout0_49ck183 = 1.8 time = 1840
.meas tran vdout0_49ck183 FIND v(dout0_49) AT=1840.05n

* CHECK dout0_50 Vdout0_50ck183 = 1.8 time = 1840
.meas tran vdout0_50ck183 FIND v(dout0_50) AT=1840.05n

* CHECK dout0_51 Vdout0_51ck183 = 0 time = 1840
.meas tran vdout0_51ck183 FIND v(dout0_51) AT=1840.05n

* CHECK dout0_52 Vdout0_52ck183 = 0 time = 1840
.meas tran vdout0_52ck183 FIND v(dout0_52) AT=1840.05n

* CHECK dout0_53 Vdout0_53ck183 = 1.8 time = 1840
.meas tran vdout0_53ck183 FIND v(dout0_53) AT=1840.05n

* CHECK dout0_54 Vdout0_54ck183 = 0 time = 1840
.meas tran vdout0_54ck183 FIND v(dout0_54) AT=1840.05n

* CHECK dout0_55 Vdout0_55ck183 = 1.8 time = 1840
.meas tran vdout0_55ck183 FIND v(dout0_55) AT=1840.05n

* CHECK dout0_56 Vdout0_56ck183 = 1.8 time = 1840
.meas tran vdout0_56ck183 FIND v(dout0_56) AT=1840.05n

* CHECK dout0_57 Vdout0_57ck183 = 1.8 time = 1840
.meas tran vdout0_57ck183 FIND v(dout0_57) AT=1840.05n

* CHECK dout0_58 Vdout0_58ck183 = 0 time = 1840
.meas tran vdout0_58ck183 FIND v(dout0_58) AT=1840.05n

* CHECK dout0_59 Vdout0_59ck183 = 0 time = 1840
.meas tran vdout0_59ck183 FIND v(dout0_59) AT=1840.05n

* CHECK dout0_60 Vdout0_60ck183 = 1.8 time = 1840
.meas tran vdout0_60ck183 FIND v(dout0_60) AT=1840.05n

* CHECK dout0_61 Vdout0_61ck183 = 1.8 time = 1840
.meas tran vdout0_61ck183 FIND v(dout0_61) AT=1840.05n

* CHECK dout0_62 Vdout0_62ck183 = 1.8 time = 1840
.meas tran vdout0_62ck183 FIND v(dout0_62) AT=1840.05n

* CHECK dout0_63 Vdout0_63ck183 = 1.8 time = 1840
.meas tran vdout0_63ck183 FIND v(dout0_63) AT=1840.05n

* CHECK dout0_64 Vdout0_64ck183 = 0 time = 1840
.meas tran vdout0_64ck183 FIND v(dout0_64) AT=1840.05n

* CHECK dout0_0 Vdout0_0ck184 = 0 time = 1850
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=1850.05n

* CHECK dout0_1 Vdout0_1ck184 = 0 time = 1850
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=1850.05n

* CHECK dout0_2 Vdout0_2ck184 = 1.8 time = 1850
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=1850.05n

* CHECK dout0_3 Vdout0_3ck184 = 1.8 time = 1850
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=1850.05n

* CHECK dout0_4 Vdout0_4ck184 = 1.8 time = 1850
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=1850.05n

* CHECK dout0_5 Vdout0_5ck184 = 1.8 time = 1850
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=1850.05n

* CHECK dout0_6 Vdout0_6ck184 = 1.8 time = 1850
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=1850.05n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 1850
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=1850.05n

* CHECK dout0_8 Vdout0_8ck184 = 1.8 time = 1850
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=1850.05n

* CHECK dout0_9 Vdout0_9ck184 = 0 time = 1850
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=1850.05n

* CHECK dout0_10 Vdout0_10ck184 = 0 time = 1850
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=1850.05n

* CHECK dout0_11 Vdout0_11ck184 = 1.8 time = 1850
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=1850.05n

* CHECK dout0_12 Vdout0_12ck184 = 0 time = 1850
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=1850.05n

* CHECK dout0_13 Vdout0_13ck184 = 1.8 time = 1850
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=1850.05n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 1850
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=1850.05n

* CHECK dout0_15 Vdout0_15ck184 = 0 time = 1850
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=1850.05n

* CHECK dout0_16 Vdout0_16ck184 = 1.8 time = 1850
.meas tran vdout0_16ck184 FIND v(dout0_16) AT=1850.05n

* CHECK dout0_17 Vdout0_17ck184 = 0 time = 1850
.meas tran vdout0_17ck184 FIND v(dout0_17) AT=1850.05n

* CHECK dout0_18 Vdout0_18ck184 = 1.8 time = 1850
.meas tran vdout0_18ck184 FIND v(dout0_18) AT=1850.05n

* CHECK dout0_19 Vdout0_19ck184 = 0 time = 1850
.meas tran vdout0_19ck184 FIND v(dout0_19) AT=1850.05n

* CHECK dout0_20 Vdout0_20ck184 = 1.8 time = 1850
.meas tran vdout0_20ck184 FIND v(dout0_20) AT=1850.05n

* CHECK dout0_21 Vdout0_21ck184 = 1.8 time = 1850
.meas tran vdout0_21ck184 FIND v(dout0_21) AT=1850.05n

* CHECK dout0_22 Vdout0_22ck184 = 1.8 time = 1850
.meas tran vdout0_22ck184 FIND v(dout0_22) AT=1850.05n

* CHECK dout0_23 Vdout0_23ck184 = 1.8 time = 1850
.meas tran vdout0_23ck184 FIND v(dout0_23) AT=1850.05n

* CHECK dout0_24 Vdout0_24ck184 = 0 time = 1850
.meas tran vdout0_24ck184 FIND v(dout0_24) AT=1850.05n

* CHECK dout0_25 Vdout0_25ck184 = 0 time = 1850
.meas tran vdout0_25ck184 FIND v(dout0_25) AT=1850.05n

* CHECK dout0_26 Vdout0_26ck184 = 0 time = 1850
.meas tran vdout0_26ck184 FIND v(dout0_26) AT=1850.05n

* CHECK dout0_27 Vdout0_27ck184 = 0 time = 1850
.meas tran vdout0_27ck184 FIND v(dout0_27) AT=1850.05n

* CHECK dout0_28 Vdout0_28ck184 = 0 time = 1850
.meas tran vdout0_28ck184 FIND v(dout0_28) AT=1850.05n

* CHECK dout0_29 Vdout0_29ck184 = 1.8 time = 1850
.meas tran vdout0_29ck184 FIND v(dout0_29) AT=1850.05n

* CHECK dout0_30 Vdout0_30ck184 = 1.8 time = 1850
.meas tran vdout0_30ck184 FIND v(dout0_30) AT=1850.05n

* CHECK dout0_31 Vdout0_31ck184 = 0 time = 1850
.meas tran vdout0_31ck184 FIND v(dout0_31) AT=1850.05n

* CHECK dout0_32 Vdout0_32ck184 = 1.8 time = 1850
.meas tran vdout0_32ck184 FIND v(dout0_32) AT=1850.05n

* CHECK dout0_33 Vdout0_33ck184 = 1.8 time = 1850
.meas tran vdout0_33ck184 FIND v(dout0_33) AT=1850.05n

* CHECK dout0_34 Vdout0_34ck184 = 0 time = 1850
.meas tran vdout0_34ck184 FIND v(dout0_34) AT=1850.05n

* CHECK dout0_35 Vdout0_35ck184 = 1.8 time = 1850
.meas tran vdout0_35ck184 FIND v(dout0_35) AT=1850.05n

* CHECK dout0_36 Vdout0_36ck184 = 1.8 time = 1850
.meas tran vdout0_36ck184 FIND v(dout0_36) AT=1850.05n

* CHECK dout0_37 Vdout0_37ck184 = 0 time = 1850
.meas tran vdout0_37ck184 FIND v(dout0_37) AT=1850.05n

* CHECK dout0_38 Vdout0_38ck184 = 1.8 time = 1850
.meas tran vdout0_38ck184 FIND v(dout0_38) AT=1850.05n

* CHECK dout0_39 Vdout0_39ck184 = 1.8 time = 1850
.meas tran vdout0_39ck184 FIND v(dout0_39) AT=1850.05n

* CHECK dout0_40 Vdout0_40ck184 = 1.8 time = 1850
.meas tran vdout0_40ck184 FIND v(dout0_40) AT=1850.05n

* CHECK dout0_41 Vdout0_41ck184 = 1.8 time = 1850
.meas tran vdout0_41ck184 FIND v(dout0_41) AT=1850.05n

* CHECK dout0_42 Vdout0_42ck184 = 1.8 time = 1850
.meas tran vdout0_42ck184 FIND v(dout0_42) AT=1850.05n

* CHECK dout0_43 Vdout0_43ck184 = 0 time = 1850
.meas tran vdout0_43ck184 FIND v(dout0_43) AT=1850.05n

* CHECK dout0_44 Vdout0_44ck184 = 1.8 time = 1850
.meas tran vdout0_44ck184 FIND v(dout0_44) AT=1850.05n

* CHECK dout0_45 Vdout0_45ck184 = 1.8 time = 1850
.meas tran vdout0_45ck184 FIND v(dout0_45) AT=1850.05n

* CHECK dout0_46 Vdout0_46ck184 = 0 time = 1850
.meas tran vdout0_46ck184 FIND v(dout0_46) AT=1850.05n

* CHECK dout0_47 Vdout0_47ck184 = 1.8 time = 1850
.meas tran vdout0_47ck184 FIND v(dout0_47) AT=1850.05n

* CHECK dout0_48 Vdout0_48ck184 = 1.8 time = 1850
.meas tran vdout0_48ck184 FIND v(dout0_48) AT=1850.05n

* CHECK dout0_49 Vdout0_49ck184 = 0 time = 1850
.meas tran vdout0_49ck184 FIND v(dout0_49) AT=1850.05n

* CHECK dout0_50 Vdout0_50ck184 = 1.8 time = 1850
.meas tran vdout0_50ck184 FIND v(dout0_50) AT=1850.05n

* CHECK dout0_51 Vdout0_51ck184 = 1.8 time = 1850
.meas tran vdout0_51ck184 FIND v(dout0_51) AT=1850.05n

* CHECK dout0_52 Vdout0_52ck184 = 1.8 time = 1850
.meas tran vdout0_52ck184 FIND v(dout0_52) AT=1850.05n

* CHECK dout0_53 Vdout0_53ck184 = 1.8 time = 1850
.meas tran vdout0_53ck184 FIND v(dout0_53) AT=1850.05n

* CHECK dout0_54 Vdout0_54ck184 = 1.8 time = 1850
.meas tran vdout0_54ck184 FIND v(dout0_54) AT=1850.05n

* CHECK dout0_55 Vdout0_55ck184 = 0 time = 1850
.meas tran vdout0_55ck184 FIND v(dout0_55) AT=1850.05n

* CHECK dout0_56 Vdout0_56ck184 = 0 time = 1850
.meas tran vdout0_56ck184 FIND v(dout0_56) AT=1850.05n

* CHECK dout0_57 Vdout0_57ck184 = 0 time = 1850
.meas tran vdout0_57ck184 FIND v(dout0_57) AT=1850.05n

* CHECK dout0_58 Vdout0_58ck184 = 1.8 time = 1850
.meas tran vdout0_58ck184 FIND v(dout0_58) AT=1850.05n

* CHECK dout0_59 Vdout0_59ck184 = 1.8 time = 1850
.meas tran vdout0_59ck184 FIND v(dout0_59) AT=1850.05n

* CHECK dout0_60 Vdout0_60ck184 = 0 time = 1850
.meas tran vdout0_60ck184 FIND v(dout0_60) AT=1850.05n

* CHECK dout0_61 Vdout0_61ck184 = 1.8 time = 1850
.meas tran vdout0_61ck184 FIND v(dout0_61) AT=1850.05n

* CHECK dout0_62 Vdout0_62ck184 = 1.8 time = 1850
.meas tran vdout0_62ck184 FIND v(dout0_62) AT=1850.05n

* CHECK dout0_63 Vdout0_63ck184 = 0 time = 1850
.meas tran vdout0_63ck184 FIND v(dout0_63) AT=1850.05n

* CHECK dout0_64 Vdout0_64ck184 = 0 time = 1850
.meas tran vdout0_64ck184 FIND v(dout0_64) AT=1850.05n

* CHECK dout0_0 Vdout0_0ck185 = 0 time = 1860
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=1860.05n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 1860
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=1860.05n

* CHECK dout0_2 Vdout0_2ck185 = 0 time = 1860
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=1860.05n

* CHECK dout0_3 Vdout0_3ck185 = 1.8 time = 1860
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=1860.05n

* CHECK dout0_4 Vdout0_4ck185 = 0 time = 1860
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=1860.05n

* CHECK dout0_5 Vdout0_5ck185 = 1.8 time = 1860
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=1860.05n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 1860
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=1860.05n

* CHECK dout0_7 Vdout0_7ck185 = 1.8 time = 1860
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=1860.05n

* CHECK dout0_8 Vdout0_8ck185 = 1.8 time = 1860
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=1860.05n

* CHECK dout0_9 Vdout0_9ck185 = 1.8 time = 1860
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=1860.05n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 1860
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=1860.05n

* CHECK dout0_11 Vdout0_11ck185 = 1.8 time = 1860
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=1860.05n

* CHECK dout0_12 Vdout0_12ck185 = 0 time = 1860
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=1860.05n

* CHECK dout0_13 Vdout0_13ck185 = 1.8 time = 1860
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=1860.05n

* CHECK dout0_14 Vdout0_14ck185 = 0 time = 1860
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=1860.05n

* CHECK dout0_15 Vdout0_15ck185 = 1.8 time = 1860
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=1860.05n

* CHECK dout0_16 Vdout0_16ck185 = 1.8 time = 1860
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=1860.05n

* CHECK dout0_17 Vdout0_17ck185 = 1.8 time = 1860
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=1860.05n

* CHECK dout0_18 Vdout0_18ck185 = 0 time = 1860
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=1860.05n

* CHECK dout0_19 Vdout0_19ck185 = 1.8 time = 1860
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=1860.05n

* CHECK dout0_20 Vdout0_20ck185 = 0 time = 1860
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=1860.05n

* CHECK dout0_21 Vdout0_21ck185 = 0 time = 1860
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=1860.05n

* CHECK dout0_22 Vdout0_22ck185 = 0 time = 1860
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=1860.05n

* CHECK dout0_23 Vdout0_23ck185 = 1.8 time = 1860
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=1860.05n

* CHECK dout0_24 Vdout0_24ck185 = 1.8 time = 1860
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=1860.05n

* CHECK dout0_25 Vdout0_25ck185 = 0 time = 1860
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=1860.05n

* CHECK dout0_26 Vdout0_26ck185 = 0 time = 1860
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=1860.05n

* CHECK dout0_27 Vdout0_27ck185 = 0 time = 1860
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=1860.05n

* CHECK dout0_28 Vdout0_28ck185 = 0 time = 1860
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=1860.05n

* CHECK dout0_29 Vdout0_29ck185 = 1.8 time = 1860
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=1860.05n

* CHECK dout0_30 Vdout0_30ck185 = 0 time = 1860
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=1860.05n

* CHECK dout0_31 Vdout0_31ck185 = 0 time = 1860
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=1860.05n

* CHECK dout0_32 Vdout0_32ck185 = 0 time = 1860
.meas tran vdout0_32ck185 FIND v(dout0_32) AT=1860.05n

* CHECK dout0_33 Vdout0_33ck185 = 1.8 time = 1860
.meas tran vdout0_33ck185 FIND v(dout0_33) AT=1860.05n

* CHECK dout0_34 Vdout0_34ck185 = 1.8 time = 1860
.meas tran vdout0_34ck185 FIND v(dout0_34) AT=1860.05n

* CHECK dout0_35 Vdout0_35ck185 = 1.8 time = 1860
.meas tran vdout0_35ck185 FIND v(dout0_35) AT=1860.05n

* CHECK dout0_36 Vdout0_36ck185 = 1.8 time = 1860
.meas tran vdout0_36ck185 FIND v(dout0_36) AT=1860.05n

* CHECK dout0_37 Vdout0_37ck185 = 0 time = 1860
.meas tran vdout0_37ck185 FIND v(dout0_37) AT=1860.05n

* CHECK dout0_38 Vdout0_38ck185 = 1.8 time = 1860
.meas tran vdout0_38ck185 FIND v(dout0_38) AT=1860.05n

* CHECK dout0_39 Vdout0_39ck185 = 1.8 time = 1860
.meas tran vdout0_39ck185 FIND v(dout0_39) AT=1860.05n

* CHECK dout0_40 Vdout0_40ck185 = 0 time = 1860
.meas tran vdout0_40ck185 FIND v(dout0_40) AT=1860.05n

* CHECK dout0_41 Vdout0_41ck185 = 0 time = 1860
.meas tran vdout0_41ck185 FIND v(dout0_41) AT=1860.05n

* CHECK dout0_42 Vdout0_42ck185 = 0 time = 1860
.meas tran vdout0_42ck185 FIND v(dout0_42) AT=1860.05n

* CHECK dout0_43 Vdout0_43ck185 = 1.8 time = 1860
.meas tran vdout0_43ck185 FIND v(dout0_43) AT=1860.05n

* CHECK dout0_44 Vdout0_44ck185 = 0 time = 1860
.meas tran vdout0_44ck185 FIND v(dout0_44) AT=1860.05n

* CHECK dout0_45 Vdout0_45ck185 = 1.8 time = 1860
.meas tran vdout0_45ck185 FIND v(dout0_45) AT=1860.05n

* CHECK dout0_46 Vdout0_46ck185 = 1.8 time = 1860
.meas tran vdout0_46ck185 FIND v(dout0_46) AT=1860.05n

* CHECK dout0_47 Vdout0_47ck185 = 0 time = 1860
.meas tran vdout0_47ck185 FIND v(dout0_47) AT=1860.05n

* CHECK dout0_48 Vdout0_48ck185 = 0 time = 1860
.meas tran vdout0_48ck185 FIND v(dout0_48) AT=1860.05n

* CHECK dout0_49 Vdout0_49ck185 = 0 time = 1860
.meas tran vdout0_49ck185 FIND v(dout0_49) AT=1860.05n

* CHECK dout0_50 Vdout0_50ck185 = 0 time = 1860
.meas tran vdout0_50ck185 FIND v(dout0_50) AT=1860.05n

* CHECK dout0_51 Vdout0_51ck185 = 0 time = 1860
.meas tran vdout0_51ck185 FIND v(dout0_51) AT=1860.05n

* CHECK dout0_52 Vdout0_52ck185 = 0 time = 1860
.meas tran vdout0_52ck185 FIND v(dout0_52) AT=1860.05n

* CHECK dout0_53 Vdout0_53ck185 = 1.8 time = 1860
.meas tran vdout0_53ck185 FIND v(dout0_53) AT=1860.05n

* CHECK dout0_54 Vdout0_54ck185 = 0 time = 1860
.meas tran vdout0_54ck185 FIND v(dout0_54) AT=1860.05n

* CHECK dout0_55 Vdout0_55ck185 = 0 time = 1860
.meas tran vdout0_55ck185 FIND v(dout0_55) AT=1860.05n

* CHECK dout0_56 Vdout0_56ck185 = 0 time = 1860
.meas tran vdout0_56ck185 FIND v(dout0_56) AT=1860.05n

* CHECK dout0_57 Vdout0_57ck185 = 1.8 time = 1860
.meas tran vdout0_57ck185 FIND v(dout0_57) AT=1860.05n

* CHECK dout0_58 Vdout0_58ck185 = 1.8 time = 1860
.meas tran vdout0_58ck185 FIND v(dout0_58) AT=1860.05n

* CHECK dout0_59 Vdout0_59ck185 = 0 time = 1860
.meas tran vdout0_59ck185 FIND v(dout0_59) AT=1860.05n

* CHECK dout0_60 Vdout0_60ck185 = 1.8 time = 1860
.meas tran vdout0_60ck185 FIND v(dout0_60) AT=1860.05n

* CHECK dout0_61 Vdout0_61ck185 = 0 time = 1860
.meas tran vdout0_61ck185 FIND v(dout0_61) AT=1860.05n

* CHECK dout0_62 Vdout0_62ck185 = 0 time = 1860
.meas tran vdout0_62ck185 FIND v(dout0_62) AT=1860.05n

* CHECK dout0_63 Vdout0_63ck185 = 0 time = 1860
.meas tran vdout0_63ck185 FIND v(dout0_63) AT=1860.05n

* CHECK dout0_64 Vdout0_64ck185 = 0 time = 1860
.meas tran vdout0_64ck185 FIND v(dout0_64) AT=1860.05n

* CHECK dout0_0 Vdout0_0ck188 = 1.8 time = 1890
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=1890.05n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 1890
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=1890.05n

* CHECK dout0_2 Vdout0_2ck188 = 0 time = 1890
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=1890.05n

* CHECK dout0_3 Vdout0_3ck188 = 1.8 time = 1890
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=1890.05n

* CHECK dout0_4 Vdout0_4ck188 = 0 time = 1890
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=1890.05n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 1890
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=1890.05n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 1890
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=1890.05n

* CHECK dout0_7 Vdout0_7ck188 = 1.8 time = 1890
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=1890.05n

* CHECK dout0_8 Vdout0_8ck188 = 0 time = 1890
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=1890.05n

* CHECK dout0_9 Vdout0_9ck188 = 0 time = 1890
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=1890.05n

* CHECK dout0_10 Vdout0_10ck188 = 0 time = 1890
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=1890.05n

* CHECK dout0_11 Vdout0_11ck188 = 0 time = 1890
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=1890.05n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 1890
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=1890.05n

* CHECK dout0_13 Vdout0_13ck188 = 1.8 time = 1890
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=1890.05n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 1890
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=1890.05n

* CHECK dout0_15 Vdout0_15ck188 = 1.8 time = 1890
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=1890.05n

* CHECK dout0_16 Vdout0_16ck188 = 1.8 time = 1890
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=1890.05n

* CHECK dout0_17 Vdout0_17ck188 = 0 time = 1890
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=1890.05n

* CHECK dout0_18 Vdout0_18ck188 = 0 time = 1890
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=1890.05n

* CHECK dout0_19 Vdout0_19ck188 = 1.8 time = 1890
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=1890.05n

* CHECK dout0_20 Vdout0_20ck188 = 1.8 time = 1890
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=1890.05n

* CHECK dout0_21 Vdout0_21ck188 = 1.8 time = 1890
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=1890.05n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 1890
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=1890.05n

* CHECK dout0_23 Vdout0_23ck188 = 1.8 time = 1890
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=1890.05n

* CHECK dout0_24 Vdout0_24ck188 = 0 time = 1890
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=1890.05n

* CHECK dout0_25 Vdout0_25ck188 = 1.8 time = 1890
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=1890.05n

* CHECK dout0_26 Vdout0_26ck188 = 0 time = 1890
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=1890.05n

* CHECK dout0_27 Vdout0_27ck188 = 0 time = 1890
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=1890.05n

* CHECK dout0_28 Vdout0_28ck188 = 1.8 time = 1890
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=1890.05n

* CHECK dout0_29 Vdout0_29ck188 = 1.8 time = 1890
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=1890.05n

* CHECK dout0_30 Vdout0_30ck188 = 1.8 time = 1890
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=1890.05n

* CHECK dout0_31 Vdout0_31ck188 = 0 time = 1890
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=1890.05n

* CHECK dout0_32 Vdout0_32ck188 = 1.8 time = 1890
.meas tran vdout0_32ck188 FIND v(dout0_32) AT=1890.05n

* CHECK dout0_33 Vdout0_33ck188 = 1.8 time = 1890
.meas tran vdout0_33ck188 FIND v(dout0_33) AT=1890.05n

* CHECK dout0_34 Vdout0_34ck188 = 1.8 time = 1890
.meas tran vdout0_34ck188 FIND v(dout0_34) AT=1890.05n

* CHECK dout0_35 Vdout0_35ck188 = 0 time = 1890
.meas tran vdout0_35ck188 FIND v(dout0_35) AT=1890.05n

* CHECK dout0_36 Vdout0_36ck188 = 0 time = 1890
.meas tran vdout0_36ck188 FIND v(dout0_36) AT=1890.05n

* CHECK dout0_37 Vdout0_37ck188 = 0 time = 1890
.meas tran vdout0_37ck188 FIND v(dout0_37) AT=1890.05n

* CHECK dout0_38 Vdout0_38ck188 = 0 time = 1890
.meas tran vdout0_38ck188 FIND v(dout0_38) AT=1890.05n

* CHECK dout0_39 Vdout0_39ck188 = 0 time = 1890
.meas tran vdout0_39ck188 FIND v(dout0_39) AT=1890.05n

* CHECK dout0_40 Vdout0_40ck188 = 1.8 time = 1890
.meas tran vdout0_40ck188 FIND v(dout0_40) AT=1890.05n

* CHECK dout0_41 Vdout0_41ck188 = 1.8 time = 1890
.meas tran vdout0_41ck188 FIND v(dout0_41) AT=1890.05n

* CHECK dout0_42 Vdout0_42ck188 = 1.8 time = 1890
.meas tran vdout0_42ck188 FIND v(dout0_42) AT=1890.05n

* CHECK dout0_43 Vdout0_43ck188 = 0 time = 1890
.meas tran vdout0_43ck188 FIND v(dout0_43) AT=1890.05n

* CHECK dout0_44 Vdout0_44ck188 = 1.8 time = 1890
.meas tran vdout0_44ck188 FIND v(dout0_44) AT=1890.05n

* CHECK dout0_45 Vdout0_45ck188 = 1.8 time = 1890
.meas tran vdout0_45ck188 FIND v(dout0_45) AT=1890.05n

* CHECK dout0_46 Vdout0_46ck188 = 1.8 time = 1890
.meas tran vdout0_46ck188 FIND v(dout0_46) AT=1890.05n

* CHECK dout0_47 Vdout0_47ck188 = 0 time = 1890
.meas tran vdout0_47ck188 FIND v(dout0_47) AT=1890.05n

* CHECK dout0_48 Vdout0_48ck188 = 1.8 time = 1890
.meas tran vdout0_48ck188 FIND v(dout0_48) AT=1890.05n

* CHECK dout0_49 Vdout0_49ck188 = 1.8 time = 1890
.meas tran vdout0_49ck188 FIND v(dout0_49) AT=1890.05n

* CHECK dout0_50 Vdout0_50ck188 = 1.8 time = 1890
.meas tran vdout0_50ck188 FIND v(dout0_50) AT=1890.05n

* CHECK dout0_51 Vdout0_51ck188 = 1.8 time = 1890
.meas tran vdout0_51ck188 FIND v(dout0_51) AT=1890.05n

* CHECK dout0_52 Vdout0_52ck188 = 0 time = 1890
.meas tran vdout0_52ck188 FIND v(dout0_52) AT=1890.05n

* CHECK dout0_53 Vdout0_53ck188 = 0 time = 1890
.meas tran vdout0_53ck188 FIND v(dout0_53) AT=1890.05n

* CHECK dout0_54 Vdout0_54ck188 = 1.8 time = 1890
.meas tran vdout0_54ck188 FIND v(dout0_54) AT=1890.05n

* CHECK dout0_55 Vdout0_55ck188 = 1.8 time = 1890
.meas tran vdout0_55ck188 FIND v(dout0_55) AT=1890.05n

* CHECK dout0_56 Vdout0_56ck188 = 1.8 time = 1890
.meas tran vdout0_56ck188 FIND v(dout0_56) AT=1890.05n

* CHECK dout0_57 Vdout0_57ck188 = 0 time = 1890
.meas tran vdout0_57ck188 FIND v(dout0_57) AT=1890.05n

* CHECK dout0_58 Vdout0_58ck188 = 1.8 time = 1890
.meas tran vdout0_58ck188 FIND v(dout0_58) AT=1890.05n

* CHECK dout0_59 Vdout0_59ck188 = 1.8 time = 1890
.meas tran vdout0_59ck188 FIND v(dout0_59) AT=1890.05n

* CHECK dout0_60 Vdout0_60ck188 = 1.8 time = 1890
.meas tran vdout0_60ck188 FIND v(dout0_60) AT=1890.05n

* CHECK dout0_61 Vdout0_61ck188 = 1.8 time = 1890
.meas tran vdout0_61ck188 FIND v(dout0_61) AT=1890.05n

* CHECK dout0_62 Vdout0_62ck188 = 1.8 time = 1890
.meas tran vdout0_62ck188 FIND v(dout0_62) AT=1890.05n

* CHECK dout0_63 Vdout0_63ck188 = 1.8 time = 1890
.meas tran vdout0_63ck188 FIND v(dout0_63) AT=1890.05n

* CHECK dout0_64 Vdout0_64ck188 = 0 time = 1890
.meas tran vdout0_64ck188 FIND v(dout0_64) AT=1890.05n

* CHECK dout0_0 Vdout0_0ck192 = 1.8 time = 1930
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=1930.05n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 1930
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=1930.05n

* CHECK dout0_2 Vdout0_2ck192 = 1.8 time = 1930
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=1930.05n

* CHECK dout0_3 Vdout0_3ck192 = 0 time = 1930
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=1930.05n

* CHECK dout0_4 Vdout0_4ck192 = 0 time = 1930
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=1930.05n

* CHECK dout0_5 Vdout0_5ck192 = 1.8 time = 1930
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=1930.05n

* CHECK dout0_6 Vdout0_6ck192 = 1.8 time = 1930
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=1930.05n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 1930
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=1930.05n

* CHECK dout0_8 Vdout0_8ck192 = 1.8 time = 1930
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=1930.05n

* CHECK dout0_9 Vdout0_9ck192 = 1.8 time = 1930
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=1930.05n

* CHECK dout0_10 Vdout0_10ck192 = 1.8 time = 1930
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=1930.05n

* CHECK dout0_11 Vdout0_11ck192 = 1.8 time = 1930
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=1930.05n

* CHECK dout0_12 Vdout0_12ck192 = 1.8 time = 1930
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=1930.05n

* CHECK dout0_13 Vdout0_13ck192 = 1.8 time = 1930
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=1930.05n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 1930
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=1930.05n

* CHECK dout0_15 Vdout0_15ck192 = 1.8 time = 1930
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=1930.05n

* CHECK dout0_16 Vdout0_16ck192 = 0 time = 1930
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=1930.05n

* CHECK dout0_17 Vdout0_17ck192 = 1.8 time = 1930
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=1930.05n

* CHECK dout0_18 Vdout0_18ck192 = 1.8 time = 1930
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=1930.05n

* CHECK dout0_19 Vdout0_19ck192 = 0 time = 1930
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=1930.05n

* CHECK dout0_20 Vdout0_20ck192 = 1.8 time = 1930
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=1930.05n

* CHECK dout0_21 Vdout0_21ck192 = 1.8 time = 1930
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=1930.05n

* CHECK dout0_22 Vdout0_22ck192 = 0 time = 1930
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=1930.05n

* CHECK dout0_23 Vdout0_23ck192 = 0 time = 1930
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=1930.05n

* CHECK dout0_24 Vdout0_24ck192 = 0 time = 1930
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=1930.05n

* CHECK dout0_25 Vdout0_25ck192 = 0 time = 1930
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=1930.05n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 1930
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=1930.05n

* CHECK dout0_27 Vdout0_27ck192 = 1.8 time = 1930
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=1930.05n

* CHECK dout0_28 Vdout0_28ck192 = 1.8 time = 1930
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=1930.05n

* CHECK dout0_29 Vdout0_29ck192 = 0 time = 1930
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=1930.05n

* CHECK dout0_30 Vdout0_30ck192 = 1.8 time = 1930
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=1930.05n

* CHECK dout0_31 Vdout0_31ck192 = 0 time = 1930
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=1930.05n

* CHECK dout0_32 Vdout0_32ck192 = 0 time = 1930
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=1930.05n

* CHECK dout0_33 Vdout0_33ck192 = 1.8 time = 1930
.meas tran vdout0_33ck192 FIND v(dout0_33) AT=1930.05n

* CHECK dout0_34 Vdout0_34ck192 = 1.8 time = 1930
.meas tran vdout0_34ck192 FIND v(dout0_34) AT=1930.05n

* CHECK dout0_35 Vdout0_35ck192 = 0 time = 1930
.meas tran vdout0_35ck192 FIND v(dout0_35) AT=1930.05n

* CHECK dout0_36 Vdout0_36ck192 = 0 time = 1930
.meas tran vdout0_36ck192 FIND v(dout0_36) AT=1930.05n

* CHECK dout0_37 Vdout0_37ck192 = 1.8 time = 1930
.meas tran vdout0_37ck192 FIND v(dout0_37) AT=1930.05n

* CHECK dout0_38 Vdout0_38ck192 = 0 time = 1930
.meas tran vdout0_38ck192 FIND v(dout0_38) AT=1930.05n

* CHECK dout0_39 Vdout0_39ck192 = 0 time = 1930
.meas tran vdout0_39ck192 FIND v(dout0_39) AT=1930.05n

* CHECK dout0_40 Vdout0_40ck192 = 1.8 time = 1930
.meas tran vdout0_40ck192 FIND v(dout0_40) AT=1930.05n

* CHECK dout0_41 Vdout0_41ck192 = 0 time = 1930
.meas tran vdout0_41ck192 FIND v(dout0_41) AT=1930.05n

* CHECK dout0_42 Vdout0_42ck192 = 0 time = 1930
.meas tran vdout0_42ck192 FIND v(dout0_42) AT=1930.05n

* CHECK dout0_43 Vdout0_43ck192 = 1.8 time = 1930
.meas tran vdout0_43ck192 FIND v(dout0_43) AT=1930.05n

* CHECK dout0_44 Vdout0_44ck192 = 1.8 time = 1930
.meas tran vdout0_44ck192 FIND v(dout0_44) AT=1930.05n

* CHECK dout0_45 Vdout0_45ck192 = 0 time = 1930
.meas tran vdout0_45ck192 FIND v(dout0_45) AT=1930.05n

* CHECK dout0_46 Vdout0_46ck192 = 0 time = 1930
.meas tran vdout0_46ck192 FIND v(dout0_46) AT=1930.05n

* CHECK dout0_47 Vdout0_47ck192 = 1.8 time = 1930
.meas tran vdout0_47ck192 FIND v(dout0_47) AT=1930.05n

* CHECK dout0_48 Vdout0_48ck192 = 0 time = 1930
.meas tran vdout0_48ck192 FIND v(dout0_48) AT=1930.05n

* CHECK dout0_49 Vdout0_49ck192 = 1.8 time = 1930
.meas tran vdout0_49ck192 FIND v(dout0_49) AT=1930.05n

* CHECK dout0_50 Vdout0_50ck192 = 0 time = 1930
.meas tran vdout0_50ck192 FIND v(dout0_50) AT=1930.05n

* CHECK dout0_51 Vdout0_51ck192 = 0 time = 1930
.meas tran vdout0_51ck192 FIND v(dout0_51) AT=1930.05n

* CHECK dout0_52 Vdout0_52ck192 = 1.8 time = 1930
.meas tran vdout0_52ck192 FIND v(dout0_52) AT=1930.05n

* CHECK dout0_53 Vdout0_53ck192 = 0 time = 1930
.meas tran vdout0_53ck192 FIND v(dout0_53) AT=1930.05n

* CHECK dout0_54 Vdout0_54ck192 = 0 time = 1930
.meas tran vdout0_54ck192 FIND v(dout0_54) AT=1930.05n

* CHECK dout0_55 Vdout0_55ck192 = 1.8 time = 1930
.meas tran vdout0_55ck192 FIND v(dout0_55) AT=1930.05n

* CHECK dout0_56 Vdout0_56ck192 = 0 time = 1930
.meas tran vdout0_56ck192 FIND v(dout0_56) AT=1930.05n

* CHECK dout0_57 Vdout0_57ck192 = 1.8 time = 1930
.meas tran vdout0_57ck192 FIND v(dout0_57) AT=1930.05n

* CHECK dout0_58 Vdout0_58ck192 = 1.8 time = 1930
.meas tran vdout0_58ck192 FIND v(dout0_58) AT=1930.05n

* CHECK dout0_59 Vdout0_59ck192 = 0 time = 1930
.meas tran vdout0_59ck192 FIND v(dout0_59) AT=1930.05n

* CHECK dout0_60 Vdout0_60ck192 = 1.8 time = 1930
.meas tran vdout0_60ck192 FIND v(dout0_60) AT=1930.05n

* CHECK dout0_61 Vdout0_61ck192 = 1.8 time = 1930
.meas tran vdout0_61ck192 FIND v(dout0_61) AT=1930.05n

* CHECK dout0_62 Vdout0_62ck192 = 0 time = 1930
.meas tran vdout0_62ck192 FIND v(dout0_62) AT=1930.05n

* CHECK dout0_63 Vdout0_63ck192 = 1.8 time = 1930
.meas tran vdout0_63ck192 FIND v(dout0_63) AT=1930.05n

* CHECK dout0_64 Vdout0_64ck192 = 0 time = 1930
.meas tran vdout0_64ck192 FIND v(dout0_64) AT=1930.05n

* CHECK dout0_0 Vdout0_0ck194 = 1.8 time = 1950
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=1950.05n

* CHECK dout0_1 Vdout0_1ck194 = 0 time = 1950
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=1950.05n

* CHECK dout0_2 Vdout0_2ck194 = 0 time = 1950
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=1950.05n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 1950
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=1950.05n

* CHECK dout0_4 Vdout0_4ck194 = 0 time = 1950
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=1950.05n

* CHECK dout0_5 Vdout0_5ck194 = 0 time = 1950
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=1950.05n

* CHECK dout0_6 Vdout0_6ck194 = 1.8 time = 1950
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=1950.05n

* CHECK dout0_7 Vdout0_7ck194 = 1.8 time = 1950
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=1950.05n

* CHECK dout0_8 Vdout0_8ck194 = 1.8 time = 1950
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=1950.05n

* CHECK dout0_9 Vdout0_9ck194 = 0 time = 1950
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=1950.05n

* CHECK dout0_10 Vdout0_10ck194 = 0 time = 1950
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=1950.05n

* CHECK dout0_11 Vdout0_11ck194 = 1.8 time = 1950
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=1950.05n

* CHECK dout0_12 Vdout0_12ck194 = 0 time = 1950
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=1950.05n

* CHECK dout0_13 Vdout0_13ck194 = 1.8 time = 1950
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=1950.05n

* CHECK dout0_14 Vdout0_14ck194 = 1.8 time = 1950
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=1950.05n

* CHECK dout0_15 Vdout0_15ck194 = 1.8 time = 1950
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=1950.05n

* CHECK dout0_16 Vdout0_16ck194 = 0 time = 1950
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=1950.05n

* CHECK dout0_17 Vdout0_17ck194 = 0 time = 1950
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=1950.05n

* CHECK dout0_18 Vdout0_18ck194 = 0 time = 1950
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=1950.05n

* CHECK dout0_19 Vdout0_19ck194 = 1.8 time = 1950
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=1950.05n

* CHECK dout0_20 Vdout0_20ck194 = 0 time = 1950
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=1950.05n

* CHECK dout0_21 Vdout0_21ck194 = 0 time = 1950
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=1950.05n

* CHECK dout0_22 Vdout0_22ck194 = 1.8 time = 1950
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=1950.05n

* CHECK dout0_23 Vdout0_23ck194 = 0 time = 1950
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=1950.05n

* CHECK dout0_24 Vdout0_24ck194 = 0 time = 1950
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=1950.05n

* CHECK dout0_25 Vdout0_25ck194 = 1.8 time = 1950
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=1950.05n

* CHECK dout0_26 Vdout0_26ck194 = 0 time = 1950
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=1950.05n

* CHECK dout0_27 Vdout0_27ck194 = 1.8 time = 1950
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=1950.05n

* CHECK dout0_28 Vdout0_28ck194 = 0 time = 1950
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=1950.05n

* CHECK dout0_29 Vdout0_29ck194 = 0 time = 1950
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=1950.05n

* CHECK dout0_30 Vdout0_30ck194 = 1.8 time = 1950
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=1950.05n

* CHECK dout0_31 Vdout0_31ck194 = 1.8 time = 1950
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=1950.05n

* CHECK dout0_32 Vdout0_32ck194 = 1.8 time = 1950
.meas tran vdout0_32ck194 FIND v(dout0_32) AT=1950.05n

* CHECK dout0_33 Vdout0_33ck194 = 1.8 time = 1950
.meas tran vdout0_33ck194 FIND v(dout0_33) AT=1950.05n

* CHECK dout0_34 Vdout0_34ck194 = 0 time = 1950
.meas tran vdout0_34ck194 FIND v(dout0_34) AT=1950.05n

* CHECK dout0_35 Vdout0_35ck194 = 1.8 time = 1950
.meas tran vdout0_35ck194 FIND v(dout0_35) AT=1950.05n

* CHECK dout0_36 Vdout0_36ck194 = 1.8 time = 1950
.meas tran vdout0_36ck194 FIND v(dout0_36) AT=1950.05n

* CHECK dout0_37 Vdout0_37ck194 = 0 time = 1950
.meas tran vdout0_37ck194 FIND v(dout0_37) AT=1950.05n

* CHECK dout0_38 Vdout0_38ck194 = 0 time = 1950
.meas tran vdout0_38ck194 FIND v(dout0_38) AT=1950.05n

* CHECK dout0_39 Vdout0_39ck194 = 0 time = 1950
.meas tran vdout0_39ck194 FIND v(dout0_39) AT=1950.05n

* CHECK dout0_40 Vdout0_40ck194 = 0 time = 1950
.meas tran vdout0_40ck194 FIND v(dout0_40) AT=1950.05n

* CHECK dout0_41 Vdout0_41ck194 = 0 time = 1950
.meas tran vdout0_41ck194 FIND v(dout0_41) AT=1950.05n

* CHECK dout0_42 Vdout0_42ck194 = 0 time = 1950
.meas tran vdout0_42ck194 FIND v(dout0_42) AT=1950.05n

* CHECK dout0_43 Vdout0_43ck194 = 1.8 time = 1950
.meas tran vdout0_43ck194 FIND v(dout0_43) AT=1950.05n

* CHECK dout0_44 Vdout0_44ck194 = 1.8 time = 1950
.meas tran vdout0_44ck194 FIND v(dout0_44) AT=1950.05n

* CHECK dout0_45 Vdout0_45ck194 = 1.8 time = 1950
.meas tran vdout0_45ck194 FIND v(dout0_45) AT=1950.05n

* CHECK dout0_46 Vdout0_46ck194 = 1.8 time = 1950
.meas tran vdout0_46ck194 FIND v(dout0_46) AT=1950.05n

* CHECK dout0_47 Vdout0_47ck194 = 1.8 time = 1950
.meas tran vdout0_47ck194 FIND v(dout0_47) AT=1950.05n

* CHECK dout0_48 Vdout0_48ck194 = 0 time = 1950
.meas tran vdout0_48ck194 FIND v(dout0_48) AT=1950.05n

* CHECK dout0_49 Vdout0_49ck194 = 1.8 time = 1950
.meas tran vdout0_49ck194 FIND v(dout0_49) AT=1950.05n

* CHECK dout0_50 Vdout0_50ck194 = 1.8 time = 1950
.meas tran vdout0_50ck194 FIND v(dout0_50) AT=1950.05n

* CHECK dout0_51 Vdout0_51ck194 = 1.8 time = 1950
.meas tran vdout0_51ck194 FIND v(dout0_51) AT=1950.05n

* CHECK dout0_52 Vdout0_52ck194 = 1.8 time = 1950
.meas tran vdout0_52ck194 FIND v(dout0_52) AT=1950.05n

* CHECK dout0_53 Vdout0_53ck194 = 1.8 time = 1950
.meas tran vdout0_53ck194 FIND v(dout0_53) AT=1950.05n

* CHECK dout0_54 Vdout0_54ck194 = 0 time = 1950
.meas tran vdout0_54ck194 FIND v(dout0_54) AT=1950.05n

* CHECK dout0_55 Vdout0_55ck194 = 1.8 time = 1950
.meas tran vdout0_55ck194 FIND v(dout0_55) AT=1950.05n

* CHECK dout0_56 Vdout0_56ck194 = 1.8 time = 1950
.meas tran vdout0_56ck194 FIND v(dout0_56) AT=1950.05n

* CHECK dout0_57 Vdout0_57ck194 = 1.8 time = 1950
.meas tran vdout0_57ck194 FIND v(dout0_57) AT=1950.05n

* CHECK dout0_58 Vdout0_58ck194 = 0 time = 1950
.meas tran vdout0_58ck194 FIND v(dout0_58) AT=1950.05n

* CHECK dout0_59 Vdout0_59ck194 = 0 time = 1950
.meas tran vdout0_59ck194 FIND v(dout0_59) AT=1950.05n

* CHECK dout0_60 Vdout0_60ck194 = 0 time = 1950
.meas tran vdout0_60ck194 FIND v(dout0_60) AT=1950.05n

* CHECK dout0_61 Vdout0_61ck194 = 1.8 time = 1950
.meas tran vdout0_61ck194 FIND v(dout0_61) AT=1950.05n

* CHECK dout0_62 Vdout0_62ck194 = 1.8 time = 1950
.meas tran vdout0_62ck194 FIND v(dout0_62) AT=1950.05n

* CHECK dout0_63 Vdout0_63ck194 = 0 time = 1950
.meas tran vdout0_63ck194 FIND v(dout0_63) AT=1950.05n

* CHECK dout0_64 Vdout0_64ck194 = 0 time = 1950
.meas tran vdout0_64ck194 FIND v(dout0_64) AT=1950.05n

* CHECK dout0_0 Vdout0_0ck198 = 1.8 time = 1990
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=1990.05n

* CHECK dout0_1 Vdout0_1ck198 = 1.8 time = 1990
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=1990.05n

* CHECK dout0_2 Vdout0_2ck198 = 1.8 time = 1990
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=1990.05n

* CHECK dout0_3 Vdout0_3ck198 = 1.8 time = 1990
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=1990.05n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 1990
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=1990.05n

* CHECK dout0_5 Vdout0_5ck198 = 1.8 time = 1990
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=1990.05n

* CHECK dout0_6 Vdout0_6ck198 = 1.8 time = 1990
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=1990.05n

* CHECK dout0_7 Vdout0_7ck198 = 0 time = 1990
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=1990.05n

* CHECK dout0_8 Vdout0_8ck198 = 1.8 time = 1990
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=1990.05n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 1990
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=1990.05n

* CHECK dout0_10 Vdout0_10ck198 = 1.8 time = 1990
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=1990.05n

* CHECK dout0_11 Vdout0_11ck198 = 1.8 time = 1990
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=1990.05n

* CHECK dout0_12 Vdout0_12ck198 = 1.8 time = 1990
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=1990.05n

* CHECK dout0_13 Vdout0_13ck198 = 0 time = 1990
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=1990.05n

* CHECK dout0_14 Vdout0_14ck198 = 1.8 time = 1990
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=1990.05n

* CHECK dout0_15 Vdout0_15ck198 = 1.8 time = 1990
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=1990.05n

* CHECK dout0_16 Vdout0_16ck198 = 1.8 time = 1990
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=1990.05n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 1990
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=1990.05n

* CHECK dout0_18 Vdout0_18ck198 = 1.8 time = 1990
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=1990.05n

* CHECK dout0_19 Vdout0_19ck198 = 1.8 time = 1990
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=1990.05n

* CHECK dout0_20 Vdout0_20ck198 = 1.8 time = 1990
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=1990.05n

* CHECK dout0_21 Vdout0_21ck198 = 1.8 time = 1990
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=1990.05n

* CHECK dout0_22 Vdout0_22ck198 = 1.8 time = 1990
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=1990.05n

* CHECK dout0_23 Vdout0_23ck198 = 0 time = 1990
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=1990.05n

* CHECK dout0_24 Vdout0_24ck198 = 0 time = 1990
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=1990.05n

* CHECK dout0_25 Vdout0_25ck198 = 0 time = 1990
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=1990.05n

* CHECK dout0_26 Vdout0_26ck198 = 0 time = 1990
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=1990.05n

* CHECK dout0_27 Vdout0_27ck198 = 1.8 time = 1990
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=1990.05n

* CHECK dout0_28 Vdout0_28ck198 = 0 time = 1990
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=1990.05n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 1990
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=1990.05n

* CHECK dout0_30 Vdout0_30ck198 = 0 time = 1990
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=1990.05n

* CHECK dout0_31 Vdout0_31ck198 = 0 time = 1990
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=1990.05n

* CHECK dout0_32 Vdout0_32ck198 = 1.8 time = 1990
.meas tran vdout0_32ck198 FIND v(dout0_32) AT=1990.05n

* CHECK dout0_33 Vdout0_33ck198 = 0 time = 1990
.meas tran vdout0_33ck198 FIND v(dout0_33) AT=1990.05n

* CHECK dout0_34 Vdout0_34ck198 = 1.8 time = 1990
.meas tran vdout0_34ck198 FIND v(dout0_34) AT=1990.05n

* CHECK dout0_35 Vdout0_35ck198 = 1.8 time = 1990
.meas tran vdout0_35ck198 FIND v(dout0_35) AT=1990.05n

* CHECK dout0_36 Vdout0_36ck198 = 1.8 time = 1990
.meas tran vdout0_36ck198 FIND v(dout0_36) AT=1990.05n

* CHECK dout0_37 Vdout0_37ck198 = 1.8 time = 1990
.meas tran vdout0_37ck198 FIND v(dout0_37) AT=1990.05n

* CHECK dout0_38 Vdout0_38ck198 = 0 time = 1990
.meas tran vdout0_38ck198 FIND v(dout0_38) AT=1990.05n

* CHECK dout0_39 Vdout0_39ck198 = 1.8 time = 1990
.meas tran vdout0_39ck198 FIND v(dout0_39) AT=1990.05n

* CHECK dout0_40 Vdout0_40ck198 = 0 time = 1990
.meas tran vdout0_40ck198 FIND v(dout0_40) AT=1990.05n

* CHECK dout0_41 Vdout0_41ck198 = 0 time = 1990
.meas tran vdout0_41ck198 FIND v(dout0_41) AT=1990.05n

* CHECK dout0_42 Vdout0_42ck198 = 1.8 time = 1990
.meas tran vdout0_42ck198 FIND v(dout0_42) AT=1990.05n

* CHECK dout0_43 Vdout0_43ck198 = 0 time = 1990
.meas tran vdout0_43ck198 FIND v(dout0_43) AT=1990.05n

* CHECK dout0_44 Vdout0_44ck198 = 1.8 time = 1990
.meas tran vdout0_44ck198 FIND v(dout0_44) AT=1990.05n

* CHECK dout0_45 Vdout0_45ck198 = 0 time = 1990
.meas tran vdout0_45ck198 FIND v(dout0_45) AT=1990.05n

* CHECK dout0_46 Vdout0_46ck198 = 1.8 time = 1990
.meas tran vdout0_46ck198 FIND v(dout0_46) AT=1990.05n

* CHECK dout0_47 Vdout0_47ck198 = 1.8 time = 1990
.meas tran vdout0_47ck198 FIND v(dout0_47) AT=1990.05n

* CHECK dout0_48 Vdout0_48ck198 = 1.8 time = 1990
.meas tran vdout0_48ck198 FIND v(dout0_48) AT=1990.05n

* CHECK dout0_49 Vdout0_49ck198 = 1.8 time = 1990
.meas tran vdout0_49ck198 FIND v(dout0_49) AT=1990.05n

* CHECK dout0_50 Vdout0_50ck198 = 1.8 time = 1990
.meas tran vdout0_50ck198 FIND v(dout0_50) AT=1990.05n

* CHECK dout0_51 Vdout0_51ck198 = 0 time = 1990
.meas tran vdout0_51ck198 FIND v(dout0_51) AT=1990.05n

* CHECK dout0_52 Vdout0_52ck198 = 1.8 time = 1990
.meas tran vdout0_52ck198 FIND v(dout0_52) AT=1990.05n

* CHECK dout0_53 Vdout0_53ck198 = 1.8 time = 1990
.meas tran vdout0_53ck198 FIND v(dout0_53) AT=1990.05n

* CHECK dout0_54 Vdout0_54ck198 = 1.8 time = 1990
.meas tran vdout0_54ck198 FIND v(dout0_54) AT=1990.05n

* CHECK dout0_55 Vdout0_55ck198 = 0 time = 1990
.meas tran vdout0_55ck198 FIND v(dout0_55) AT=1990.05n

* CHECK dout0_56 Vdout0_56ck198 = 1.8 time = 1990
.meas tran vdout0_56ck198 FIND v(dout0_56) AT=1990.05n

* CHECK dout0_57 Vdout0_57ck198 = 1.8 time = 1990
.meas tran vdout0_57ck198 FIND v(dout0_57) AT=1990.05n

* CHECK dout0_58 Vdout0_58ck198 = 0 time = 1990
.meas tran vdout0_58ck198 FIND v(dout0_58) AT=1990.05n

* CHECK dout0_59 Vdout0_59ck198 = 1.8 time = 1990
.meas tran vdout0_59ck198 FIND v(dout0_59) AT=1990.05n

* CHECK dout0_60 Vdout0_60ck198 = 0 time = 1990
.meas tran vdout0_60ck198 FIND v(dout0_60) AT=1990.05n

* CHECK dout0_61 Vdout0_61ck198 = 1.8 time = 1990
.meas tran vdout0_61ck198 FIND v(dout0_61) AT=1990.05n

* CHECK dout0_62 Vdout0_62ck198 = 1.8 time = 1990
.meas tran vdout0_62ck198 FIND v(dout0_62) AT=1990.05n

* CHECK dout0_63 Vdout0_63ck198 = 0 time = 1990
.meas tran vdout0_63ck198 FIND v(dout0_63) AT=1990.05n

* CHECK dout0_64 Vdout0_64ck198 = 0 time = 1990
.meas tran vdout0_64ck198 FIND v(dout0_64) AT=1990.05n

* CHECK dout0_0 Vdout0_0ck200 = 0 time = 2010
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=2010.05n

* CHECK dout0_1 Vdout0_1ck200 = 0 time = 2010
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=2010.05n

* CHECK dout0_2 Vdout0_2ck200 = 0 time = 2010
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=2010.05n

* CHECK dout0_3 Vdout0_3ck200 = 1.8 time = 2010
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=2010.05n

* CHECK dout0_4 Vdout0_4ck200 = 1.8 time = 2010
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=2010.05n

* CHECK dout0_5 Vdout0_5ck200 = 0 time = 2010
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=2010.05n

* CHECK dout0_6 Vdout0_6ck200 = 0 time = 2010
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=2010.05n

* CHECK dout0_7 Vdout0_7ck200 = 0 time = 2010
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=2010.05n

* CHECK dout0_8 Vdout0_8ck200 = 0 time = 2010
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=2010.05n

* CHECK dout0_9 Vdout0_9ck200 = 1.8 time = 2010
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=2010.05n

* CHECK dout0_10 Vdout0_10ck200 = 0 time = 2010
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=2010.05n

* CHECK dout0_11 Vdout0_11ck200 = 1.8 time = 2010
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=2010.05n

* CHECK dout0_12 Vdout0_12ck200 = 1.8 time = 2010
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=2010.05n

* CHECK dout0_13 Vdout0_13ck200 = 1.8 time = 2010
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=2010.05n

* CHECK dout0_14 Vdout0_14ck200 = 0 time = 2010
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=2010.05n

* CHECK dout0_15 Vdout0_15ck200 = 0 time = 2010
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=2010.05n

* CHECK dout0_16 Vdout0_16ck200 = 1.8 time = 2010
.meas tran vdout0_16ck200 FIND v(dout0_16) AT=2010.05n

* CHECK dout0_17 Vdout0_17ck200 = 1.8 time = 2010
.meas tran vdout0_17ck200 FIND v(dout0_17) AT=2010.05n

* CHECK dout0_18 Vdout0_18ck200 = 1.8 time = 2010
.meas tran vdout0_18ck200 FIND v(dout0_18) AT=2010.05n

* CHECK dout0_19 Vdout0_19ck200 = 0 time = 2010
.meas tran vdout0_19ck200 FIND v(dout0_19) AT=2010.05n

* CHECK dout0_20 Vdout0_20ck200 = 1.8 time = 2010
.meas tran vdout0_20ck200 FIND v(dout0_20) AT=2010.05n

* CHECK dout0_21 Vdout0_21ck200 = 1.8 time = 2010
.meas tran vdout0_21ck200 FIND v(dout0_21) AT=2010.05n

* CHECK dout0_22 Vdout0_22ck200 = 0 time = 2010
.meas tran vdout0_22ck200 FIND v(dout0_22) AT=2010.05n

* CHECK dout0_23 Vdout0_23ck200 = 1.8 time = 2010
.meas tran vdout0_23ck200 FIND v(dout0_23) AT=2010.05n

* CHECK dout0_24 Vdout0_24ck200 = 1.8 time = 2010
.meas tran vdout0_24ck200 FIND v(dout0_24) AT=2010.05n

* CHECK dout0_25 Vdout0_25ck200 = 0 time = 2010
.meas tran vdout0_25ck200 FIND v(dout0_25) AT=2010.05n

* CHECK dout0_26 Vdout0_26ck200 = 0 time = 2010
.meas tran vdout0_26ck200 FIND v(dout0_26) AT=2010.05n

* CHECK dout0_27 Vdout0_27ck200 = 1.8 time = 2010
.meas tran vdout0_27ck200 FIND v(dout0_27) AT=2010.05n

* CHECK dout0_28 Vdout0_28ck200 = 0 time = 2010
.meas tran vdout0_28ck200 FIND v(dout0_28) AT=2010.05n

* CHECK dout0_29 Vdout0_29ck200 = 0 time = 2010
.meas tran vdout0_29ck200 FIND v(dout0_29) AT=2010.05n

* CHECK dout0_30 Vdout0_30ck200 = 1.8 time = 2010
.meas tran vdout0_30ck200 FIND v(dout0_30) AT=2010.05n

* CHECK dout0_31 Vdout0_31ck200 = 1.8 time = 2010
.meas tran vdout0_31ck200 FIND v(dout0_31) AT=2010.05n

* CHECK dout0_32 Vdout0_32ck200 = 0 time = 2010
.meas tran vdout0_32ck200 FIND v(dout0_32) AT=2010.05n

* CHECK dout0_33 Vdout0_33ck200 = 1.8 time = 2010
.meas tran vdout0_33ck200 FIND v(dout0_33) AT=2010.05n

* CHECK dout0_34 Vdout0_34ck200 = 1.8 time = 2010
.meas tran vdout0_34ck200 FIND v(dout0_34) AT=2010.05n

* CHECK dout0_35 Vdout0_35ck200 = 1.8 time = 2010
.meas tran vdout0_35ck200 FIND v(dout0_35) AT=2010.05n

* CHECK dout0_36 Vdout0_36ck200 = 1.8 time = 2010
.meas tran vdout0_36ck200 FIND v(dout0_36) AT=2010.05n

* CHECK dout0_37 Vdout0_37ck200 = 0 time = 2010
.meas tran vdout0_37ck200 FIND v(dout0_37) AT=2010.05n

* CHECK dout0_38 Vdout0_38ck200 = 1.8 time = 2010
.meas tran vdout0_38ck200 FIND v(dout0_38) AT=2010.05n

* CHECK dout0_39 Vdout0_39ck200 = 1.8 time = 2010
.meas tran vdout0_39ck200 FIND v(dout0_39) AT=2010.05n

* CHECK dout0_40 Vdout0_40ck200 = 1.8 time = 2010
.meas tran vdout0_40ck200 FIND v(dout0_40) AT=2010.05n

* CHECK dout0_41 Vdout0_41ck200 = 0 time = 2010
.meas tran vdout0_41ck200 FIND v(dout0_41) AT=2010.05n

* CHECK dout0_42 Vdout0_42ck200 = 1.8 time = 2010
.meas tran vdout0_42ck200 FIND v(dout0_42) AT=2010.05n

* CHECK dout0_43 Vdout0_43ck200 = 0 time = 2010
.meas tran vdout0_43ck200 FIND v(dout0_43) AT=2010.05n

* CHECK dout0_44 Vdout0_44ck200 = 0 time = 2010
.meas tran vdout0_44ck200 FIND v(dout0_44) AT=2010.05n

* CHECK dout0_45 Vdout0_45ck200 = 0 time = 2010
.meas tran vdout0_45ck200 FIND v(dout0_45) AT=2010.05n

* CHECK dout0_46 Vdout0_46ck200 = 0 time = 2010
.meas tran vdout0_46ck200 FIND v(dout0_46) AT=2010.05n

* CHECK dout0_47 Vdout0_47ck200 = 0 time = 2010
.meas tran vdout0_47ck200 FIND v(dout0_47) AT=2010.05n

* CHECK dout0_48 Vdout0_48ck200 = 0 time = 2010
.meas tran vdout0_48ck200 FIND v(dout0_48) AT=2010.05n

* CHECK dout0_49 Vdout0_49ck200 = 1.8 time = 2010
.meas tran vdout0_49ck200 FIND v(dout0_49) AT=2010.05n

* CHECK dout0_50 Vdout0_50ck200 = 1.8 time = 2010
.meas tran vdout0_50ck200 FIND v(dout0_50) AT=2010.05n

* CHECK dout0_51 Vdout0_51ck200 = 1.8 time = 2010
.meas tran vdout0_51ck200 FIND v(dout0_51) AT=2010.05n

* CHECK dout0_52 Vdout0_52ck200 = 1.8 time = 2010
.meas tran vdout0_52ck200 FIND v(dout0_52) AT=2010.05n

* CHECK dout0_53 Vdout0_53ck200 = 0 time = 2010
.meas tran vdout0_53ck200 FIND v(dout0_53) AT=2010.05n

* CHECK dout0_54 Vdout0_54ck200 = 0 time = 2010
.meas tran vdout0_54ck200 FIND v(dout0_54) AT=2010.05n

* CHECK dout0_55 Vdout0_55ck200 = 1.8 time = 2010
.meas tran vdout0_55ck200 FIND v(dout0_55) AT=2010.05n

* CHECK dout0_56 Vdout0_56ck200 = 0 time = 2010
.meas tran vdout0_56ck200 FIND v(dout0_56) AT=2010.05n

* CHECK dout0_57 Vdout0_57ck200 = 1.8 time = 2010
.meas tran vdout0_57ck200 FIND v(dout0_57) AT=2010.05n

* CHECK dout0_58 Vdout0_58ck200 = 1.8 time = 2010
.meas tran vdout0_58ck200 FIND v(dout0_58) AT=2010.05n

* CHECK dout0_59 Vdout0_59ck200 = 1.8 time = 2010
.meas tran vdout0_59ck200 FIND v(dout0_59) AT=2010.05n

* CHECK dout0_60 Vdout0_60ck200 = 1.8 time = 2010
.meas tran vdout0_60ck200 FIND v(dout0_60) AT=2010.05n

* CHECK dout0_61 Vdout0_61ck200 = 0 time = 2010
.meas tran vdout0_61ck200 FIND v(dout0_61) AT=2010.05n

* CHECK dout0_62 Vdout0_62ck200 = 1.8 time = 2010
.meas tran vdout0_62ck200 FIND v(dout0_62) AT=2010.05n

* CHECK dout0_63 Vdout0_63ck200 = 0 time = 2010
.meas tran vdout0_63ck200 FIND v(dout0_63) AT=2010.05n

* CHECK dout0_64 Vdout0_64ck200 = 0 time = 2010
.meas tran vdout0_64ck200 FIND v(dout0_64) AT=2010.05n

* CHECK dout0_0 Vdout0_0ck201 = 0 time = 2020
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=2020.05n

* CHECK dout0_1 Vdout0_1ck201 = 0 time = 2020
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=2020.05n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 2020
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=2020.05n

* CHECK dout0_3 Vdout0_3ck201 = 1.8 time = 2020
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=2020.05n

* CHECK dout0_4 Vdout0_4ck201 = 0 time = 2020
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=2020.05n

* CHECK dout0_5 Vdout0_5ck201 = 1.8 time = 2020
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=2020.05n

* CHECK dout0_6 Vdout0_6ck201 = 0 time = 2020
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=2020.05n

* CHECK dout0_7 Vdout0_7ck201 = 1.8 time = 2020
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=2020.05n

* CHECK dout0_8 Vdout0_8ck201 = 1.8 time = 2020
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=2020.05n

* CHECK dout0_9 Vdout0_9ck201 = 1.8 time = 2020
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=2020.05n

* CHECK dout0_10 Vdout0_10ck201 = 0 time = 2020
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=2020.05n

* CHECK dout0_11 Vdout0_11ck201 = 1.8 time = 2020
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=2020.05n

* CHECK dout0_12 Vdout0_12ck201 = 0 time = 2020
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=2020.05n

* CHECK dout0_13 Vdout0_13ck201 = 1.8 time = 2020
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=2020.05n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 2020
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=2020.05n

* CHECK dout0_15 Vdout0_15ck201 = 1.8 time = 2020
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=2020.05n

* CHECK dout0_16 Vdout0_16ck201 = 1.8 time = 2020
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=2020.05n

* CHECK dout0_17 Vdout0_17ck201 = 1.8 time = 2020
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=2020.05n

* CHECK dout0_18 Vdout0_18ck201 = 0 time = 2020
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=2020.05n

* CHECK dout0_19 Vdout0_19ck201 = 1.8 time = 2020
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=2020.05n

* CHECK dout0_20 Vdout0_20ck201 = 0 time = 2020
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=2020.05n

* CHECK dout0_21 Vdout0_21ck201 = 0 time = 2020
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=2020.05n

* CHECK dout0_22 Vdout0_22ck201 = 0 time = 2020
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=2020.05n

* CHECK dout0_23 Vdout0_23ck201 = 1.8 time = 2020
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=2020.05n

* CHECK dout0_24 Vdout0_24ck201 = 1.8 time = 2020
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=2020.05n

* CHECK dout0_25 Vdout0_25ck201 = 0 time = 2020
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=2020.05n

* CHECK dout0_26 Vdout0_26ck201 = 0 time = 2020
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=2020.05n

* CHECK dout0_27 Vdout0_27ck201 = 0 time = 2020
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=2020.05n

* CHECK dout0_28 Vdout0_28ck201 = 0 time = 2020
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=2020.05n

* CHECK dout0_29 Vdout0_29ck201 = 1.8 time = 2020
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=2020.05n

* CHECK dout0_30 Vdout0_30ck201 = 0 time = 2020
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=2020.05n

* CHECK dout0_31 Vdout0_31ck201 = 0 time = 2020
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=2020.05n

* CHECK dout0_32 Vdout0_32ck201 = 0 time = 2020
.meas tran vdout0_32ck201 FIND v(dout0_32) AT=2020.05n

* CHECK dout0_33 Vdout0_33ck201 = 1.8 time = 2020
.meas tran vdout0_33ck201 FIND v(dout0_33) AT=2020.05n

* CHECK dout0_34 Vdout0_34ck201 = 1.8 time = 2020
.meas tran vdout0_34ck201 FIND v(dout0_34) AT=2020.05n

* CHECK dout0_35 Vdout0_35ck201 = 1.8 time = 2020
.meas tran vdout0_35ck201 FIND v(dout0_35) AT=2020.05n

* CHECK dout0_36 Vdout0_36ck201 = 1.8 time = 2020
.meas tran vdout0_36ck201 FIND v(dout0_36) AT=2020.05n

* CHECK dout0_37 Vdout0_37ck201 = 0 time = 2020
.meas tran vdout0_37ck201 FIND v(dout0_37) AT=2020.05n

* CHECK dout0_38 Vdout0_38ck201 = 1.8 time = 2020
.meas tran vdout0_38ck201 FIND v(dout0_38) AT=2020.05n

* CHECK dout0_39 Vdout0_39ck201 = 1.8 time = 2020
.meas tran vdout0_39ck201 FIND v(dout0_39) AT=2020.05n

* CHECK dout0_40 Vdout0_40ck201 = 0 time = 2020
.meas tran vdout0_40ck201 FIND v(dout0_40) AT=2020.05n

* CHECK dout0_41 Vdout0_41ck201 = 0 time = 2020
.meas tran vdout0_41ck201 FIND v(dout0_41) AT=2020.05n

* CHECK dout0_42 Vdout0_42ck201 = 0 time = 2020
.meas tran vdout0_42ck201 FIND v(dout0_42) AT=2020.05n

* CHECK dout0_43 Vdout0_43ck201 = 1.8 time = 2020
.meas tran vdout0_43ck201 FIND v(dout0_43) AT=2020.05n

* CHECK dout0_44 Vdout0_44ck201 = 0 time = 2020
.meas tran vdout0_44ck201 FIND v(dout0_44) AT=2020.05n

* CHECK dout0_45 Vdout0_45ck201 = 1.8 time = 2020
.meas tran vdout0_45ck201 FIND v(dout0_45) AT=2020.05n

* CHECK dout0_46 Vdout0_46ck201 = 1.8 time = 2020
.meas tran vdout0_46ck201 FIND v(dout0_46) AT=2020.05n

* CHECK dout0_47 Vdout0_47ck201 = 0 time = 2020
.meas tran vdout0_47ck201 FIND v(dout0_47) AT=2020.05n

* CHECK dout0_48 Vdout0_48ck201 = 0 time = 2020
.meas tran vdout0_48ck201 FIND v(dout0_48) AT=2020.05n

* CHECK dout0_49 Vdout0_49ck201 = 0 time = 2020
.meas tran vdout0_49ck201 FIND v(dout0_49) AT=2020.05n

* CHECK dout0_50 Vdout0_50ck201 = 0 time = 2020
.meas tran vdout0_50ck201 FIND v(dout0_50) AT=2020.05n

* CHECK dout0_51 Vdout0_51ck201 = 0 time = 2020
.meas tran vdout0_51ck201 FIND v(dout0_51) AT=2020.05n

* CHECK dout0_52 Vdout0_52ck201 = 0 time = 2020
.meas tran vdout0_52ck201 FIND v(dout0_52) AT=2020.05n

* CHECK dout0_53 Vdout0_53ck201 = 1.8 time = 2020
.meas tran vdout0_53ck201 FIND v(dout0_53) AT=2020.05n

* CHECK dout0_54 Vdout0_54ck201 = 0 time = 2020
.meas tran vdout0_54ck201 FIND v(dout0_54) AT=2020.05n

* CHECK dout0_55 Vdout0_55ck201 = 0 time = 2020
.meas tran vdout0_55ck201 FIND v(dout0_55) AT=2020.05n

* CHECK dout0_56 Vdout0_56ck201 = 0 time = 2020
.meas tran vdout0_56ck201 FIND v(dout0_56) AT=2020.05n

* CHECK dout0_57 Vdout0_57ck201 = 1.8 time = 2020
.meas tran vdout0_57ck201 FIND v(dout0_57) AT=2020.05n

* CHECK dout0_58 Vdout0_58ck201 = 1.8 time = 2020
.meas tran vdout0_58ck201 FIND v(dout0_58) AT=2020.05n

* CHECK dout0_59 Vdout0_59ck201 = 0 time = 2020
.meas tran vdout0_59ck201 FIND v(dout0_59) AT=2020.05n

* CHECK dout0_60 Vdout0_60ck201 = 1.8 time = 2020
.meas tran vdout0_60ck201 FIND v(dout0_60) AT=2020.05n

* CHECK dout0_61 Vdout0_61ck201 = 0 time = 2020
.meas tran vdout0_61ck201 FIND v(dout0_61) AT=2020.05n

* CHECK dout0_62 Vdout0_62ck201 = 0 time = 2020
.meas tran vdout0_62ck201 FIND v(dout0_62) AT=2020.05n

* CHECK dout0_63 Vdout0_63ck201 = 0 time = 2020
.meas tran vdout0_63ck201 FIND v(dout0_63) AT=2020.05n

* CHECK dout0_64 Vdout0_64ck201 = 0 time = 2020
.meas tran vdout0_64ck201 FIND v(dout0_64) AT=2020.05n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
