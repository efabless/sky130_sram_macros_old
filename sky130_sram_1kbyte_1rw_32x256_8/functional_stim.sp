* Functional test stimulus file for 10ns period

* TT process corner
.lib "/home/software/PDKs/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "sky130_sram_1kbyte_1rw_32x256_8.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsky130_sram_1kbyte_1rw_32x256_8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 vdd gnd sky130_sram_1kbyte_1rw_32x256_8

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f

* Important signals for debug
* bl:	xsky130_sram_1kbyte_1rw_32x256_8.xbank0.bl_0_0
* br:	xsky130_sram_1kbyte_1rw_32x256_8.xbank0.br_0_0
* s_en:	xsky130_sram_1kbyte_1rw_32x256_8.s_en
* q:	xsky130_sram_1kbyte_1rw_32x256_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q
* qbar:	xsky130_sram_1kbyte_1rw_32x256_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+00110111011001011111010001001011  to  address 100000001 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+01101011110010100001101011001000  to  address 000000011 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+11000000001100111100100011010110  to  address 100000000 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+01101011110010100001101011001000 from address 000000011 (from port 0) during cycle 4 (40ns - 50ns)
*	Writing (partial) 0+11100001110011001010011111000011  to  address 100000001 with mask bit 0001 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 0+11000000001100111100100011010110 from address 100000000 (from port 0) during cycle 7 (70ns - 80ns)
*	Writing (partial) 0+01001110100101010110000101000101  to  address 100000000 with mask bit 0011 (from port 0) during cycle 8 (80ns - 90ns)
*	Writing (partial) 0+10000011001000101001101011111011  to  address 100000001 with mask bit 1000 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 0+10000011011001011111010011000011 from address 100000001 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 0+11000000001100110110000101000101 from address 100000000 (from port 0) during cycle 11 (110ns - 120ns)
*	Reading 0+01101011110010100001101011001000 from address 000000011 (from port 0) during cycle 12 (120ns - 130ns)
*	Reading 0+01101011110010100001101011001000 from address 000000011 (from port 0) during cycle 13 (130ns - 140ns)
*	Writing (partial) 0+00001110110110000100101000000100  to  address 000000011 with mask bit 1110 (from port 0) during cycle 15 (150ns - 160ns)
*	Writing (partial) 0+10101100010110000011110111010010  to  address 100000001 with mask bit 1001 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 0+11000000001100110110000101000101 from address 100000000 (from port 0) during cycle 18 (180ns - 190ns)
*	Writing 0+00001111111010101000001100111001  to  address 011111111 (from port 0) during cycle 19 (190ns - 200ns)
*	Writing 0+11000101110001110000111001100110  to  address 000000001 (from port 0) during cycle 20 (200ns - 210ns)
*	Reading 0+00001110110110000100101011001000 from address 000000011 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 0+10101100011001011111010011010010 from address 100000001 (from port 0) during cycle 22 (220ns - 230ns)
*	Writing (partial) 0+11101011100101110010100011100001  to  address 000000011 with mask bit 0010 (from port 0) during cycle 23 (230ns - 240ns)
*	Writing (partial) 0+10011000111111011101010111000111  to  address 100000001 with mask bit 1110 (from port 0) during cycle 24 (240ns - 250ns)
*	Writing 0+01000110001010001000001100011101  to  address 000000000 (from port 0) during cycle 25 (250ns - 260ns)
*	Writing 0+10111101100011011101100011001011  to  address 000000001 (from port 0) during cycle 27 (270ns - 280ns)
*	Writing (partial) 0+11001001011001010110101101100011  to  address 000000011 with mask bit 1100 (from port 0) during cycle 28 (280ns - 290ns)
*	Reading 0+10111101100011011101100011001011 from address 000000001 (from port 0) during cycle 29 (290ns - 300ns)
*	Reading 0+10111101100011011101100011001011 from address 000000001 (from port 0) during cycle 30 (300ns - 310ns)
*	Writing 0+10110111111001101010110000110000  to  address 000000000 (from port 0) during cycle 31 (310ns - 320ns)
*	Reading 0+00001111111010101000001100111001 from address 011111111 (from port 0) during cycle 33 (330ns - 340ns)
*	Writing (partial) 0+01110110001111101001110101101110  to  address 000000001 with mask bit 1000 (from port 0) during cycle 34 (340ns - 350ns)
*	Writing (partial) 0+00001010001011001011110110011111  to  address 100000000 with mask bit 0011 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 0+11000000001100111011110110011111 from address 100000000 (from port 0) during cycle 36 (360ns - 370ns)
*	Writing (partial) 0+01110010010001000101011110100101  to  address 000000000 with mask bit 1011 (from port 0) during cycle 37 (370ns - 380ns)
*	Reading 0+01110010111001100101011110100101 from address 000000000 (from port 0) during cycle 38 (380ns - 390ns)
*	Writing 0+11001011101100000000111111110010  to  address 100000000 (from port 0) during cycle 39 (390ns - 400ns)
*	Reading 0+01110110100011011101100011001011 from address 000000001 (from port 0) during cycle 41 (410ns - 420ns)
*	Writing 0+00101110100100100000110101001101  to  address 100000000 (from port 0) during cycle 42 (420ns - 430ns)
*	Writing (partial) 0+10000001000000001111110101011101  to  address 000000001 with mask bit 1100 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 0+10011000111111011101010111010010 from address 100000001 (from port 0) during cycle 47 (470ns - 480ns)
*	Reading 0+10000001000000001101100011001011 from address 000000001 (from port 0) during cycle 48 (480ns - 490ns)
*	Writing (partial) 0+10111011011010101010010101111111  to  address 100000000 with mask bit 0100 (from port 0) during cycle 49 (490ns - 500ns)
*	Reading 0+00101110011010100000110101001101 from address 100000000 (from port 0) during cycle 50 (500ns - 510ns)
*	Writing 0+00101110010110011101100100000100  to  address 100000001 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 0+00101110011010100000110101001101 from address 100000000 (from port 0) during cycle 52 (520ns - 530ns)
*	Reading 0+10000001000000001101100011001011 from address 000000001 (from port 0) during cycle 53 (530ns - 540ns)
*	Writing 0+11010111101000111000010011001010  to  address 000000010 (from port 0) during cycle 55 (550ns - 560ns)
*	Writing 0+11010010001100100011001011101111  to  address 000000010 (from port 0) during cycle 56 (560ns - 570ns)
*	Writing (partial) 0+00110101101011010000101000001111  to  address 000000010 with mask bit 1010 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 0+00110101001100100000101011101111 from address 000000010 (from port 0) during cycle 58 (580ns - 590ns)
*	Writing (partial) 0+11101001001111000001011100110001  to  address 100000001 with mask bit 0111 (from port 0) during cycle 59 (590ns - 600ns)
*	Writing 0+10000101100110010101001110111111  to  address 011111111 (from port 0) during cycle 61 (610ns - 620ns)
*	Writing (partial) 0+01111101110110111111001101010001  to  address 100000000 with mask bit 1000 (from port 0) during cycle 62 (620ns - 630ns)
*	Writing 0+01000111111100011011011011110001  to  address 100000001 (from port 0) during cycle 63 (630ns - 640ns)
*	Writing 0+11001111000001111010010111110111  to  address 000000011 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 0+11001111000001111010010111110111 from address 000000011 (from port 0) during cycle 66 (660ns - 670ns)
*	Writing (partial) 0+10001110110111011011010111000111  to  address 000000001 with mask bit 0011 (from port 0) during cycle 67 (670ns - 680ns)
*	Writing 0+10001110000011011000000100111000  to  address 011111111 (from port 0) during cycle 70 (700ns - 710ns)
*	Writing (partial) 0+01011100011111101101010100001100  to  address 000000011 with mask bit 1110 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 0+10001110000011011000000100111000 from address 011111111 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 0+01110010111001100101011110100101 from address 000000000 (from port 0) during cycle 73 (730ns - 740ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 74 (740ns - 750ns)
*	Writing 0+11110001111000000111010001111011  to  address 000000000 (from port 0) during cycle 75 (750ns - 760ns)
*	Writing 0+10111000100000010010110111000000  to  address 100000010 (from port 0) during cycle 76 (760ns - 770ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 77 (770ns - 780ns)
*	Reading 0+01000111111100011011011011110001 from address 100000001 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing 0+01000011111011011111001010001010  to  address 000000001 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 0+01111101011010100000110101001101 from address 100000000 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 82 (820ns - 830ns)
*	Writing (partial) 0+10111001000001111111111010110111  to  address 000000001 with mask bit 1101 (from port 0) during cycle 83 (830ns - 840ns)
*	Writing 0+01010100111001110010011101101101  to  address 100000001 (from port 0) during cycle 84 (840ns - 850ns)
*	Writing (partial) 0+00000100110010010011010011001110  to  address 000000001 with mask bit 0011 (from port 0) during cycle 85 (850ns - 860ns)
*	Reading 0+10111000100000010010110111000000 from address 100000010 (from port 0) during cycle 86 (860ns - 870ns)
*	Reading 0+01111101011010100000110101001101 from address 100000000 (from port 0) during cycle 88 (880ns - 890ns)
*	Writing 0+11000011110010111001010011100011  to  address 100000000 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 0+10001110000011011000000100111000 from address 011111111 (from port 0) during cycle 91 (910ns - 920ns)
*	Writing 0+11000101000100000000100110110001  to  address 100000000 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 0+11110001111000000111010001111011 from address 000000000 (from port 0) during cycle 94 (940ns - 950ns)
*	Reading 0+00110101001100100000101011101111 from address 000000010 (from port 0) during cycle 96 (960ns - 970ns)
*	Writing 0+00100010100001101111110111101101  to  address 011111111 (from port 0) during cycle 97 (970ns - 980ns)
*	Reading 0+11000101000100000000100110110001 from address 100000000 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+10111001000001110011010011001110 from address 000000001 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 0+11000101000100000000100110110001 from address 100000000 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Writing 0+01110101101011101110010010010110  to  address 000000001 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Writing (partial) 0+10010011010101000010110101010110  to  address 100000010 with mask bit 1000 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 0+11110001111000000111010001111011 from address 000000000 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Writing (partial) 0+11001100111101000111100110100100  to  address 000000010 with mask bit 1110 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Writing 0+01000000100100010010101011100111  to  address 011111111 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Writing 0+11010010111001010110010010011111  to  address 000000001 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 0+01000000100100010010101011100111 from address 011111111 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Writing 0+10000110100100110000001011111110  to  address 000000001 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Reading 0+11001100111101000111100111101111 from address 000000010 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 0+10000110100100110000001011111110 from address 000000001 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Writing 0+01001011011011011100010001110100  to  address 000000010 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 0+01011100011111101101010111110111 from address 000000011 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Writing 0+01010101010110101011100100101111  to  address 100000000 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 0+01010101010110101011100100101111 from address 100000000 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Writing (partial) 0+10101111101000000101010111101100  to  address 000000010 with mask bit 1010 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 0+11110001111000000111010001111011 from address 000000000 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Writing 0+10010011011101010110001100101001  to  address 000000000 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing (partial) 0+00010001100000010100011100001100  to  address 000000000 with mask bit 0010 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Reading 0+01010101010110101011100100101111 from address 100000000 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Writing (partial) 0+01011010111000001110010100111011  to  address 011111111 with mask bit 1101 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Writing (partial) 0+01001110111010101101010101110001  to  address 100000001 with mask bit 1011 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Reading 0+10010011011101010100011100101001 from address 000000000 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Reading 0+01001110111001111101010101110001 from address 100000001 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Reading 0+01010101010110101011100100101111 from address 100000000 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Writing 0+01101111101011100000010010101011  to  address 100000000 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Writing 0+11001000101111111010110010010001  to  address 000000000 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Reading 0+10101111011011010101010101110100 from address 000000010 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Writing 0+11011011111101010101011001001000  to  address 000000011 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Reading 0+10000110100100110000001011111110 from address 000000001 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Writing (partial) 0+01010101000011110111010111110110  to  address 100000001 with mask bit 1100 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Writing 0+00111100010110001010111101110001  to  address 100000010 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Writing (partial) 0+00000000111010010110011110000001  to  address 000000000 with mask bit 0001 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Writing 0+10101000110111100011011011011111  to  address 000000001 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Writing 0+11001001001010111011111010101101  to  address 000000001 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 0+00111100010110001010111101110001 from address 100000010 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Writing 0+10001110011000001101000010110110  to  address 000000010 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Writing (partial) 0+10100101101101010000011110010100  to  address 100000010 with mask bit 0010 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Writing 0+10001100110101010111111110011101  to  address 011111111 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Reading 0+10001110011000001101000010110110 from address 000000010 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Writing 0+11100100110000110110100111010100  to  address 100000001 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Writing 0+01110100110111111111001010011010  to  address 100000010 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 0+01101111101011100000010010101011 from address 100000000 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Writing 0+01110011001101011100000011000101  to  address 000000001 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Reading 0+11001000101111111010110010000001 from address 000000000 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Reading 0+10001100110101010111111110011101 from address 011111111 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 0+10001110011000001101000010110110 from address 000000010 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Reading 0+11011011111101010101011001001000 from address 000000011 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Writing 0+10110011111101011011100011111101  to  address 100000000 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Reading 0+10001100110101010111111110011101 from address 011111111 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 0+01110011001101011100000011000101 from address 000000001 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Writing 0+11000100001000010101111101111100  to  address 000000001 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 0+10110011111101011011100011111101 from address 100000000 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Reading 0+11100100110000110110100111010100 from address 100000001 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Writing (partial) 0+00100001110100111010110001010010  to  address 100000000 with mask bit 0011 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Writing 0+01101010101001011001101101101110  to  address 100000001 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Reading 0+01110100110111111111001010011010 from address 100000010 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Writing 0+10101001111111011100110010111010  to  address 100000010 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Writing (partial) 0+10010000011110011100000111101110  to  address 100000000 with mask bit 1100 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 0+10101001111111011100110010111010 from address 100000010 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Reading 0+11011011111101010101011001001000 from address 000000011 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Writing (partial) 0+01101011111010100110011000100001  to  address 000000001 with mask bit 1010 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Writing (partial) 0+00010011001010110100110111110100  to  address 100000010 with mask bit 1011 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Writing 0+10111101000010101110000101101101  to  address 000000010 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing (partial) 0+11100011011111001011011000000001  to  address 011111111 with mask bit 1010 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 0+11100011110101011011011010011101 from address 011111111 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Writing 0+01010101000001001100110101001010  to  address 000000010 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 0+10010000011110011010110001010010 from address 100000000 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 0+11100011110101011011011010011101 from address 011111111 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 0+01101011001000010110011001111100 from address 000000001 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Reading 0+11011011111101010101011001001000 from address 000000011 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Writing 0+00100100100011000000010001010001  to  address 000000001 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Reading 0+11100011110101011011011010011101 from address 011111111 (from port 0) during cycle 196 (1960ns - 1970ns)
*	Writing 0+11110110111101110010011110110100  to  address 000000010 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Writing (partial) 0+00101001110101100000000101001000  to  address 100000000 with mask bit 1001 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing (partial) 0+10110011011011000000011011010101  to  address 100000000 with mask bit 1101 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 0+10110011011011001010110011010101 from address 100000000 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Reading 0+10110011011011001010110011010101 from address 100000000 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Writing (partial) 0+11110110110010000100110101000001  to  address 011111111 with mask bit 0001 (from port 0) during cycle 203 (2030ns - 2040ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 0), (240, 1), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 0), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 1), (520, 0), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 0), (1760, 1), (1770, 0), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 1), (220, 0), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 0), (740, 1), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 1), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_7  a0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 1), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 0), (780, 1), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 1), (180, 1), (190, 0), (200, 0), (210, 1), (220, 1), (230, 0), (240, 0), (250, 0), (260, 1), (270, 0), (280, 0), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 0), (350, 0), (360, 1), (370, 0), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 1), (510, 0), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 0), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 0), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 0), (1500, 0), (1510, 1), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of wmask signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 1.8 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 50
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=50.05n

* CHECK dout0_9 Vdout0_9ck4 = 1.8 time = 50
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=50.05n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 50
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=50.05n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 50
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=50.05n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 50
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=50.05n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 50
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=50.05n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 50
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=50.05n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 50
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=50.05n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 50
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=50.05n

* CHECK dout0_17 Vdout0_17ck4 = 1.8 time = 50
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=50.05n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 50
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=50.05n

* CHECK dout0_19 Vdout0_19ck4 = 1.8 time = 50
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=50.05n

* CHECK dout0_20 Vdout0_20ck4 = 0 time = 50
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=50.05n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 50
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=50.05n

* CHECK dout0_22 Vdout0_22ck4 = 1.8 time = 50
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=50.05n

* CHECK dout0_23 Vdout0_23ck4 = 1.8 time = 50
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=50.05n

* CHECK dout0_24 Vdout0_24ck4 = 1.8 time = 50
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=50.05n

* CHECK dout0_25 Vdout0_25ck4 = 1.8 time = 50
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=50.05n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 50
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=50.05n

* CHECK dout0_27 Vdout0_27ck4 = 1.8 time = 50
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=50.05n

* CHECK dout0_28 Vdout0_28ck4 = 0 time = 50
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=50.05n

* CHECK dout0_29 Vdout0_29ck4 = 1.8 time = 50
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=50.05n

* CHECK dout0_30 Vdout0_30ck4 = 1.8 time = 50
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=50.05n

* CHECK dout0_31 Vdout0_31ck4 = 0 time = 50
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=50.05n

* CHECK dout0_32 Vdout0_32ck4 = 0 time = 50
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=50.05n

* CHECK dout0_0 Vdout0_0ck7 = 0 time = 80
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=80.05n

* CHECK dout0_1 Vdout0_1ck7 = 1.8 time = 80
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=80.05n

* CHECK dout0_2 Vdout0_2ck7 = 1.8 time = 80
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=80.05n

* CHECK dout0_3 Vdout0_3ck7 = 0 time = 80
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=80.05n

* CHECK dout0_4 Vdout0_4ck7 = 1.8 time = 80
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=80.05n

* CHECK dout0_5 Vdout0_5ck7 = 0 time = 80
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=80.05n

* CHECK dout0_6 Vdout0_6ck7 = 1.8 time = 80
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=80.05n

* CHECK dout0_7 Vdout0_7ck7 = 1.8 time = 80
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=80.05n

* CHECK dout0_8 Vdout0_8ck7 = 0 time = 80
.meas tran vdout0_8ck7 FIND v(dout0_8) AT=80.05n

* CHECK dout0_9 Vdout0_9ck7 = 0 time = 80
.meas tran vdout0_9ck7 FIND v(dout0_9) AT=80.05n

* CHECK dout0_10 Vdout0_10ck7 = 0 time = 80
.meas tran vdout0_10ck7 FIND v(dout0_10) AT=80.05n

* CHECK dout0_11 Vdout0_11ck7 = 1.8 time = 80
.meas tran vdout0_11ck7 FIND v(dout0_11) AT=80.05n

* CHECK dout0_12 Vdout0_12ck7 = 0 time = 80
.meas tran vdout0_12ck7 FIND v(dout0_12) AT=80.05n

* CHECK dout0_13 Vdout0_13ck7 = 0 time = 80
.meas tran vdout0_13ck7 FIND v(dout0_13) AT=80.05n

* CHECK dout0_14 Vdout0_14ck7 = 1.8 time = 80
.meas tran vdout0_14ck7 FIND v(dout0_14) AT=80.05n

* CHECK dout0_15 Vdout0_15ck7 = 1.8 time = 80
.meas tran vdout0_15ck7 FIND v(dout0_15) AT=80.05n

* CHECK dout0_16 Vdout0_16ck7 = 1.8 time = 80
.meas tran vdout0_16ck7 FIND v(dout0_16) AT=80.05n

* CHECK dout0_17 Vdout0_17ck7 = 1.8 time = 80
.meas tran vdout0_17ck7 FIND v(dout0_17) AT=80.05n

* CHECK dout0_18 Vdout0_18ck7 = 0 time = 80
.meas tran vdout0_18ck7 FIND v(dout0_18) AT=80.05n

* CHECK dout0_19 Vdout0_19ck7 = 0 time = 80
.meas tran vdout0_19ck7 FIND v(dout0_19) AT=80.05n

* CHECK dout0_20 Vdout0_20ck7 = 1.8 time = 80
.meas tran vdout0_20ck7 FIND v(dout0_20) AT=80.05n

* CHECK dout0_21 Vdout0_21ck7 = 1.8 time = 80
.meas tran vdout0_21ck7 FIND v(dout0_21) AT=80.05n

* CHECK dout0_22 Vdout0_22ck7 = 0 time = 80
.meas tran vdout0_22ck7 FIND v(dout0_22) AT=80.05n

* CHECK dout0_23 Vdout0_23ck7 = 0 time = 80
.meas tran vdout0_23ck7 FIND v(dout0_23) AT=80.05n

* CHECK dout0_24 Vdout0_24ck7 = 0 time = 80
.meas tran vdout0_24ck7 FIND v(dout0_24) AT=80.05n

* CHECK dout0_25 Vdout0_25ck7 = 0 time = 80
.meas tran vdout0_25ck7 FIND v(dout0_25) AT=80.05n

* CHECK dout0_26 Vdout0_26ck7 = 0 time = 80
.meas tran vdout0_26ck7 FIND v(dout0_26) AT=80.05n

* CHECK dout0_27 Vdout0_27ck7 = 0 time = 80
.meas tran vdout0_27ck7 FIND v(dout0_27) AT=80.05n

* CHECK dout0_28 Vdout0_28ck7 = 0 time = 80
.meas tran vdout0_28ck7 FIND v(dout0_28) AT=80.05n

* CHECK dout0_29 Vdout0_29ck7 = 0 time = 80
.meas tran vdout0_29ck7 FIND v(dout0_29) AT=80.05n

* CHECK dout0_30 Vdout0_30ck7 = 1.8 time = 80
.meas tran vdout0_30ck7 FIND v(dout0_30) AT=80.05n

* CHECK dout0_31 Vdout0_31ck7 = 1.8 time = 80
.meas tran vdout0_31ck7 FIND v(dout0_31) AT=80.05n

* CHECK dout0_32 Vdout0_32ck7 = 0 time = 80
.meas tran vdout0_32ck7 FIND v(dout0_32) AT=80.05n

* CHECK dout0_0 Vdout0_0ck10 = 1.8 time = 110
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=110.05n

* CHECK dout0_1 Vdout0_1ck10 = 1.8 time = 110
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=110.05n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 110
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=110.05n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 110
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=110.05n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 110
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=110.05n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 110
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=110.05n

* CHECK dout0_6 Vdout0_6ck10 = 1.8 time = 110
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=110.05n

* CHECK dout0_7 Vdout0_7ck10 = 1.8 time = 110
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=110.05n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 110
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=110.05n

* CHECK dout0_9 Vdout0_9ck10 = 0 time = 110
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=110.05n

* CHECK dout0_10 Vdout0_10ck10 = 1.8 time = 110
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=110.05n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 110
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=110.05n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 110
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=110.05n

* CHECK dout0_13 Vdout0_13ck10 = 1.8 time = 110
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=110.05n

* CHECK dout0_14 Vdout0_14ck10 = 1.8 time = 110
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=110.05n

* CHECK dout0_15 Vdout0_15ck10 = 1.8 time = 110
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=110.05n

* CHECK dout0_16 Vdout0_16ck10 = 1.8 time = 110
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=110.05n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 110
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=110.05n

* CHECK dout0_18 Vdout0_18ck10 = 1.8 time = 110
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=110.05n

* CHECK dout0_19 Vdout0_19ck10 = 0 time = 110
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=110.05n

* CHECK dout0_20 Vdout0_20ck10 = 0 time = 110
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=110.05n

* CHECK dout0_21 Vdout0_21ck10 = 1.8 time = 110
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=110.05n

* CHECK dout0_22 Vdout0_22ck10 = 1.8 time = 110
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=110.05n

* CHECK dout0_23 Vdout0_23ck10 = 0 time = 110
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=110.05n

* CHECK dout0_24 Vdout0_24ck10 = 1.8 time = 110
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=110.05n

* CHECK dout0_25 Vdout0_25ck10 = 1.8 time = 110
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=110.05n

* CHECK dout0_26 Vdout0_26ck10 = 0 time = 110
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=110.05n

* CHECK dout0_27 Vdout0_27ck10 = 0 time = 110
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=110.05n

* CHECK dout0_28 Vdout0_28ck10 = 0 time = 110
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=110.05n

* CHECK dout0_29 Vdout0_29ck10 = 0 time = 110
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=110.05n

* CHECK dout0_30 Vdout0_30ck10 = 0 time = 110
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=110.05n

* CHECK dout0_31 Vdout0_31ck10 = 1.8 time = 110
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=110.05n

* CHECK dout0_32 Vdout0_32ck10 = 0 time = 110
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=110.05n

* CHECK dout0_0 Vdout0_0ck11 = 1.8 time = 120
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=120.05n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 120
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=120.05n

* CHECK dout0_2 Vdout0_2ck11 = 1.8 time = 120
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=120.05n

* CHECK dout0_3 Vdout0_3ck11 = 0 time = 120
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=120.05n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 120
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=120.05n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 120
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=120.05n

* CHECK dout0_6 Vdout0_6ck11 = 1.8 time = 120
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=120.05n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 120
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=120.05n

* CHECK dout0_8 Vdout0_8ck11 = 1.8 time = 120
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=120.05n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 120
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=120.05n

* CHECK dout0_10 Vdout0_10ck11 = 0 time = 120
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=120.05n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 120
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=120.05n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 120
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=120.05n

* CHECK dout0_13 Vdout0_13ck11 = 1.8 time = 120
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=120.05n

* CHECK dout0_14 Vdout0_14ck11 = 1.8 time = 120
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=120.05n

* CHECK dout0_15 Vdout0_15ck11 = 0 time = 120
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=120.05n

* CHECK dout0_16 Vdout0_16ck11 = 1.8 time = 120
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=120.05n

* CHECK dout0_17 Vdout0_17ck11 = 1.8 time = 120
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=120.05n

* CHECK dout0_18 Vdout0_18ck11 = 0 time = 120
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=120.05n

* CHECK dout0_19 Vdout0_19ck11 = 0 time = 120
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=120.05n

* CHECK dout0_20 Vdout0_20ck11 = 1.8 time = 120
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=120.05n

* CHECK dout0_21 Vdout0_21ck11 = 1.8 time = 120
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=120.05n

* CHECK dout0_22 Vdout0_22ck11 = 0 time = 120
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=120.05n

* CHECK dout0_23 Vdout0_23ck11 = 0 time = 120
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=120.05n

* CHECK dout0_24 Vdout0_24ck11 = 0 time = 120
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=120.05n

* CHECK dout0_25 Vdout0_25ck11 = 0 time = 120
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=120.05n

* CHECK dout0_26 Vdout0_26ck11 = 0 time = 120
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=120.05n

* CHECK dout0_27 Vdout0_27ck11 = 0 time = 120
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=120.05n

* CHECK dout0_28 Vdout0_28ck11 = 0 time = 120
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=120.05n

* CHECK dout0_29 Vdout0_29ck11 = 0 time = 120
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=120.05n

* CHECK dout0_30 Vdout0_30ck11 = 1.8 time = 120
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=120.05n

* CHECK dout0_31 Vdout0_31ck11 = 1.8 time = 120
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=120.05n

* CHECK dout0_32 Vdout0_32ck11 = 0 time = 120
.meas tran vdout0_32ck11 FIND v(dout0_32) AT=120.05n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 130
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=130.05n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 130
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=130.05n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 130
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=130.05n

* CHECK dout0_3 Vdout0_3ck12 = 1.8 time = 130
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=130.05n

* CHECK dout0_4 Vdout0_4ck12 = 0 time = 130
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=130.05n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 130
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=130.05n

* CHECK dout0_6 Vdout0_6ck12 = 1.8 time = 130
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=130.05n

* CHECK dout0_7 Vdout0_7ck12 = 1.8 time = 130
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=130.05n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 130
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=130.05n

* CHECK dout0_9 Vdout0_9ck12 = 1.8 time = 130
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=130.05n

* CHECK dout0_10 Vdout0_10ck12 = 0 time = 130
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=130.05n

* CHECK dout0_11 Vdout0_11ck12 = 1.8 time = 130
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=130.05n

* CHECK dout0_12 Vdout0_12ck12 = 1.8 time = 130
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=130.05n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 130
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=130.05n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 130
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=130.05n

* CHECK dout0_15 Vdout0_15ck12 = 0 time = 130
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=130.05n

* CHECK dout0_16 Vdout0_16ck12 = 0 time = 130
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=130.05n

* CHECK dout0_17 Vdout0_17ck12 = 1.8 time = 130
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=130.05n

* CHECK dout0_18 Vdout0_18ck12 = 0 time = 130
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=130.05n

* CHECK dout0_19 Vdout0_19ck12 = 1.8 time = 130
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=130.05n

* CHECK dout0_20 Vdout0_20ck12 = 0 time = 130
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=130.05n

* CHECK dout0_21 Vdout0_21ck12 = 0 time = 130
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=130.05n

* CHECK dout0_22 Vdout0_22ck12 = 1.8 time = 130
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=130.05n

* CHECK dout0_23 Vdout0_23ck12 = 1.8 time = 130
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=130.05n

* CHECK dout0_24 Vdout0_24ck12 = 1.8 time = 130
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=130.05n

* CHECK dout0_25 Vdout0_25ck12 = 1.8 time = 130
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=130.05n

* CHECK dout0_26 Vdout0_26ck12 = 0 time = 130
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=130.05n

* CHECK dout0_27 Vdout0_27ck12 = 1.8 time = 130
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=130.05n

* CHECK dout0_28 Vdout0_28ck12 = 0 time = 130
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=130.05n

* CHECK dout0_29 Vdout0_29ck12 = 1.8 time = 130
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=130.05n

* CHECK dout0_30 Vdout0_30ck12 = 1.8 time = 130
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=130.05n

* CHECK dout0_31 Vdout0_31ck12 = 0 time = 130
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=130.05n

* CHECK dout0_32 Vdout0_32ck12 = 0 time = 130
.meas tran vdout0_32ck12 FIND v(dout0_32) AT=130.05n

* CHECK dout0_0 Vdout0_0ck13 = 0 time = 140
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=140.05n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 140
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=140.05n

* CHECK dout0_2 Vdout0_2ck13 = 0 time = 140
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=140.05n

* CHECK dout0_3 Vdout0_3ck13 = 1.8 time = 140
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=140.05n

* CHECK dout0_4 Vdout0_4ck13 = 0 time = 140
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=140.05n

* CHECK dout0_5 Vdout0_5ck13 = 0 time = 140
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=140.05n

* CHECK dout0_6 Vdout0_6ck13 = 1.8 time = 140
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=140.05n

* CHECK dout0_7 Vdout0_7ck13 = 1.8 time = 140
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=140.05n

* CHECK dout0_8 Vdout0_8ck13 = 0 time = 140
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=140.05n

* CHECK dout0_9 Vdout0_9ck13 = 1.8 time = 140
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=140.05n

* CHECK dout0_10 Vdout0_10ck13 = 0 time = 140
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=140.05n

* CHECK dout0_11 Vdout0_11ck13 = 1.8 time = 140
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=140.05n

* CHECK dout0_12 Vdout0_12ck13 = 1.8 time = 140
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=140.05n

* CHECK dout0_13 Vdout0_13ck13 = 0 time = 140
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=140.05n

* CHECK dout0_14 Vdout0_14ck13 = 0 time = 140
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=140.05n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 140
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=140.05n

* CHECK dout0_16 Vdout0_16ck13 = 0 time = 140
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=140.05n

* CHECK dout0_17 Vdout0_17ck13 = 1.8 time = 140
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=140.05n

* CHECK dout0_18 Vdout0_18ck13 = 0 time = 140
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=140.05n

* CHECK dout0_19 Vdout0_19ck13 = 1.8 time = 140
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=140.05n

* CHECK dout0_20 Vdout0_20ck13 = 0 time = 140
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=140.05n

* CHECK dout0_21 Vdout0_21ck13 = 0 time = 140
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=140.05n

* CHECK dout0_22 Vdout0_22ck13 = 1.8 time = 140
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=140.05n

* CHECK dout0_23 Vdout0_23ck13 = 1.8 time = 140
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=140.05n

* CHECK dout0_24 Vdout0_24ck13 = 1.8 time = 140
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=140.05n

* CHECK dout0_25 Vdout0_25ck13 = 1.8 time = 140
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=140.05n

* CHECK dout0_26 Vdout0_26ck13 = 0 time = 140
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=140.05n

* CHECK dout0_27 Vdout0_27ck13 = 1.8 time = 140
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=140.05n

* CHECK dout0_28 Vdout0_28ck13 = 0 time = 140
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=140.05n

* CHECK dout0_29 Vdout0_29ck13 = 1.8 time = 140
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=140.05n

* CHECK dout0_30 Vdout0_30ck13 = 1.8 time = 140
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=140.05n

* CHECK dout0_31 Vdout0_31ck13 = 0 time = 140
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=140.05n

* CHECK dout0_32 Vdout0_32ck13 = 0 time = 140
.meas tran vdout0_32ck13 FIND v(dout0_32) AT=140.05n

* CHECK dout0_0 Vdout0_0ck18 = 1.8 time = 190
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=190.05n

* CHECK dout0_1 Vdout0_1ck18 = 0 time = 190
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=190.05n

* CHECK dout0_2 Vdout0_2ck18 = 1.8 time = 190
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=190.05n

* CHECK dout0_3 Vdout0_3ck18 = 0 time = 190
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=190.05n

* CHECK dout0_4 Vdout0_4ck18 = 0 time = 190
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=190.05n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 190
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=190.05n

* CHECK dout0_6 Vdout0_6ck18 = 1.8 time = 190
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=190.05n

* CHECK dout0_7 Vdout0_7ck18 = 0 time = 190
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=190.05n

* CHECK dout0_8 Vdout0_8ck18 = 1.8 time = 190
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=190.05n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 190
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=190.05n

* CHECK dout0_10 Vdout0_10ck18 = 0 time = 190
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=190.05n

* CHECK dout0_11 Vdout0_11ck18 = 0 time = 190
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=190.05n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 190
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=190.05n

* CHECK dout0_13 Vdout0_13ck18 = 1.8 time = 190
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=190.05n

* CHECK dout0_14 Vdout0_14ck18 = 1.8 time = 190
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=190.05n

* CHECK dout0_15 Vdout0_15ck18 = 0 time = 190
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=190.05n

* CHECK dout0_16 Vdout0_16ck18 = 1.8 time = 190
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=190.05n

* CHECK dout0_17 Vdout0_17ck18 = 1.8 time = 190
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=190.05n

* CHECK dout0_18 Vdout0_18ck18 = 0 time = 190
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=190.05n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 190
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=190.05n

* CHECK dout0_20 Vdout0_20ck18 = 1.8 time = 190
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=190.05n

* CHECK dout0_21 Vdout0_21ck18 = 1.8 time = 190
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=190.05n

* CHECK dout0_22 Vdout0_22ck18 = 0 time = 190
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=190.05n

* CHECK dout0_23 Vdout0_23ck18 = 0 time = 190
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=190.05n

* CHECK dout0_24 Vdout0_24ck18 = 0 time = 190
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=190.05n

* CHECK dout0_25 Vdout0_25ck18 = 0 time = 190
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=190.05n

* CHECK dout0_26 Vdout0_26ck18 = 0 time = 190
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=190.05n

* CHECK dout0_27 Vdout0_27ck18 = 0 time = 190
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=190.05n

* CHECK dout0_28 Vdout0_28ck18 = 0 time = 190
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=190.05n

* CHECK dout0_29 Vdout0_29ck18 = 0 time = 190
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=190.05n

* CHECK dout0_30 Vdout0_30ck18 = 1.8 time = 190
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=190.05n

* CHECK dout0_31 Vdout0_31ck18 = 1.8 time = 190
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=190.05n

* CHECK dout0_32 Vdout0_32ck18 = 0 time = 190
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=190.05n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 220
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=220.05n

* CHECK dout0_1 Vdout0_1ck21 = 0 time = 220
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=220.05n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 220
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=220.05n

* CHECK dout0_3 Vdout0_3ck21 = 1.8 time = 220
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=220.05n

* CHECK dout0_4 Vdout0_4ck21 = 0 time = 220
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=220.05n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 220
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=220.05n

* CHECK dout0_6 Vdout0_6ck21 = 1.8 time = 220
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=220.05n

* CHECK dout0_7 Vdout0_7ck21 = 1.8 time = 220
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=220.05n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 220
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=220.05n

* CHECK dout0_9 Vdout0_9ck21 = 1.8 time = 220
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=220.05n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 220
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=220.05n

* CHECK dout0_11 Vdout0_11ck21 = 1.8 time = 220
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=220.05n

* CHECK dout0_12 Vdout0_12ck21 = 0 time = 220
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=220.05n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 220
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=220.05n

* CHECK dout0_14 Vdout0_14ck21 = 1.8 time = 220
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=220.05n

* CHECK dout0_15 Vdout0_15ck21 = 0 time = 220
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=220.05n

* CHECK dout0_16 Vdout0_16ck21 = 0 time = 220
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=220.05n

* CHECK dout0_17 Vdout0_17ck21 = 0 time = 220
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=220.05n

* CHECK dout0_18 Vdout0_18ck21 = 0 time = 220
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=220.05n

* CHECK dout0_19 Vdout0_19ck21 = 1.8 time = 220
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=220.05n

* CHECK dout0_20 Vdout0_20ck21 = 1.8 time = 220
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=220.05n

* CHECK dout0_21 Vdout0_21ck21 = 0 time = 220
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=220.05n

* CHECK dout0_22 Vdout0_22ck21 = 1.8 time = 220
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=220.05n

* CHECK dout0_23 Vdout0_23ck21 = 1.8 time = 220
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=220.05n

* CHECK dout0_24 Vdout0_24ck21 = 0 time = 220
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=220.05n

* CHECK dout0_25 Vdout0_25ck21 = 1.8 time = 220
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=220.05n

* CHECK dout0_26 Vdout0_26ck21 = 1.8 time = 220
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=220.05n

* CHECK dout0_27 Vdout0_27ck21 = 1.8 time = 220
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=220.05n

* CHECK dout0_28 Vdout0_28ck21 = 0 time = 220
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=220.05n

* CHECK dout0_29 Vdout0_29ck21 = 0 time = 220
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=220.05n

* CHECK dout0_30 Vdout0_30ck21 = 0 time = 220
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=220.05n

* CHECK dout0_31 Vdout0_31ck21 = 0 time = 220
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=220.05n

* CHECK dout0_32 Vdout0_32ck21 = 0 time = 220
.meas tran vdout0_32ck21 FIND v(dout0_32) AT=220.05n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 230
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=230.05n

* CHECK dout0_1 Vdout0_1ck22 = 1.8 time = 230
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=230.05n

* CHECK dout0_2 Vdout0_2ck22 = 0 time = 230
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=230.05n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 230
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=230.05n

* CHECK dout0_4 Vdout0_4ck22 = 1.8 time = 230
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=230.05n

* CHECK dout0_5 Vdout0_5ck22 = 0 time = 230
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=230.05n

* CHECK dout0_6 Vdout0_6ck22 = 1.8 time = 230
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=230.05n

* CHECK dout0_7 Vdout0_7ck22 = 1.8 time = 230
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=230.05n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 230
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=230.05n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 230
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=230.05n

* CHECK dout0_10 Vdout0_10ck22 = 1.8 time = 230
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=230.05n

* CHECK dout0_11 Vdout0_11ck22 = 0 time = 230
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=230.05n

* CHECK dout0_12 Vdout0_12ck22 = 1.8 time = 230
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=230.05n

* CHECK dout0_13 Vdout0_13ck22 = 1.8 time = 230
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=230.05n

* CHECK dout0_14 Vdout0_14ck22 = 1.8 time = 230
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=230.05n

* CHECK dout0_15 Vdout0_15ck22 = 1.8 time = 230
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=230.05n

* CHECK dout0_16 Vdout0_16ck22 = 1.8 time = 230
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=230.05n

* CHECK dout0_17 Vdout0_17ck22 = 0 time = 230
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=230.05n

* CHECK dout0_18 Vdout0_18ck22 = 1.8 time = 230
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=230.05n

* CHECK dout0_19 Vdout0_19ck22 = 0 time = 230
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=230.05n

* CHECK dout0_20 Vdout0_20ck22 = 0 time = 230
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=230.05n

* CHECK dout0_21 Vdout0_21ck22 = 1.8 time = 230
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=230.05n

* CHECK dout0_22 Vdout0_22ck22 = 1.8 time = 230
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=230.05n

* CHECK dout0_23 Vdout0_23ck22 = 0 time = 230
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=230.05n

* CHECK dout0_24 Vdout0_24ck22 = 0 time = 230
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=230.05n

* CHECK dout0_25 Vdout0_25ck22 = 0 time = 230
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=230.05n

* CHECK dout0_26 Vdout0_26ck22 = 1.8 time = 230
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=230.05n

* CHECK dout0_27 Vdout0_27ck22 = 1.8 time = 230
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=230.05n

* CHECK dout0_28 Vdout0_28ck22 = 0 time = 230
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=230.05n

* CHECK dout0_29 Vdout0_29ck22 = 1.8 time = 230
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=230.05n

* CHECK dout0_30 Vdout0_30ck22 = 0 time = 230
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=230.05n

* CHECK dout0_31 Vdout0_31ck22 = 1.8 time = 230
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=230.05n

* CHECK dout0_32 Vdout0_32ck22 = 0 time = 230
.meas tran vdout0_32ck22 FIND v(dout0_32) AT=230.05n

* CHECK dout0_0 Vdout0_0ck29 = 1.8 time = 300
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=300.05n

* CHECK dout0_1 Vdout0_1ck29 = 1.8 time = 300
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=300.05n

* CHECK dout0_2 Vdout0_2ck29 = 0 time = 300
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=300.05n

* CHECK dout0_3 Vdout0_3ck29 = 1.8 time = 300
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=300.05n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 300
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=300.05n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 300
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=300.05n

* CHECK dout0_6 Vdout0_6ck29 = 1.8 time = 300
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=300.05n

* CHECK dout0_7 Vdout0_7ck29 = 1.8 time = 300
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=300.05n

* CHECK dout0_8 Vdout0_8ck29 = 0 time = 300
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=300.05n

* CHECK dout0_9 Vdout0_9ck29 = 0 time = 300
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=300.05n

* CHECK dout0_10 Vdout0_10ck29 = 0 time = 300
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=300.05n

* CHECK dout0_11 Vdout0_11ck29 = 1.8 time = 300
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=300.05n

* CHECK dout0_12 Vdout0_12ck29 = 1.8 time = 300
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=300.05n

* CHECK dout0_13 Vdout0_13ck29 = 0 time = 300
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=300.05n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 300
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=300.05n

* CHECK dout0_15 Vdout0_15ck29 = 1.8 time = 300
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=300.05n

* CHECK dout0_16 Vdout0_16ck29 = 1.8 time = 300
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=300.05n

* CHECK dout0_17 Vdout0_17ck29 = 0 time = 300
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=300.05n

* CHECK dout0_18 Vdout0_18ck29 = 1.8 time = 300
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=300.05n

* CHECK dout0_19 Vdout0_19ck29 = 1.8 time = 300
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=300.05n

* CHECK dout0_20 Vdout0_20ck29 = 0 time = 300
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=300.05n

* CHECK dout0_21 Vdout0_21ck29 = 0 time = 300
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=300.05n

* CHECK dout0_22 Vdout0_22ck29 = 0 time = 300
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=300.05n

* CHECK dout0_23 Vdout0_23ck29 = 1.8 time = 300
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=300.05n

* CHECK dout0_24 Vdout0_24ck29 = 1.8 time = 300
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=300.05n

* CHECK dout0_25 Vdout0_25ck29 = 0 time = 300
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=300.05n

* CHECK dout0_26 Vdout0_26ck29 = 1.8 time = 300
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=300.05n

* CHECK dout0_27 Vdout0_27ck29 = 1.8 time = 300
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=300.05n

* CHECK dout0_28 Vdout0_28ck29 = 1.8 time = 300
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=300.05n

* CHECK dout0_29 Vdout0_29ck29 = 1.8 time = 300
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=300.05n

* CHECK dout0_30 Vdout0_30ck29 = 0 time = 300
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=300.05n

* CHECK dout0_31 Vdout0_31ck29 = 1.8 time = 300
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=300.05n

* CHECK dout0_32 Vdout0_32ck29 = 0 time = 300
.meas tran vdout0_32ck29 FIND v(dout0_32) AT=300.05n

* CHECK dout0_0 Vdout0_0ck30 = 1.8 time = 310
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=310.05n

* CHECK dout0_1 Vdout0_1ck30 = 1.8 time = 310
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=310.05n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 310
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=310.05n

* CHECK dout0_3 Vdout0_3ck30 = 1.8 time = 310
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=310.05n

* CHECK dout0_4 Vdout0_4ck30 = 0 time = 310
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=310.05n

* CHECK dout0_5 Vdout0_5ck30 = 0 time = 310
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=310.05n

* CHECK dout0_6 Vdout0_6ck30 = 1.8 time = 310
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=310.05n

* CHECK dout0_7 Vdout0_7ck30 = 1.8 time = 310
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=310.05n

* CHECK dout0_8 Vdout0_8ck30 = 0 time = 310
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=310.05n

* CHECK dout0_9 Vdout0_9ck30 = 0 time = 310
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=310.05n

* CHECK dout0_10 Vdout0_10ck30 = 0 time = 310
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=310.05n

* CHECK dout0_11 Vdout0_11ck30 = 1.8 time = 310
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=310.05n

* CHECK dout0_12 Vdout0_12ck30 = 1.8 time = 310
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=310.05n

* CHECK dout0_13 Vdout0_13ck30 = 0 time = 310
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=310.05n

* CHECK dout0_14 Vdout0_14ck30 = 1.8 time = 310
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=310.05n

* CHECK dout0_15 Vdout0_15ck30 = 1.8 time = 310
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=310.05n

* CHECK dout0_16 Vdout0_16ck30 = 1.8 time = 310
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=310.05n

* CHECK dout0_17 Vdout0_17ck30 = 0 time = 310
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=310.05n

* CHECK dout0_18 Vdout0_18ck30 = 1.8 time = 310
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=310.05n

* CHECK dout0_19 Vdout0_19ck30 = 1.8 time = 310
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=310.05n

* CHECK dout0_20 Vdout0_20ck30 = 0 time = 310
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=310.05n

* CHECK dout0_21 Vdout0_21ck30 = 0 time = 310
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=310.05n

* CHECK dout0_22 Vdout0_22ck30 = 0 time = 310
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=310.05n

* CHECK dout0_23 Vdout0_23ck30 = 1.8 time = 310
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=310.05n

* CHECK dout0_24 Vdout0_24ck30 = 1.8 time = 310
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=310.05n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 310
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=310.05n

* CHECK dout0_26 Vdout0_26ck30 = 1.8 time = 310
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=310.05n

* CHECK dout0_27 Vdout0_27ck30 = 1.8 time = 310
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=310.05n

* CHECK dout0_28 Vdout0_28ck30 = 1.8 time = 310
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=310.05n

* CHECK dout0_29 Vdout0_29ck30 = 1.8 time = 310
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=310.05n

* CHECK dout0_30 Vdout0_30ck30 = 0 time = 310
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=310.05n

* CHECK dout0_31 Vdout0_31ck30 = 1.8 time = 310
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=310.05n

* CHECK dout0_32 Vdout0_32ck30 = 0 time = 310
.meas tran vdout0_32ck30 FIND v(dout0_32) AT=310.05n

* CHECK dout0_0 Vdout0_0ck33 = 1.8 time = 340
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=340.05n

* CHECK dout0_1 Vdout0_1ck33 = 0 time = 340
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=340.05n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 340
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=340.05n

* CHECK dout0_3 Vdout0_3ck33 = 1.8 time = 340
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=340.05n

* CHECK dout0_4 Vdout0_4ck33 = 1.8 time = 340
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=340.05n

* CHECK dout0_5 Vdout0_5ck33 = 1.8 time = 340
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=340.05n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 340
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=340.05n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 340
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=340.05n

* CHECK dout0_8 Vdout0_8ck33 = 1.8 time = 340
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=340.05n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 340
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=340.05n

* CHECK dout0_10 Vdout0_10ck33 = 0 time = 340
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=340.05n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 340
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=340.05n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 340
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=340.05n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 340
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=340.05n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 340
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=340.05n

* CHECK dout0_15 Vdout0_15ck33 = 1.8 time = 340
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=340.05n

* CHECK dout0_16 Vdout0_16ck33 = 0 time = 340
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=340.05n

* CHECK dout0_17 Vdout0_17ck33 = 1.8 time = 340
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=340.05n

* CHECK dout0_18 Vdout0_18ck33 = 0 time = 340
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=340.05n

* CHECK dout0_19 Vdout0_19ck33 = 1.8 time = 340
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=340.05n

* CHECK dout0_20 Vdout0_20ck33 = 0 time = 340
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=340.05n

* CHECK dout0_21 Vdout0_21ck33 = 1.8 time = 340
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=340.05n

* CHECK dout0_22 Vdout0_22ck33 = 1.8 time = 340
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=340.05n

* CHECK dout0_23 Vdout0_23ck33 = 1.8 time = 340
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=340.05n

* CHECK dout0_24 Vdout0_24ck33 = 1.8 time = 340
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=340.05n

* CHECK dout0_25 Vdout0_25ck33 = 1.8 time = 340
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=340.05n

* CHECK dout0_26 Vdout0_26ck33 = 1.8 time = 340
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=340.05n

* CHECK dout0_27 Vdout0_27ck33 = 1.8 time = 340
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=340.05n

* CHECK dout0_28 Vdout0_28ck33 = 0 time = 340
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=340.05n

* CHECK dout0_29 Vdout0_29ck33 = 0 time = 340
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=340.05n

* CHECK dout0_30 Vdout0_30ck33 = 0 time = 340
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=340.05n

* CHECK dout0_31 Vdout0_31ck33 = 0 time = 340
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=340.05n

* CHECK dout0_32 Vdout0_32ck33 = 0 time = 340
.meas tran vdout0_32ck33 FIND v(dout0_32) AT=340.05n

* CHECK dout0_0 Vdout0_0ck36 = 1.8 time = 370
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=370.05n

* CHECK dout0_1 Vdout0_1ck36 = 1.8 time = 370
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=370.05n

* CHECK dout0_2 Vdout0_2ck36 = 1.8 time = 370
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=370.05n

* CHECK dout0_3 Vdout0_3ck36 = 1.8 time = 370
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=370.05n

* CHECK dout0_4 Vdout0_4ck36 = 1.8 time = 370
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=370.05n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 370
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=370.05n

* CHECK dout0_6 Vdout0_6ck36 = 0 time = 370
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=370.05n

* CHECK dout0_7 Vdout0_7ck36 = 1.8 time = 370
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=370.05n

* CHECK dout0_8 Vdout0_8ck36 = 1.8 time = 370
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=370.05n

* CHECK dout0_9 Vdout0_9ck36 = 0 time = 370
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=370.05n

* CHECK dout0_10 Vdout0_10ck36 = 1.8 time = 370
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=370.05n

* CHECK dout0_11 Vdout0_11ck36 = 1.8 time = 370
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=370.05n

* CHECK dout0_12 Vdout0_12ck36 = 1.8 time = 370
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=370.05n

* CHECK dout0_13 Vdout0_13ck36 = 1.8 time = 370
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=370.05n

* CHECK dout0_14 Vdout0_14ck36 = 0 time = 370
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=370.05n

* CHECK dout0_15 Vdout0_15ck36 = 1.8 time = 370
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=370.05n

* CHECK dout0_16 Vdout0_16ck36 = 1.8 time = 370
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=370.05n

* CHECK dout0_17 Vdout0_17ck36 = 1.8 time = 370
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=370.05n

* CHECK dout0_18 Vdout0_18ck36 = 0 time = 370
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=370.05n

* CHECK dout0_19 Vdout0_19ck36 = 0 time = 370
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=370.05n

* CHECK dout0_20 Vdout0_20ck36 = 1.8 time = 370
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=370.05n

* CHECK dout0_21 Vdout0_21ck36 = 1.8 time = 370
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=370.05n

* CHECK dout0_22 Vdout0_22ck36 = 0 time = 370
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=370.05n

* CHECK dout0_23 Vdout0_23ck36 = 0 time = 370
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=370.05n

* CHECK dout0_24 Vdout0_24ck36 = 0 time = 370
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=370.05n

* CHECK dout0_25 Vdout0_25ck36 = 0 time = 370
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=370.05n

* CHECK dout0_26 Vdout0_26ck36 = 0 time = 370
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=370.05n

* CHECK dout0_27 Vdout0_27ck36 = 0 time = 370
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=370.05n

* CHECK dout0_28 Vdout0_28ck36 = 0 time = 370
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=370.05n

* CHECK dout0_29 Vdout0_29ck36 = 0 time = 370
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=370.05n

* CHECK dout0_30 Vdout0_30ck36 = 1.8 time = 370
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=370.05n

* CHECK dout0_31 Vdout0_31ck36 = 1.8 time = 370
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=370.05n

* CHECK dout0_32 Vdout0_32ck36 = 0 time = 370
.meas tran vdout0_32ck36 FIND v(dout0_32) AT=370.05n

* CHECK dout0_0 Vdout0_0ck38 = 1.8 time = 390
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=390.05n

* CHECK dout0_1 Vdout0_1ck38 = 0 time = 390
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=390.05n

* CHECK dout0_2 Vdout0_2ck38 = 1.8 time = 390
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=390.05n

* CHECK dout0_3 Vdout0_3ck38 = 0 time = 390
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=390.05n

* CHECK dout0_4 Vdout0_4ck38 = 0 time = 390
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=390.05n

* CHECK dout0_5 Vdout0_5ck38 = 1.8 time = 390
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=390.05n

* CHECK dout0_6 Vdout0_6ck38 = 0 time = 390
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=390.05n

* CHECK dout0_7 Vdout0_7ck38 = 1.8 time = 390
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=390.05n

* CHECK dout0_8 Vdout0_8ck38 = 1.8 time = 390
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=390.05n

* CHECK dout0_9 Vdout0_9ck38 = 1.8 time = 390
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=390.05n

* CHECK dout0_10 Vdout0_10ck38 = 1.8 time = 390
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=390.05n

* CHECK dout0_11 Vdout0_11ck38 = 0 time = 390
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=390.05n

* CHECK dout0_12 Vdout0_12ck38 = 1.8 time = 390
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=390.05n

* CHECK dout0_13 Vdout0_13ck38 = 0 time = 390
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=390.05n

* CHECK dout0_14 Vdout0_14ck38 = 1.8 time = 390
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=390.05n

* CHECK dout0_15 Vdout0_15ck38 = 0 time = 390
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=390.05n

* CHECK dout0_16 Vdout0_16ck38 = 0 time = 390
.meas tran vdout0_16ck38 FIND v(dout0_16) AT=390.05n

* CHECK dout0_17 Vdout0_17ck38 = 1.8 time = 390
.meas tran vdout0_17ck38 FIND v(dout0_17) AT=390.05n

* CHECK dout0_18 Vdout0_18ck38 = 1.8 time = 390
.meas tran vdout0_18ck38 FIND v(dout0_18) AT=390.05n

* CHECK dout0_19 Vdout0_19ck38 = 0 time = 390
.meas tran vdout0_19ck38 FIND v(dout0_19) AT=390.05n

* CHECK dout0_20 Vdout0_20ck38 = 0 time = 390
.meas tran vdout0_20ck38 FIND v(dout0_20) AT=390.05n

* CHECK dout0_21 Vdout0_21ck38 = 1.8 time = 390
.meas tran vdout0_21ck38 FIND v(dout0_21) AT=390.05n

* CHECK dout0_22 Vdout0_22ck38 = 1.8 time = 390
.meas tran vdout0_22ck38 FIND v(dout0_22) AT=390.05n

* CHECK dout0_23 Vdout0_23ck38 = 1.8 time = 390
.meas tran vdout0_23ck38 FIND v(dout0_23) AT=390.05n

* CHECK dout0_24 Vdout0_24ck38 = 0 time = 390
.meas tran vdout0_24ck38 FIND v(dout0_24) AT=390.05n

* CHECK dout0_25 Vdout0_25ck38 = 1.8 time = 390
.meas tran vdout0_25ck38 FIND v(dout0_25) AT=390.05n

* CHECK dout0_26 Vdout0_26ck38 = 0 time = 390
.meas tran vdout0_26ck38 FIND v(dout0_26) AT=390.05n

* CHECK dout0_27 Vdout0_27ck38 = 0 time = 390
.meas tran vdout0_27ck38 FIND v(dout0_27) AT=390.05n

* CHECK dout0_28 Vdout0_28ck38 = 1.8 time = 390
.meas tran vdout0_28ck38 FIND v(dout0_28) AT=390.05n

* CHECK dout0_29 Vdout0_29ck38 = 1.8 time = 390
.meas tran vdout0_29ck38 FIND v(dout0_29) AT=390.05n

* CHECK dout0_30 Vdout0_30ck38 = 1.8 time = 390
.meas tran vdout0_30ck38 FIND v(dout0_30) AT=390.05n

* CHECK dout0_31 Vdout0_31ck38 = 0 time = 390
.meas tran vdout0_31ck38 FIND v(dout0_31) AT=390.05n

* CHECK dout0_32 Vdout0_32ck38 = 0 time = 390
.meas tran vdout0_32ck38 FIND v(dout0_32) AT=390.05n

* CHECK dout0_0 Vdout0_0ck41 = 1.8 time = 420
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=420.05n

* CHECK dout0_1 Vdout0_1ck41 = 1.8 time = 420
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=420.05n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 420
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=420.05n

* CHECK dout0_3 Vdout0_3ck41 = 1.8 time = 420
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=420.05n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 420
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=420.05n

* CHECK dout0_5 Vdout0_5ck41 = 0 time = 420
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=420.05n

* CHECK dout0_6 Vdout0_6ck41 = 1.8 time = 420
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=420.05n

* CHECK dout0_7 Vdout0_7ck41 = 1.8 time = 420
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=420.05n

* CHECK dout0_8 Vdout0_8ck41 = 0 time = 420
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=420.05n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 420
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=420.05n

* CHECK dout0_10 Vdout0_10ck41 = 0 time = 420
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=420.05n

* CHECK dout0_11 Vdout0_11ck41 = 1.8 time = 420
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=420.05n

* CHECK dout0_12 Vdout0_12ck41 = 1.8 time = 420
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=420.05n

* CHECK dout0_13 Vdout0_13ck41 = 0 time = 420
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=420.05n

* CHECK dout0_14 Vdout0_14ck41 = 1.8 time = 420
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=420.05n

* CHECK dout0_15 Vdout0_15ck41 = 1.8 time = 420
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=420.05n

* CHECK dout0_16 Vdout0_16ck41 = 1.8 time = 420
.meas tran vdout0_16ck41 FIND v(dout0_16) AT=420.05n

* CHECK dout0_17 Vdout0_17ck41 = 0 time = 420
.meas tran vdout0_17ck41 FIND v(dout0_17) AT=420.05n

* CHECK dout0_18 Vdout0_18ck41 = 1.8 time = 420
.meas tran vdout0_18ck41 FIND v(dout0_18) AT=420.05n

* CHECK dout0_19 Vdout0_19ck41 = 1.8 time = 420
.meas tran vdout0_19ck41 FIND v(dout0_19) AT=420.05n

* CHECK dout0_20 Vdout0_20ck41 = 0 time = 420
.meas tran vdout0_20ck41 FIND v(dout0_20) AT=420.05n

* CHECK dout0_21 Vdout0_21ck41 = 0 time = 420
.meas tran vdout0_21ck41 FIND v(dout0_21) AT=420.05n

* CHECK dout0_22 Vdout0_22ck41 = 0 time = 420
.meas tran vdout0_22ck41 FIND v(dout0_22) AT=420.05n

* CHECK dout0_23 Vdout0_23ck41 = 1.8 time = 420
.meas tran vdout0_23ck41 FIND v(dout0_23) AT=420.05n

* CHECK dout0_24 Vdout0_24ck41 = 0 time = 420
.meas tran vdout0_24ck41 FIND v(dout0_24) AT=420.05n

* CHECK dout0_25 Vdout0_25ck41 = 1.8 time = 420
.meas tran vdout0_25ck41 FIND v(dout0_25) AT=420.05n

* CHECK dout0_26 Vdout0_26ck41 = 1.8 time = 420
.meas tran vdout0_26ck41 FIND v(dout0_26) AT=420.05n

* CHECK dout0_27 Vdout0_27ck41 = 0 time = 420
.meas tran vdout0_27ck41 FIND v(dout0_27) AT=420.05n

* CHECK dout0_28 Vdout0_28ck41 = 1.8 time = 420
.meas tran vdout0_28ck41 FIND v(dout0_28) AT=420.05n

* CHECK dout0_29 Vdout0_29ck41 = 1.8 time = 420
.meas tran vdout0_29ck41 FIND v(dout0_29) AT=420.05n

* CHECK dout0_30 Vdout0_30ck41 = 1.8 time = 420
.meas tran vdout0_30ck41 FIND v(dout0_30) AT=420.05n

* CHECK dout0_31 Vdout0_31ck41 = 0 time = 420
.meas tran vdout0_31ck41 FIND v(dout0_31) AT=420.05n

* CHECK dout0_32 Vdout0_32ck41 = 0 time = 420
.meas tran vdout0_32ck41 FIND v(dout0_32) AT=420.05n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 1.8 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 0 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 0 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 1.8 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 1.8 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_8 Vdout0_8ck47 = 1.8 time = 480
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=480.05n

* CHECK dout0_9 Vdout0_9ck47 = 0 time = 480
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=480.05n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 480
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=480.05n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 480
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=480.05n

* CHECK dout0_12 Vdout0_12ck47 = 1.8 time = 480
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=480.05n

* CHECK dout0_13 Vdout0_13ck47 = 0 time = 480
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=480.05n

* CHECK dout0_14 Vdout0_14ck47 = 1.8 time = 480
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=480.05n

* CHECK dout0_15 Vdout0_15ck47 = 1.8 time = 480
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=480.05n

* CHECK dout0_16 Vdout0_16ck47 = 1.8 time = 480
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=480.05n

* CHECK dout0_17 Vdout0_17ck47 = 0 time = 480
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=480.05n

* CHECK dout0_18 Vdout0_18ck47 = 1.8 time = 480
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=480.05n

* CHECK dout0_19 Vdout0_19ck47 = 1.8 time = 480
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=480.05n

* CHECK dout0_20 Vdout0_20ck47 = 1.8 time = 480
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=480.05n

* CHECK dout0_21 Vdout0_21ck47 = 1.8 time = 480
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=480.05n

* CHECK dout0_22 Vdout0_22ck47 = 1.8 time = 480
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=480.05n

* CHECK dout0_23 Vdout0_23ck47 = 1.8 time = 480
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=480.05n

* CHECK dout0_24 Vdout0_24ck47 = 0 time = 480
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=480.05n

* CHECK dout0_25 Vdout0_25ck47 = 0 time = 480
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=480.05n

* CHECK dout0_26 Vdout0_26ck47 = 0 time = 480
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=480.05n

* CHECK dout0_27 Vdout0_27ck47 = 1.8 time = 480
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=480.05n

* CHECK dout0_28 Vdout0_28ck47 = 1.8 time = 480
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=480.05n

* CHECK dout0_29 Vdout0_29ck47 = 0 time = 480
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=480.05n

* CHECK dout0_30 Vdout0_30ck47 = 0 time = 480
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=480.05n

* CHECK dout0_31 Vdout0_31ck47 = 1.8 time = 480
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=480.05n

* CHECK dout0_32 Vdout0_32ck47 = 0 time = 480
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=480.05n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 490
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=490.05n

* CHECK dout0_1 Vdout0_1ck48 = 1.8 time = 490
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=490.05n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 490
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=490.05n

* CHECK dout0_3 Vdout0_3ck48 = 1.8 time = 490
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=490.05n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 490
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=490.05n

* CHECK dout0_5 Vdout0_5ck48 = 0 time = 490
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=490.05n

* CHECK dout0_6 Vdout0_6ck48 = 1.8 time = 490
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=490.05n

* CHECK dout0_7 Vdout0_7ck48 = 1.8 time = 490
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=490.05n

* CHECK dout0_8 Vdout0_8ck48 = 0 time = 490
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=490.05n

* CHECK dout0_9 Vdout0_9ck48 = 0 time = 490
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=490.05n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 490
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=490.05n

* CHECK dout0_11 Vdout0_11ck48 = 1.8 time = 490
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=490.05n

* CHECK dout0_12 Vdout0_12ck48 = 1.8 time = 490
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=490.05n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 490
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=490.05n

* CHECK dout0_14 Vdout0_14ck48 = 1.8 time = 490
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=490.05n

* CHECK dout0_15 Vdout0_15ck48 = 1.8 time = 490
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=490.05n

* CHECK dout0_16 Vdout0_16ck48 = 0 time = 490
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=490.05n

* CHECK dout0_17 Vdout0_17ck48 = 0 time = 490
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=490.05n

* CHECK dout0_18 Vdout0_18ck48 = 0 time = 490
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=490.05n

* CHECK dout0_19 Vdout0_19ck48 = 0 time = 490
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=490.05n

* CHECK dout0_20 Vdout0_20ck48 = 0 time = 490
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=490.05n

* CHECK dout0_21 Vdout0_21ck48 = 0 time = 490
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=490.05n

* CHECK dout0_22 Vdout0_22ck48 = 0 time = 490
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=490.05n

* CHECK dout0_23 Vdout0_23ck48 = 0 time = 490
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=490.05n

* CHECK dout0_24 Vdout0_24ck48 = 1.8 time = 490
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=490.05n

* CHECK dout0_25 Vdout0_25ck48 = 0 time = 490
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=490.05n

* CHECK dout0_26 Vdout0_26ck48 = 0 time = 490
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=490.05n

* CHECK dout0_27 Vdout0_27ck48 = 0 time = 490
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=490.05n

* CHECK dout0_28 Vdout0_28ck48 = 0 time = 490
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=490.05n

* CHECK dout0_29 Vdout0_29ck48 = 0 time = 490
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=490.05n

* CHECK dout0_30 Vdout0_30ck48 = 0 time = 490
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=490.05n

* CHECK dout0_31 Vdout0_31ck48 = 1.8 time = 490
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=490.05n

* CHECK dout0_32 Vdout0_32ck48 = 0 time = 490
.meas tran vdout0_32ck48 FIND v(dout0_32) AT=490.05n

* CHECK dout0_0 Vdout0_0ck50 = 1.8 time = 510
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=510.05n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 510
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=510.05n

* CHECK dout0_2 Vdout0_2ck50 = 1.8 time = 510
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=510.05n

* CHECK dout0_3 Vdout0_3ck50 = 1.8 time = 510
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=510.05n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 510
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=510.05n

* CHECK dout0_5 Vdout0_5ck50 = 0 time = 510
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=510.05n

* CHECK dout0_6 Vdout0_6ck50 = 1.8 time = 510
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=510.05n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 510
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=510.05n

* CHECK dout0_8 Vdout0_8ck50 = 1.8 time = 510
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=510.05n

* CHECK dout0_9 Vdout0_9ck50 = 0 time = 510
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=510.05n

* CHECK dout0_10 Vdout0_10ck50 = 1.8 time = 510
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=510.05n

* CHECK dout0_11 Vdout0_11ck50 = 1.8 time = 510
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=510.05n

* CHECK dout0_12 Vdout0_12ck50 = 0 time = 510
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=510.05n

* CHECK dout0_13 Vdout0_13ck50 = 0 time = 510
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=510.05n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 510
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=510.05n

* CHECK dout0_15 Vdout0_15ck50 = 0 time = 510
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=510.05n

* CHECK dout0_16 Vdout0_16ck50 = 0 time = 510
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=510.05n

* CHECK dout0_17 Vdout0_17ck50 = 1.8 time = 510
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=510.05n

* CHECK dout0_18 Vdout0_18ck50 = 0 time = 510
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=510.05n

* CHECK dout0_19 Vdout0_19ck50 = 1.8 time = 510
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=510.05n

* CHECK dout0_20 Vdout0_20ck50 = 0 time = 510
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=510.05n

* CHECK dout0_21 Vdout0_21ck50 = 1.8 time = 510
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=510.05n

* CHECK dout0_22 Vdout0_22ck50 = 1.8 time = 510
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=510.05n

* CHECK dout0_23 Vdout0_23ck50 = 0 time = 510
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=510.05n

* CHECK dout0_24 Vdout0_24ck50 = 0 time = 510
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=510.05n

* CHECK dout0_25 Vdout0_25ck50 = 1.8 time = 510
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=510.05n

* CHECK dout0_26 Vdout0_26ck50 = 1.8 time = 510
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=510.05n

* CHECK dout0_27 Vdout0_27ck50 = 1.8 time = 510
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=510.05n

* CHECK dout0_28 Vdout0_28ck50 = 0 time = 510
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=510.05n

* CHECK dout0_29 Vdout0_29ck50 = 1.8 time = 510
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=510.05n

* CHECK dout0_30 Vdout0_30ck50 = 0 time = 510
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=510.05n

* CHECK dout0_31 Vdout0_31ck50 = 0 time = 510
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=510.05n

* CHECK dout0_32 Vdout0_32ck50 = 0 time = 510
.meas tran vdout0_32ck50 FIND v(dout0_32) AT=510.05n

* CHECK dout0_0 Vdout0_0ck52 = 1.8 time = 530
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=530.05n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 530
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=530.05n

* CHECK dout0_2 Vdout0_2ck52 = 1.8 time = 530
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=530.05n

* CHECK dout0_3 Vdout0_3ck52 = 1.8 time = 530
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=530.05n

* CHECK dout0_4 Vdout0_4ck52 = 0 time = 530
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=530.05n

* CHECK dout0_5 Vdout0_5ck52 = 0 time = 530
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=530.05n

* CHECK dout0_6 Vdout0_6ck52 = 1.8 time = 530
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=530.05n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 530
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=530.05n

* CHECK dout0_8 Vdout0_8ck52 = 1.8 time = 530
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=530.05n

* CHECK dout0_9 Vdout0_9ck52 = 0 time = 530
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=530.05n

* CHECK dout0_10 Vdout0_10ck52 = 1.8 time = 530
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=530.05n

* CHECK dout0_11 Vdout0_11ck52 = 1.8 time = 530
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=530.05n

* CHECK dout0_12 Vdout0_12ck52 = 0 time = 530
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=530.05n

* CHECK dout0_13 Vdout0_13ck52 = 0 time = 530
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=530.05n

* CHECK dout0_14 Vdout0_14ck52 = 0 time = 530
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=530.05n

* CHECK dout0_15 Vdout0_15ck52 = 0 time = 530
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=530.05n

* CHECK dout0_16 Vdout0_16ck52 = 0 time = 530
.meas tran vdout0_16ck52 FIND v(dout0_16) AT=530.05n

* CHECK dout0_17 Vdout0_17ck52 = 1.8 time = 530
.meas tran vdout0_17ck52 FIND v(dout0_17) AT=530.05n

* CHECK dout0_18 Vdout0_18ck52 = 0 time = 530
.meas tran vdout0_18ck52 FIND v(dout0_18) AT=530.05n

* CHECK dout0_19 Vdout0_19ck52 = 1.8 time = 530
.meas tran vdout0_19ck52 FIND v(dout0_19) AT=530.05n

* CHECK dout0_20 Vdout0_20ck52 = 0 time = 530
.meas tran vdout0_20ck52 FIND v(dout0_20) AT=530.05n

* CHECK dout0_21 Vdout0_21ck52 = 1.8 time = 530
.meas tran vdout0_21ck52 FIND v(dout0_21) AT=530.05n

* CHECK dout0_22 Vdout0_22ck52 = 1.8 time = 530
.meas tran vdout0_22ck52 FIND v(dout0_22) AT=530.05n

* CHECK dout0_23 Vdout0_23ck52 = 0 time = 530
.meas tran vdout0_23ck52 FIND v(dout0_23) AT=530.05n

* CHECK dout0_24 Vdout0_24ck52 = 0 time = 530
.meas tran vdout0_24ck52 FIND v(dout0_24) AT=530.05n

* CHECK dout0_25 Vdout0_25ck52 = 1.8 time = 530
.meas tran vdout0_25ck52 FIND v(dout0_25) AT=530.05n

* CHECK dout0_26 Vdout0_26ck52 = 1.8 time = 530
.meas tran vdout0_26ck52 FIND v(dout0_26) AT=530.05n

* CHECK dout0_27 Vdout0_27ck52 = 1.8 time = 530
.meas tran vdout0_27ck52 FIND v(dout0_27) AT=530.05n

* CHECK dout0_28 Vdout0_28ck52 = 0 time = 530
.meas tran vdout0_28ck52 FIND v(dout0_28) AT=530.05n

* CHECK dout0_29 Vdout0_29ck52 = 1.8 time = 530
.meas tran vdout0_29ck52 FIND v(dout0_29) AT=530.05n

* CHECK dout0_30 Vdout0_30ck52 = 0 time = 530
.meas tran vdout0_30ck52 FIND v(dout0_30) AT=530.05n

* CHECK dout0_31 Vdout0_31ck52 = 0 time = 530
.meas tran vdout0_31ck52 FIND v(dout0_31) AT=530.05n

* CHECK dout0_32 Vdout0_32ck52 = 0 time = 530
.meas tran vdout0_32ck52 FIND v(dout0_32) AT=530.05n

* CHECK dout0_0 Vdout0_0ck53 = 1.8 time = 540
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=540.05n

* CHECK dout0_1 Vdout0_1ck53 = 1.8 time = 540
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=540.05n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 540
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=540.05n

* CHECK dout0_3 Vdout0_3ck53 = 1.8 time = 540
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=540.05n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 540
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=540.05n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 540
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=540.05n

* CHECK dout0_6 Vdout0_6ck53 = 1.8 time = 540
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=540.05n

* CHECK dout0_7 Vdout0_7ck53 = 1.8 time = 540
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=540.05n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 540
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=540.05n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 540
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=540.05n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 540
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=540.05n

* CHECK dout0_11 Vdout0_11ck53 = 1.8 time = 540
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=540.05n

* CHECK dout0_12 Vdout0_12ck53 = 1.8 time = 540
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=540.05n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 540
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=540.05n

* CHECK dout0_14 Vdout0_14ck53 = 1.8 time = 540
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=540.05n

* CHECK dout0_15 Vdout0_15ck53 = 1.8 time = 540
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=540.05n

* CHECK dout0_16 Vdout0_16ck53 = 0 time = 540
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=540.05n

* CHECK dout0_17 Vdout0_17ck53 = 0 time = 540
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=540.05n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 540
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=540.05n

* CHECK dout0_19 Vdout0_19ck53 = 0 time = 540
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=540.05n

* CHECK dout0_20 Vdout0_20ck53 = 0 time = 540
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=540.05n

* CHECK dout0_21 Vdout0_21ck53 = 0 time = 540
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=540.05n

* CHECK dout0_22 Vdout0_22ck53 = 0 time = 540
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=540.05n

* CHECK dout0_23 Vdout0_23ck53 = 0 time = 540
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=540.05n

* CHECK dout0_24 Vdout0_24ck53 = 1.8 time = 540
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=540.05n

* CHECK dout0_25 Vdout0_25ck53 = 0 time = 540
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=540.05n

* CHECK dout0_26 Vdout0_26ck53 = 0 time = 540
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=540.05n

* CHECK dout0_27 Vdout0_27ck53 = 0 time = 540
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=540.05n

* CHECK dout0_28 Vdout0_28ck53 = 0 time = 540
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=540.05n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 540
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=540.05n

* CHECK dout0_30 Vdout0_30ck53 = 0 time = 540
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=540.05n

* CHECK dout0_31 Vdout0_31ck53 = 1.8 time = 540
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=540.05n

* CHECK dout0_32 Vdout0_32ck53 = 0 time = 540
.meas tran vdout0_32ck53 FIND v(dout0_32) AT=540.05n

* CHECK dout0_0 Vdout0_0ck58 = 1.8 time = 590
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=590.05n

* CHECK dout0_1 Vdout0_1ck58 = 1.8 time = 590
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=590.05n

* CHECK dout0_2 Vdout0_2ck58 = 1.8 time = 590
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=590.05n

* CHECK dout0_3 Vdout0_3ck58 = 1.8 time = 590
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=590.05n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 590
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=590.05n

* CHECK dout0_5 Vdout0_5ck58 = 1.8 time = 590
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=590.05n

* CHECK dout0_6 Vdout0_6ck58 = 1.8 time = 590
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=590.05n

* CHECK dout0_7 Vdout0_7ck58 = 1.8 time = 590
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=590.05n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 590
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=590.05n

* CHECK dout0_9 Vdout0_9ck58 = 1.8 time = 590
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=590.05n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 590
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=590.05n

* CHECK dout0_11 Vdout0_11ck58 = 1.8 time = 590
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=590.05n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 590
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=590.05n

* CHECK dout0_13 Vdout0_13ck58 = 0 time = 590
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=590.05n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 590
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=590.05n

* CHECK dout0_15 Vdout0_15ck58 = 0 time = 590
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=590.05n

* CHECK dout0_16 Vdout0_16ck58 = 0 time = 590
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=590.05n

* CHECK dout0_17 Vdout0_17ck58 = 1.8 time = 590
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=590.05n

* CHECK dout0_18 Vdout0_18ck58 = 0 time = 590
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=590.05n

* CHECK dout0_19 Vdout0_19ck58 = 0 time = 590
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=590.05n

* CHECK dout0_20 Vdout0_20ck58 = 1.8 time = 590
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=590.05n

* CHECK dout0_21 Vdout0_21ck58 = 1.8 time = 590
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=590.05n

* CHECK dout0_22 Vdout0_22ck58 = 0 time = 590
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=590.05n

* CHECK dout0_23 Vdout0_23ck58 = 0 time = 590
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=590.05n

* CHECK dout0_24 Vdout0_24ck58 = 1.8 time = 590
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=590.05n

* CHECK dout0_25 Vdout0_25ck58 = 0 time = 590
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=590.05n

* CHECK dout0_26 Vdout0_26ck58 = 1.8 time = 590
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=590.05n

* CHECK dout0_27 Vdout0_27ck58 = 0 time = 590
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=590.05n

* CHECK dout0_28 Vdout0_28ck58 = 1.8 time = 590
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=590.05n

* CHECK dout0_29 Vdout0_29ck58 = 1.8 time = 590
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=590.05n

* CHECK dout0_30 Vdout0_30ck58 = 0 time = 590
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=590.05n

* CHECK dout0_31 Vdout0_31ck58 = 0 time = 590
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=590.05n

* CHECK dout0_32 Vdout0_32ck58 = 0 time = 590
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=590.05n

* CHECK dout0_0 Vdout0_0ck66 = 1.8 time = 670
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=670.05n

* CHECK dout0_1 Vdout0_1ck66 = 1.8 time = 670
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=670.05n

* CHECK dout0_2 Vdout0_2ck66 = 1.8 time = 670
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=670.05n

* CHECK dout0_3 Vdout0_3ck66 = 0 time = 670
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=670.05n

* CHECK dout0_4 Vdout0_4ck66 = 1.8 time = 670
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=670.05n

* CHECK dout0_5 Vdout0_5ck66 = 1.8 time = 670
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=670.05n

* CHECK dout0_6 Vdout0_6ck66 = 1.8 time = 670
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=670.05n

* CHECK dout0_7 Vdout0_7ck66 = 1.8 time = 670
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=670.05n

* CHECK dout0_8 Vdout0_8ck66 = 1.8 time = 670
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=670.05n

* CHECK dout0_9 Vdout0_9ck66 = 0 time = 670
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=670.05n

* CHECK dout0_10 Vdout0_10ck66 = 1.8 time = 670
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=670.05n

* CHECK dout0_11 Vdout0_11ck66 = 0 time = 670
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=670.05n

* CHECK dout0_12 Vdout0_12ck66 = 0 time = 670
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=670.05n

* CHECK dout0_13 Vdout0_13ck66 = 1.8 time = 670
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=670.05n

* CHECK dout0_14 Vdout0_14ck66 = 0 time = 670
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=670.05n

* CHECK dout0_15 Vdout0_15ck66 = 1.8 time = 670
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=670.05n

* CHECK dout0_16 Vdout0_16ck66 = 1.8 time = 670
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=670.05n

* CHECK dout0_17 Vdout0_17ck66 = 1.8 time = 670
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=670.05n

* CHECK dout0_18 Vdout0_18ck66 = 1.8 time = 670
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=670.05n

* CHECK dout0_19 Vdout0_19ck66 = 0 time = 670
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=670.05n

* CHECK dout0_20 Vdout0_20ck66 = 0 time = 670
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=670.05n

* CHECK dout0_21 Vdout0_21ck66 = 0 time = 670
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=670.05n

* CHECK dout0_22 Vdout0_22ck66 = 0 time = 670
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=670.05n

* CHECK dout0_23 Vdout0_23ck66 = 0 time = 670
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=670.05n

* CHECK dout0_24 Vdout0_24ck66 = 1.8 time = 670
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=670.05n

* CHECK dout0_25 Vdout0_25ck66 = 1.8 time = 670
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=670.05n

* CHECK dout0_26 Vdout0_26ck66 = 1.8 time = 670
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=670.05n

* CHECK dout0_27 Vdout0_27ck66 = 1.8 time = 670
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=670.05n

* CHECK dout0_28 Vdout0_28ck66 = 0 time = 670
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=670.05n

* CHECK dout0_29 Vdout0_29ck66 = 0 time = 670
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=670.05n

* CHECK dout0_30 Vdout0_30ck66 = 1.8 time = 670
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=670.05n

* CHECK dout0_31 Vdout0_31ck66 = 1.8 time = 670
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=670.05n

* CHECK dout0_32 Vdout0_32ck66 = 0 time = 670
.meas tran vdout0_32ck66 FIND v(dout0_32) AT=670.05n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 730
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=730.05n

* CHECK dout0_1 Vdout0_1ck72 = 0 time = 730
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=730.05n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 730
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=730.05n

* CHECK dout0_3 Vdout0_3ck72 = 1.8 time = 730
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=730.05n

* CHECK dout0_4 Vdout0_4ck72 = 1.8 time = 730
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=730.05n

* CHECK dout0_5 Vdout0_5ck72 = 1.8 time = 730
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=730.05n

* CHECK dout0_6 Vdout0_6ck72 = 0 time = 730
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=730.05n

* CHECK dout0_7 Vdout0_7ck72 = 0 time = 730
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=730.05n

* CHECK dout0_8 Vdout0_8ck72 = 1.8 time = 730
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=730.05n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 730
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=730.05n

* CHECK dout0_10 Vdout0_10ck72 = 0 time = 730
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=730.05n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 730
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=730.05n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 730
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=730.05n

* CHECK dout0_13 Vdout0_13ck72 = 0 time = 730
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=730.05n

* CHECK dout0_14 Vdout0_14ck72 = 0 time = 730
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=730.05n

* CHECK dout0_15 Vdout0_15ck72 = 1.8 time = 730
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=730.05n

* CHECK dout0_16 Vdout0_16ck72 = 1.8 time = 730
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=730.05n

* CHECK dout0_17 Vdout0_17ck72 = 0 time = 730
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=730.05n

* CHECK dout0_18 Vdout0_18ck72 = 1.8 time = 730
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=730.05n

* CHECK dout0_19 Vdout0_19ck72 = 1.8 time = 730
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=730.05n

* CHECK dout0_20 Vdout0_20ck72 = 0 time = 730
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=730.05n

* CHECK dout0_21 Vdout0_21ck72 = 0 time = 730
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=730.05n

* CHECK dout0_22 Vdout0_22ck72 = 0 time = 730
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=730.05n

* CHECK dout0_23 Vdout0_23ck72 = 0 time = 730
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=730.05n

* CHECK dout0_24 Vdout0_24ck72 = 0 time = 730
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=730.05n

* CHECK dout0_25 Vdout0_25ck72 = 1.8 time = 730
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=730.05n

* CHECK dout0_26 Vdout0_26ck72 = 1.8 time = 730
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=730.05n

* CHECK dout0_27 Vdout0_27ck72 = 1.8 time = 730
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=730.05n

* CHECK dout0_28 Vdout0_28ck72 = 0 time = 730
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=730.05n

* CHECK dout0_29 Vdout0_29ck72 = 0 time = 730
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=730.05n

* CHECK dout0_30 Vdout0_30ck72 = 0 time = 730
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=730.05n

* CHECK dout0_31 Vdout0_31ck72 = 1.8 time = 730
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=730.05n

* CHECK dout0_32 Vdout0_32ck72 = 0 time = 730
.meas tran vdout0_32ck72 FIND v(dout0_32) AT=730.05n

* CHECK dout0_0 Vdout0_0ck73 = 1.8 time = 740
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=740.05n

* CHECK dout0_1 Vdout0_1ck73 = 0 time = 740
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=740.05n

* CHECK dout0_2 Vdout0_2ck73 = 1.8 time = 740
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=740.05n

* CHECK dout0_3 Vdout0_3ck73 = 0 time = 740
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=740.05n

* CHECK dout0_4 Vdout0_4ck73 = 0 time = 740
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=740.05n

* CHECK dout0_5 Vdout0_5ck73 = 1.8 time = 740
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=740.05n

* CHECK dout0_6 Vdout0_6ck73 = 0 time = 740
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=740.05n

* CHECK dout0_7 Vdout0_7ck73 = 1.8 time = 740
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=740.05n

* CHECK dout0_8 Vdout0_8ck73 = 1.8 time = 740
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=740.05n

* CHECK dout0_9 Vdout0_9ck73 = 1.8 time = 740
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=740.05n

* CHECK dout0_10 Vdout0_10ck73 = 1.8 time = 740
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=740.05n

* CHECK dout0_11 Vdout0_11ck73 = 0 time = 740
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=740.05n

* CHECK dout0_12 Vdout0_12ck73 = 1.8 time = 740
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=740.05n

* CHECK dout0_13 Vdout0_13ck73 = 0 time = 740
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=740.05n

* CHECK dout0_14 Vdout0_14ck73 = 1.8 time = 740
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=740.05n

* CHECK dout0_15 Vdout0_15ck73 = 0 time = 740
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=740.05n

* CHECK dout0_16 Vdout0_16ck73 = 0 time = 740
.meas tran vdout0_16ck73 FIND v(dout0_16) AT=740.05n

* CHECK dout0_17 Vdout0_17ck73 = 1.8 time = 740
.meas tran vdout0_17ck73 FIND v(dout0_17) AT=740.05n

* CHECK dout0_18 Vdout0_18ck73 = 1.8 time = 740
.meas tran vdout0_18ck73 FIND v(dout0_18) AT=740.05n

* CHECK dout0_19 Vdout0_19ck73 = 0 time = 740
.meas tran vdout0_19ck73 FIND v(dout0_19) AT=740.05n

* CHECK dout0_20 Vdout0_20ck73 = 0 time = 740
.meas tran vdout0_20ck73 FIND v(dout0_20) AT=740.05n

* CHECK dout0_21 Vdout0_21ck73 = 1.8 time = 740
.meas tran vdout0_21ck73 FIND v(dout0_21) AT=740.05n

* CHECK dout0_22 Vdout0_22ck73 = 1.8 time = 740
.meas tran vdout0_22ck73 FIND v(dout0_22) AT=740.05n

* CHECK dout0_23 Vdout0_23ck73 = 1.8 time = 740
.meas tran vdout0_23ck73 FIND v(dout0_23) AT=740.05n

* CHECK dout0_24 Vdout0_24ck73 = 0 time = 740
.meas tran vdout0_24ck73 FIND v(dout0_24) AT=740.05n

* CHECK dout0_25 Vdout0_25ck73 = 1.8 time = 740
.meas tran vdout0_25ck73 FIND v(dout0_25) AT=740.05n

* CHECK dout0_26 Vdout0_26ck73 = 0 time = 740
.meas tran vdout0_26ck73 FIND v(dout0_26) AT=740.05n

* CHECK dout0_27 Vdout0_27ck73 = 0 time = 740
.meas tran vdout0_27ck73 FIND v(dout0_27) AT=740.05n

* CHECK dout0_28 Vdout0_28ck73 = 1.8 time = 740
.meas tran vdout0_28ck73 FIND v(dout0_28) AT=740.05n

* CHECK dout0_29 Vdout0_29ck73 = 1.8 time = 740
.meas tran vdout0_29ck73 FIND v(dout0_29) AT=740.05n

* CHECK dout0_30 Vdout0_30ck73 = 1.8 time = 740
.meas tran vdout0_30ck73 FIND v(dout0_30) AT=740.05n

* CHECK dout0_31 Vdout0_31ck73 = 0 time = 740
.meas tran vdout0_31ck73 FIND v(dout0_31) AT=740.05n

* CHECK dout0_32 Vdout0_32ck73 = 0 time = 740
.meas tran vdout0_32ck73 FIND v(dout0_32) AT=740.05n

* CHECK dout0_0 Vdout0_0ck74 = 1.8 time = 750
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=750.05n

* CHECK dout0_1 Vdout0_1ck74 = 1.8 time = 750
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=750.05n

* CHECK dout0_2 Vdout0_2ck74 = 1.8 time = 750
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=750.05n

* CHECK dout0_3 Vdout0_3ck74 = 0 time = 750
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=750.05n

* CHECK dout0_4 Vdout0_4ck74 = 1.8 time = 750
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=750.05n

* CHECK dout0_5 Vdout0_5ck74 = 1.8 time = 750
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=750.05n

* CHECK dout0_6 Vdout0_6ck74 = 1.8 time = 750
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=750.05n

* CHECK dout0_7 Vdout0_7ck74 = 1.8 time = 750
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=750.05n

* CHECK dout0_8 Vdout0_8ck74 = 1.8 time = 750
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=750.05n

* CHECK dout0_9 Vdout0_9ck74 = 0 time = 750
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=750.05n

* CHECK dout0_10 Vdout0_10ck74 = 1.8 time = 750
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=750.05n

* CHECK dout0_11 Vdout0_11ck74 = 0 time = 750
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=750.05n

* CHECK dout0_12 Vdout0_12ck74 = 1.8 time = 750
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=750.05n

* CHECK dout0_13 Vdout0_13ck74 = 0 time = 750
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=750.05n

* CHECK dout0_14 Vdout0_14ck74 = 1.8 time = 750
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=750.05n

* CHECK dout0_15 Vdout0_15ck74 = 1.8 time = 750
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=750.05n

* CHECK dout0_16 Vdout0_16ck74 = 0 time = 750
.meas tran vdout0_16ck74 FIND v(dout0_16) AT=750.05n

* CHECK dout0_17 Vdout0_17ck74 = 1.8 time = 750
.meas tran vdout0_17ck74 FIND v(dout0_17) AT=750.05n

* CHECK dout0_18 Vdout0_18ck74 = 1.8 time = 750
.meas tran vdout0_18ck74 FIND v(dout0_18) AT=750.05n

* CHECK dout0_19 Vdout0_19ck74 = 1.8 time = 750
.meas tran vdout0_19ck74 FIND v(dout0_19) AT=750.05n

* CHECK dout0_20 Vdout0_20ck74 = 1.8 time = 750
.meas tran vdout0_20ck74 FIND v(dout0_20) AT=750.05n

* CHECK dout0_21 Vdout0_21ck74 = 1.8 time = 750
.meas tran vdout0_21ck74 FIND v(dout0_21) AT=750.05n

* CHECK dout0_22 Vdout0_22ck74 = 1.8 time = 750
.meas tran vdout0_22ck74 FIND v(dout0_22) AT=750.05n

* CHECK dout0_23 Vdout0_23ck74 = 0 time = 750
.meas tran vdout0_23ck74 FIND v(dout0_23) AT=750.05n

* CHECK dout0_24 Vdout0_24ck74 = 0 time = 750
.meas tran vdout0_24ck74 FIND v(dout0_24) AT=750.05n

* CHECK dout0_25 Vdout0_25ck74 = 0 time = 750
.meas tran vdout0_25ck74 FIND v(dout0_25) AT=750.05n

* CHECK dout0_26 Vdout0_26ck74 = 1.8 time = 750
.meas tran vdout0_26ck74 FIND v(dout0_26) AT=750.05n

* CHECK dout0_27 Vdout0_27ck74 = 1.8 time = 750
.meas tran vdout0_27ck74 FIND v(dout0_27) AT=750.05n

* CHECK dout0_28 Vdout0_28ck74 = 1.8 time = 750
.meas tran vdout0_28ck74 FIND v(dout0_28) AT=750.05n

* CHECK dout0_29 Vdout0_29ck74 = 0 time = 750
.meas tran vdout0_29ck74 FIND v(dout0_29) AT=750.05n

* CHECK dout0_30 Vdout0_30ck74 = 1.8 time = 750
.meas tran vdout0_30ck74 FIND v(dout0_30) AT=750.05n

* CHECK dout0_31 Vdout0_31ck74 = 0 time = 750
.meas tran vdout0_31ck74 FIND v(dout0_31) AT=750.05n

* CHECK dout0_32 Vdout0_32ck74 = 0 time = 750
.meas tran vdout0_32ck74 FIND v(dout0_32) AT=750.05n

* CHECK dout0_0 Vdout0_0ck77 = 1.8 time = 780
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=780.05n

* CHECK dout0_1 Vdout0_1ck77 = 1.8 time = 780
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=780.05n

* CHECK dout0_2 Vdout0_2ck77 = 1.8 time = 780
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=780.05n

* CHECK dout0_3 Vdout0_3ck77 = 0 time = 780
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=780.05n

* CHECK dout0_4 Vdout0_4ck77 = 1.8 time = 780
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=780.05n

* CHECK dout0_5 Vdout0_5ck77 = 1.8 time = 780
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=780.05n

* CHECK dout0_6 Vdout0_6ck77 = 1.8 time = 780
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=780.05n

* CHECK dout0_7 Vdout0_7ck77 = 1.8 time = 780
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=780.05n

* CHECK dout0_8 Vdout0_8ck77 = 1.8 time = 780
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=780.05n

* CHECK dout0_9 Vdout0_9ck77 = 0 time = 780
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=780.05n

* CHECK dout0_10 Vdout0_10ck77 = 1.8 time = 780
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=780.05n

* CHECK dout0_11 Vdout0_11ck77 = 0 time = 780
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=780.05n

* CHECK dout0_12 Vdout0_12ck77 = 1.8 time = 780
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=780.05n

* CHECK dout0_13 Vdout0_13ck77 = 0 time = 780
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=780.05n

* CHECK dout0_14 Vdout0_14ck77 = 1.8 time = 780
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=780.05n

* CHECK dout0_15 Vdout0_15ck77 = 1.8 time = 780
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=780.05n

* CHECK dout0_16 Vdout0_16ck77 = 0 time = 780
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=780.05n

* CHECK dout0_17 Vdout0_17ck77 = 1.8 time = 780
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=780.05n

* CHECK dout0_18 Vdout0_18ck77 = 1.8 time = 780
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=780.05n

* CHECK dout0_19 Vdout0_19ck77 = 1.8 time = 780
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=780.05n

* CHECK dout0_20 Vdout0_20ck77 = 1.8 time = 780
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=780.05n

* CHECK dout0_21 Vdout0_21ck77 = 1.8 time = 780
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=780.05n

* CHECK dout0_22 Vdout0_22ck77 = 1.8 time = 780
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=780.05n

* CHECK dout0_23 Vdout0_23ck77 = 0 time = 780
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=780.05n

* CHECK dout0_24 Vdout0_24ck77 = 0 time = 780
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=780.05n

* CHECK dout0_25 Vdout0_25ck77 = 0 time = 780
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=780.05n

* CHECK dout0_26 Vdout0_26ck77 = 1.8 time = 780
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=780.05n

* CHECK dout0_27 Vdout0_27ck77 = 1.8 time = 780
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=780.05n

* CHECK dout0_28 Vdout0_28ck77 = 1.8 time = 780
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=780.05n

* CHECK dout0_29 Vdout0_29ck77 = 0 time = 780
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=780.05n

* CHECK dout0_30 Vdout0_30ck77 = 1.8 time = 780
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=780.05n

* CHECK dout0_31 Vdout0_31ck77 = 0 time = 780
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=780.05n

* CHECK dout0_32 Vdout0_32ck77 = 0 time = 780
.meas tran vdout0_32ck77 FIND v(dout0_32) AT=780.05n

* CHECK dout0_0 Vdout0_0ck78 = 1.8 time = 790
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=790.05n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 790
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=790.05n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 790
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=790.05n

* CHECK dout0_3 Vdout0_3ck78 = 0 time = 790
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=790.05n

* CHECK dout0_4 Vdout0_4ck78 = 1.8 time = 790
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=790.05n

* CHECK dout0_5 Vdout0_5ck78 = 1.8 time = 790
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=790.05n

* CHECK dout0_6 Vdout0_6ck78 = 1.8 time = 790
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=790.05n

* CHECK dout0_7 Vdout0_7ck78 = 1.8 time = 790
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=790.05n

* CHECK dout0_8 Vdout0_8ck78 = 0 time = 790
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=790.05n

* CHECK dout0_9 Vdout0_9ck78 = 1.8 time = 790
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=790.05n

* CHECK dout0_10 Vdout0_10ck78 = 1.8 time = 790
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=790.05n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 790
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=790.05n

* CHECK dout0_12 Vdout0_12ck78 = 1.8 time = 790
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=790.05n

* CHECK dout0_13 Vdout0_13ck78 = 1.8 time = 790
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=790.05n

* CHECK dout0_14 Vdout0_14ck78 = 0 time = 790
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=790.05n

* CHECK dout0_15 Vdout0_15ck78 = 1.8 time = 790
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=790.05n

* CHECK dout0_16 Vdout0_16ck78 = 1.8 time = 790
.meas tran vdout0_16ck78 FIND v(dout0_16) AT=790.05n

* CHECK dout0_17 Vdout0_17ck78 = 0 time = 790
.meas tran vdout0_17ck78 FIND v(dout0_17) AT=790.05n

* CHECK dout0_18 Vdout0_18ck78 = 0 time = 790
.meas tran vdout0_18ck78 FIND v(dout0_18) AT=790.05n

* CHECK dout0_19 Vdout0_19ck78 = 0 time = 790
.meas tran vdout0_19ck78 FIND v(dout0_19) AT=790.05n

* CHECK dout0_20 Vdout0_20ck78 = 1.8 time = 790
.meas tran vdout0_20ck78 FIND v(dout0_20) AT=790.05n

* CHECK dout0_21 Vdout0_21ck78 = 1.8 time = 790
.meas tran vdout0_21ck78 FIND v(dout0_21) AT=790.05n

* CHECK dout0_22 Vdout0_22ck78 = 1.8 time = 790
.meas tran vdout0_22ck78 FIND v(dout0_22) AT=790.05n

* CHECK dout0_23 Vdout0_23ck78 = 1.8 time = 790
.meas tran vdout0_23ck78 FIND v(dout0_23) AT=790.05n

* CHECK dout0_24 Vdout0_24ck78 = 1.8 time = 790
.meas tran vdout0_24ck78 FIND v(dout0_24) AT=790.05n

* CHECK dout0_25 Vdout0_25ck78 = 1.8 time = 790
.meas tran vdout0_25ck78 FIND v(dout0_25) AT=790.05n

* CHECK dout0_26 Vdout0_26ck78 = 1.8 time = 790
.meas tran vdout0_26ck78 FIND v(dout0_26) AT=790.05n

* CHECK dout0_27 Vdout0_27ck78 = 0 time = 790
.meas tran vdout0_27ck78 FIND v(dout0_27) AT=790.05n

* CHECK dout0_28 Vdout0_28ck78 = 0 time = 790
.meas tran vdout0_28ck78 FIND v(dout0_28) AT=790.05n

* CHECK dout0_29 Vdout0_29ck78 = 0 time = 790
.meas tran vdout0_29ck78 FIND v(dout0_29) AT=790.05n

* CHECK dout0_30 Vdout0_30ck78 = 1.8 time = 790
.meas tran vdout0_30ck78 FIND v(dout0_30) AT=790.05n

* CHECK dout0_31 Vdout0_31ck78 = 0 time = 790
.meas tran vdout0_31ck78 FIND v(dout0_31) AT=790.05n

* CHECK dout0_32 Vdout0_32ck78 = 0 time = 790
.meas tran vdout0_32ck78 FIND v(dout0_32) AT=790.05n

* CHECK dout0_0 Vdout0_0ck79 = 1.8 time = 800
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=800.05n

* CHECK dout0_1 Vdout0_1ck79 = 1.8 time = 800
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=800.05n

* CHECK dout0_2 Vdout0_2ck79 = 1.8 time = 800
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=800.05n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 800
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=800.05n

* CHECK dout0_4 Vdout0_4ck79 = 1.8 time = 800
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=800.05n

* CHECK dout0_5 Vdout0_5ck79 = 1.8 time = 800
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=800.05n

* CHECK dout0_6 Vdout0_6ck79 = 1.8 time = 800
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=800.05n

* CHECK dout0_7 Vdout0_7ck79 = 1.8 time = 800
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=800.05n

* CHECK dout0_8 Vdout0_8ck79 = 1.8 time = 800
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=800.05n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 800
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=800.05n

* CHECK dout0_10 Vdout0_10ck79 = 1.8 time = 800
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=800.05n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 800
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=800.05n

* CHECK dout0_12 Vdout0_12ck79 = 1.8 time = 800
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=800.05n

* CHECK dout0_13 Vdout0_13ck79 = 0 time = 800
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=800.05n

* CHECK dout0_14 Vdout0_14ck79 = 1.8 time = 800
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=800.05n

* CHECK dout0_15 Vdout0_15ck79 = 1.8 time = 800
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=800.05n

* CHECK dout0_16 Vdout0_16ck79 = 0 time = 800
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=800.05n

* CHECK dout0_17 Vdout0_17ck79 = 1.8 time = 800
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=800.05n

* CHECK dout0_18 Vdout0_18ck79 = 1.8 time = 800
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=800.05n

* CHECK dout0_19 Vdout0_19ck79 = 1.8 time = 800
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=800.05n

* CHECK dout0_20 Vdout0_20ck79 = 1.8 time = 800
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=800.05n

* CHECK dout0_21 Vdout0_21ck79 = 1.8 time = 800
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=800.05n

* CHECK dout0_22 Vdout0_22ck79 = 1.8 time = 800
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=800.05n

* CHECK dout0_23 Vdout0_23ck79 = 0 time = 800
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=800.05n

* CHECK dout0_24 Vdout0_24ck79 = 0 time = 800
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=800.05n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 800
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=800.05n

* CHECK dout0_26 Vdout0_26ck79 = 1.8 time = 800
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=800.05n

* CHECK dout0_27 Vdout0_27ck79 = 1.8 time = 800
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=800.05n

* CHECK dout0_28 Vdout0_28ck79 = 1.8 time = 800
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=800.05n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 800
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=800.05n

* CHECK dout0_30 Vdout0_30ck79 = 1.8 time = 800
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=800.05n

* CHECK dout0_31 Vdout0_31ck79 = 0 time = 800
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=800.05n

* CHECK dout0_32 Vdout0_32ck79 = 0 time = 800
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=800.05n

* CHECK dout0_0 Vdout0_0ck81 = 1.8 time = 820
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=820.05n

* CHECK dout0_1 Vdout0_1ck81 = 0 time = 820
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=820.05n

* CHECK dout0_2 Vdout0_2ck81 = 1.8 time = 820
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=820.05n

* CHECK dout0_3 Vdout0_3ck81 = 1.8 time = 820
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=820.05n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 820
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=820.05n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 820
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=820.05n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 820
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=820.05n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 820
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=820.05n

* CHECK dout0_8 Vdout0_8ck81 = 1.8 time = 820
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=820.05n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 820
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=820.05n

* CHECK dout0_10 Vdout0_10ck81 = 1.8 time = 820
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=820.05n

* CHECK dout0_11 Vdout0_11ck81 = 1.8 time = 820
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=820.05n

* CHECK dout0_12 Vdout0_12ck81 = 0 time = 820
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=820.05n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 820
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=820.05n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 820
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=820.05n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 820
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=820.05n

* CHECK dout0_16 Vdout0_16ck81 = 0 time = 820
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=820.05n

* CHECK dout0_17 Vdout0_17ck81 = 1.8 time = 820
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=820.05n

* CHECK dout0_18 Vdout0_18ck81 = 0 time = 820
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=820.05n

* CHECK dout0_19 Vdout0_19ck81 = 1.8 time = 820
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=820.05n

* CHECK dout0_20 Vdout0_20ck81 = 0 time = 820
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=820.05n

* CHECK dout0_21 Vdout0_21ck81 = 1.8 time = 820
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=820.05n

* CHECK dout0_22 Vdout0_22ck81 = 1.8 time = 820
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=820.05n

* CHECK dout0_23 Vdout0_23ck81 = 0 time = 820
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=820.05n

* CHECK dout0_24 Vdout0_24ck81 = 1.8 time = 820
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=820.05n

* CHECK dout0_25 Vdout0_25ck81 = 0 time = 820
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=820.05n

* CHECK dout0_26 Vdout0_26ck81 = 1.8 time = 820
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=820.05n

* CHECK dout0_27 Vdout0_27ck81 = 1.8 time = 820
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=820.05n

* CHECK dout0_28 Vdout0_28ck81 = 1.8 time = 820
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=820.05n

* CHECK dout0_29 Vdout0_29ck81 = 1.8 time = 820
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=820.05n

* CHECK dout0_30 Vdout0_30ck81 = 1.8 time = 820
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=820.05n

* CHECK dout0_31 Vdout0_31ck81 = 0 time = 820
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=820.05n

* CHECK dout0_32 Vdout0_32ck81 = 0 time = 820
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=820.05n

* CHECK dout0_0 Vdout0_0ck82 = 1.8 time = 830
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=830.05n

* CHECK dout0_1 Vdout0_1ck82 = 1.8 time = 830
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=830.05n

* CHECK dout0_2 Vdout0_2ck82 = 1.8 time = 830
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=830.05n

* CHECK dout0_3 Vdout0_3ck82 = 0 time = 830
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=830.05n

* CHECK dout0_4 Vdout0_4ck82 = 1.8 time = 830
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=830.05n

* CHECK dout0_5 Vdout0_5ck82 = 1.8 time = 830
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=830.05n

* CHECK dout0_6 Vdout0_6ck82 = 1.8 time = 830
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=830.05n

* CHECK dout0_7 Vdout0_7ck82 = 1.8 time = 830
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=830.05n

* CHECK dout0_8 Vdout0_8ck82 = 1.8 time = 830
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=830.05n

* CHECK dout0_9 Vdout0_9ck82 = 0 time = 830
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=830.05n

* CHECK dout0_10 Vdout0_10ck82 = 1.8 time = 830
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=830.05n

* CHECK dout0_11 Vdout0_11ck82 = 0 time = 830
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=830.05n

* CHECK dout0_12 Vdout0_12ck82 = 1.8 time = 830
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=830.05n

* CHECK dout0_13 Vdout0_13ck82 = 0 time = 830
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=830.05n

* CHECK dout0_14 Vdout0_14ck82 = 1.8 time = 830
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=830.05n

* CHECK dout0_15 Vdout0_15ck82 = 1.8 time = 830
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=830.05n

* CHECK dout0_16 Vdout0_16ck82 = 0 time = 830
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=830.05n

* CHECK dout0_17 Vdout0_17ck82 = 1.8 time = 830
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=830.05n

* CHECK dout0_18 Vdout0_18ck82 = 1.8 time = 830
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=830.05n

* CHECK dout0_19 Vdout0_19ck82 = 1.8 time = 830
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=830.05n

* CHECK dout0_20 Vdout0_20ck82 = 1.8 time = 830
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=830.05n

* CHECK dout0_21 Vdout0_21ck82 = 1.8 time = 830
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=830.05n

* CHECK dout0_22 Vdout0_22ck82 = 1.8 time = 830
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=830.05n

* CHECK dout0_23 Vdout0_23ck82 = 0 time = 830
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=830.05n

* CHECK dout0_24 Vdout0_24ck82 = 0 time = 830
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=830.05n

* CHECK dout0_25 Vdout0_25ck82 = 0 time = 830
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=830.05n

* CHECK dout0_26 Vdout0_26ck82 = 1.8 time = 830
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=830.05n

* CHECK dout0_27 Vdout0_27ck82 = 1.8 time = 830
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=830.05n

* CHECK dout0_28 Vdout0_28ck82 = 1.8 time = 830
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=830.05n

* CHECK dout0_29 Vdout0_29ck82 = 0 time = 830
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=830.05n

* CHECK dout0_30 Vdout0_30ck82 = 1.8 time = 830
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=830.05n

* CHECK dout0_31 Vdout0_31ck82 = 0 time = 830
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=830.05n

* CHECK dout0_32 Vdout0_32ck82 = 0 time = 830
.meas tran vdout0_32ck82 FIND v(dout0_32) AT=830.05n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 870
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=870.05n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 870
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=870.05n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 870
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=870.05n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 870
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=870.05n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 870
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=870.05n

* CHECK dout0_5 Vdout0_5ck86 = 0 time = 870
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=870.05n

* CHECK dout0_6 Vdout0_6ck86 = 1.8 time = 870
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=870.05n

* CHECK dout0_7 Vdout0_7ck86 = 1.8 time = 870
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=870.05n

* CHECK dout0_8 Vdout0_8ck86 = 1.8 time = 870
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=870.05n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 870
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=870.05n

* CHECK dout0_10 Vdout0_10ck86 = 1.8 time = 870
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=870.05n

* CHECK dout0_11 Vdout0_11ck86 = 1.8 time = 870
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=870.05n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 870
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=870.05n

* CHECK dout0_13 Vdout0_13ck86 = 1.8 time = 870
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=870.05n

* CHECK dout0_14 Vdout0_14ck86 = 0 time = 870
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=870.05n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 870
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=870.05n

* CHECK dout0_16 Vdout0_16ck86 = 1.8 time = 870
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=870.05n

* CHECK dout0_17 Vdout0_17ck86 = 0 time = 870
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=870.05n

* CHECK dout0_18 Vdout0_18ck86 = 0 time = 870
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=870.05n

* CHECK dout0_19 Vdout0_19ck86 = 0 time = 870
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=870.05n

* CHECK dout0_20 Vdout0_20ck86 = 0 time = 870
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=870.05n

* CHECK dout0_21 Vdout0_21ck86 = 0 time = 870
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=870.05n

* CHECK dout0_22 Vdout0_22ck86 = 0 time = 870
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=870.05n

* CHECK dout0_23 Vdout0_23ck86 = 1.8 time = 870
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=870.05n

* CHECK dout0_24 Vdout0_24ck86 = 0 time = 870
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=870.05n

* CHECK dout0_25 Vdout0_25ck86 = 0 time = 870
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=870.05n

* CHECK dout0_26 Vdout0_26ck86 = 0 time = 870
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=870.05n

* CHECK dout0_27 Vdout0_27ck86 = 1.8 time = 870
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=870.05n

* CHECK dout0_28 Vdout0_28ck86 = 1.8 time = 870
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=870.05n

* CHECK dout0_29 Vdout0_29ck86 = 1.8 time = 870
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=870.05n

* CHECK dout0_30 Vdout0_30ck86 = 0 time = 870
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=870.05n

* CHECK dout0_31 Vdout0_31ck86 = 1.8 time = 870
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=870.05n

* CHECK dout0_32 Vdout0_32ck86 = 0 time = 870
.meas tran vdout0_32ck86 FIND v(dout0_32) AT=870.05n

* CHECK dout0_0 Vdout0_0ck88 = 1.8 time = 890
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=890.05n

* CHECK dout0_1 Vdout0_1ck88 = 0 time = 890
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=890.05n

* CHECK dout0_2 Vdout0_2ck88 = 1.8 time = 890
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=890.05n

* CHECK dout0_3 Vdout0_3ck88 = 1.8 time = 890
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=890.05n

* CHECK dout0_4 Vdout0_4ck88 = 0 time = 890
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=890.05n

* CHECK dout0_5 Vdout0_5ck88 = 0 time = 890
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=890.05n

* CHECK dout0_6 Vdout0_6ck88 = 1.8 time = 890
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=890.05n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 890
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=890.05n

* CHECK dout0_8 Vdout0_8ck88 = 1.8 time = 890
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=890.05n

* CHECK dout0_9 Vdout0_9ck88 = 0 time = 890
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=890.05n

* CHECK dout0_10 Vdout0_10ck88 = 1.8 time = 890
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=890.05n

* CHECK dout0_11 Vdout0_11ck88 = 1.8 time = 890
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=890.05n

* CHECK dout0_12 Vdout0_12ck88 = 0 time = 890
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=890.05n

* CHECK dout0_13 Vdout0_13ck88 = 0 time = 890
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=890.05n

* CHECK dout0_14 Vdout0_14ck88 = 0 time = 890
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=890.05n

* CHECK dout0_15 Vdout0_15ck88 = 0 time = 890
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=890.05n

* CHECK dout0_16 Vdout0_16ck88 = 0 time = 890
.meas tran vdout0_16ck88 FIND v(dout0_16) AT=890.05n

* CHECK dout0_17 Vdout0_17ck88 = 1.8 time = 890
.meas tran vdout0_17ck88 FIND v(dout0_17) AT=890.05n

* CHECK dout0_18 Vdout0_18ck88 = 0 time = 890
.meas tran vdout0_18ck88 FIND v(dout0_18) AT=890.05n

* CHECK dout0_19 Vdout0_19ck88 = 1.8 time = 890
.meas tran vdout0_19ck88 FIND v(dout0_19) AT=890.05n

* CHECK dout0_20 Vdout0_20ck88 = 0 time = 890
.meas tran vdout0_20ck88 FIND v(dout0_20) AT=890.05n

* CHECK dout0_21 Vdout0_21ck88 = 1.8 time = 890
.meas tran vdout0_21ck88 FIND v(dout0_21) AT=890.05n

* CHECK dout0_22 Vdout0_22ck88 = 1.8 time = 890
.meas tran vdout0_22ck88 FIND v(dout0_22) AT=890.05n

* CHECK dout0_23 Vdout0_23ck88 = 0 time = 890
.meas tran vdout0_23ck88 FIND v(dout0_23) AT=890.05n

* CHECK dout0_24 Vdout0_24ck88 = 1.8 time = 890
.meas tran vdout0_24ck88 FIND v(dout0_24) AT=890.05n

* CHECK dout0_25 Vdout0_25ck88 = 0 time = 890
.meas tran vdout0_25ck88 FIND v(dout0_25) AT=890.05n

* CHECK dout0_26 Vdout0_26ck88 = 1.8 time = 890
.meas tran vdout0_26ck88 FIND v(dout0_26) AT=890.05n

* CHECK dout0_27 Vdout0_27ck88 = 1.8 time = 890
.meas tran vdout0_27ck88 FIND v(dout0_27) AT=890.05n

* CHECK dout0_28 Vdout0_28ck88 = 1.8 time = 890
.meas tran vdout0_28ck88 FIND v(dout0_28) AT=890.05n

* CHECK dout0_29 Vdout0_29ck88 = 1.8 time = 890
.meas tran vdout0_29ck88 FIND v(dout0_29) AT=890.05n

* CHECK dout0_30 Vdout0_30ck88 = 1.8 time = 890
.meas tran vdout0_30ck88 FIND v(dout0_30) AT=890.05n

* CHECK dout0_31 Vdout0_31ck88 = 0 time = 890
.meas tran vdout0_31ck88 FIND v(dout0_31) AT=890.05n

* CHECK dout0_32 Vdout0_32ck88 = 0 time = 890
.meas tran vdout0_32ck88 FIND v(dout0_32) AT=890.05n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 920
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=920.05n

* CHECK dout0_1 Vdout0_1ck91 = 0 time = 920
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=920.05n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 920
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=920.05n

* CHECK dout0_3 Vdout0_3ck91 = 1.8 time = 920
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=920.05n

* CHECK dout0_4 Vdout0_4ck91 = 1.8 time = 920
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=920.05n

* CHECK dout0_5 Vdout0_5ck91 = 1.8 time = 920
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=920.05n

* CHECK dout0_6 Vdout0_6ck91 = 0 time = 920
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=920.05n

* CHECK dout0_7 Vdout0_7ck91 = 0 time = 920
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=920.05n

* CHECK dout0_8 Vdout0_8ck91 = 1.8 time = 920
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=920.05n

* CHECK dout0_9 Vdout0_9ck91 = 0 time = 920
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=920.05n

* CHECK dout0_10 Vdout0_10ck91 = 0 time = 920
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=920.05n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 920
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=920.05n

* CHECK dout0_12 Vdout0_12ck91 = 0 time = 920
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=920.05n

* CHECK dout0_13 Vdout0_13ck91 = 0 time = 920
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=920.05n

* CHECK dout0_14 Vdout0_14ck91 = 0 time = 920
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=920.05n

* CHECK dout0_15 Vdout0_15ck91 = 1.8 time = 920
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=920.05n

* CHECK dout0_16 Vdout0_16ck91 = 1.8 time = 920
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=920.05n

* CHECK dout0_17 Vdout0_17ck91 = 0 time = 920
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=920.05n

* CHECK dout0_18 Vdout0_18ck91 = 1.8 time = 920
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=920.05n

* CHECK dout0_19 Vdout0_19ck91 = 1.8 time = 920
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=920.05n

* CHECK dout0_20 Vdout0_20ck91 = 0 time = 920
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=920.05n

* CHECK dout0_21 Vdout0_21ck91 = 0 time = 920
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=920.05n

* CHECK dout0_22 Vdout0_22ck91 = 0 time = 920
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=920.05n

* CHECK dout0_23 Vdout0_23ck91 = 0 time = 920
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=920.05n

* CHECK dout0_24 Vdout0_24ck91 = 0 time = 920
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=920.05n

* CHECK dout0_25 Vdout0_25ck91 = 1.8 time = 920
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=920.05n

* CHECK dout0_26 Vdout0_26ck91 = 1.8 time = 920
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=920.05n

* CHECK dout0_27 Vdout0_27ck91 = 1.8 time = 920
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=920.05n

* CHECK dout0_28 Vdout0_28ck91 = 0 time = 920
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=920.05n

* CHECK dout0_29 Vdout0_29ck91 = 0 time = 920
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=920.05n

* CHECK dout0_30 Vdout0_30ck91 = 0 time = 920
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=920.05n

* CHECK dout0_31 Vdout0_31ck91 = 1.8 time = 920
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=920.05n

* CHECK dout0_32 Vdout0_32ck91 = 0 time = 920
.meas tran vdout0_32ck91 FIND v(dout0_32) AT=920.05n

* CHECK dout0_0 Vdout0_0ck93 = 1.8 time = 940
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=940.05n

* CHECK dout0_1 Vdout0_1ck93 = 1.8 time = 940
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=940.05n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 940
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=940.05n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 940
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=940.05n

* CHECK dout0_4 Vdout0_4ck93 = 1.8 time = 940
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=940.05n

* CHECK dout0_5 Vdout0_5ck93 = 1.8 time = 940
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=940.05n

* CHECK dout0_6 Vdout0_6ck93 = 1.8 time = 940
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=940.05n

* CHECK dout0_7 Vdout0_7ck93 = 1.8 time = 940
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=940.05n

* CHECK dout0_8 Vdout0_8ck93 = 1.8 time = 940
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=940.05n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 940
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=940.05n

* CHECK dout0_10 Vdout0_10ck93 = 1.8 time = 940
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=940.05n

* CHECK dout0_11 Vdout0_11ck93 = 0 time = 940
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=940.05n

* CHECK dout0_12 Vdout0_12ck93 = 1.8 time = 940
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=940.05n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 940
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=940.05n

* CHECK dout0_14 Vdout0_14ck93 = 1.8 time = 940
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=940.05n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 940
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=940.05n

* CHECK dout0_16 Vdout0_16ck93 = 0 time = 940
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=940.05n

* CHECK dout0_17 Vdout0_17ck93 = 1.8 time = 940
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=940.05n

* CHECK dout0_18 Vdout0_18ck93 = 1.8 time = 940
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=940.05n

* CHECK dout0_19 Vdout0_19ck93 = 1.8 time = 940
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=940.05n

* CHECK dout0_20 Vdout0_20ck93 = 1.8 time = 940
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=940.05n

* CHECK dout0_21 Vdout0_21ck93 = 1.8 time = 940
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=940.05n

* CHECK dout0_22 Vdout0_22ck93 = 1.8 time = 940
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=940.05n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 940
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=940.05n

* CHECK dout0_24 Vdout0_24ck93 = 0 time = 940
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=940.05n

* CHECK dout0_25 Vdout0_25ck93 = 0 time = 940
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=940.05n

* CHECK dout0_26 Vdout0_26ck93 = 1.8 time = 940
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=940.05n

* CHECK dout0_27 Vdout0_27ck93 = 1.8 time = 940
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=940.05n

* CHECK dout0_28 Vdout0_28ck93 = 1.8 time = 940
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=940.05n

* CHECK dout0_29 Vdout0_29ck93 = 0 time = 940
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=940.05n

* CHECK dout0_30 Vdout0_30ck93 = 1.8 time = 940
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=940.05n

* CHECK dout0_31 Vdout0_31ck93 = 0 time = 940
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=940.05n

* CHECK dout0_32 Vdout0_32ck93 = 0 time = 940
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=940.05n

* CHECK dout0_0 Vdout0_0ck94 = 1.8 time = 950
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=950.05n

* CHECK dout0_1 Vdout0_1ck94 = 1.8 time = 950
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=950.05n

* CHECK dout0_2 Vdout0_2ck94 = 0 time = 950
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=950.05n

* CHECK dout0_3 Vdout0_3ck94 = 1.8 time = 950
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=950.05n

* CHECK dout0_4 Vdout0_4ck94 = 1.8 time = 950
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=950.05n

* CHECK dout0_5 Vdout0_5ck94 = 1.8 time = 950
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=950.05n

* CHECK dout0_6 Vdout0_6ck94 = 1.8 time = 950
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=950.05n

* CHECK dout0_7 Vdout0_7ck94 = 0 time = 950
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=950.05n

* CHECK dout0_8 Vdout0_8ck94 = 0 time = 950
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=950.05n

* CHECK dout0_9 Vdout0_9ck94 = 0 time = 950
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=950.05n

* CHECK dout0_10 Vdout0_10ck94 = 1.8 time = 950
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=950.05n

* CHECK dout0_11 Vdout0_11ck94 = 0 time = 950
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=950.05n

* CHECK dout0_12 Vdout0_12ck94 = 1.8 time = 950
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=950.05n

* CHECK dout0_13 Vdout0_13ck94 = 1.8 time = 950
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=950.05n

* CHECK dout0_14 Vdout0_14ck94 = 1.8 time = 950
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=950.05n

* CHECK dout0_15 Vdout0_15ck94 = 0 time = 950
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=950.05n

* CHECK dout0_16 Vdout0_16ck94 = 0 time = 950
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=950.05n

* CHECK dout0_17 Vdout0_17ck94 = 0 time = 950
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=950.05n

* CHECK dout0_18 Vdout0_18ck94 = 0 time = 950
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=950.05n

* CHECK dout0_19 Vdout0_19ck94 = 0 time = 950
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=950.05n

* CHECK dout0_20 Vdout0_20ck94 = 0 time = 950
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=950.05n

* CHECK dout0_21 Vdout0_21ck94 = 1.8 time = 950
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=950.05n

* CHECK dout0_22 Vdout0_22ck94 = 1.8 time = 950
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=950.05n

* CHECK dout0_23 Vdout0_23ck94 = 1.8 time = 950
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=950.05n

* CHECK dout0_24 Vdout0_24ck94 = 1.8 time = 950
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=950.05n

* CHECK dout0_25 Vdout0_25ck94 = 0 time = 950
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=950.05n

* CHECK dout0_26 Vdout0_26ck94 = 0 time = 950
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=950.05n

* CHECK dout0_27 Vdout0_27ck94 = 0 time = 950
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=950.05n

* CHECK dout0_28 Vdout0_28ck94 = 1.8 time = 950
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=950.05n

* CHECK dout0_29 Vdout0_29ck94 = 1.8 time = 950
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=950.05n

* CHECK dout0_30 Vdout0_30ck94 = 1.8 time = 950
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=950.05n

* CHECK dout0_31 Vdout0_31ck94 = 1.8 time = 950
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=950.05n

* CHECK dout0_32 Vdout0_32ck94 = 0 time = 950
.meas tran vdout0_32ck94 FIND v(dout0_32) AT=950.05n

* CHECK dout0_0 Vdout0_0ck96 = 1.8 time = 970
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=970.05n

* CHECK dout0_1 Vdout0_1ck96 = 1.8 time = 970
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=970.05n

* CHECK dout0_2 Vdout0_2ck96 = 1.8 time = 970
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=970.05n

* CHECK dout0_3 Vdout0_3ck96 = 1.8 time = 970
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=970.05n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 970
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=970.05n

* CHECK dout0_5 Vdout0_5ck96 = 1.8 time = 970
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=970.05n

* CHECK dout0_6 Vdout0_6ck96 = 1.8 time = 970
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=970.05n

* CHECK dout0_7 Vdout0_7ck96 = 1.8 time = 970
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=970.05n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 970
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=970.05n

* CHECK dout0_9 Vdout0_9ck96 = 1.8 time = 970
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=970.05n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 970
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=970.05n

* CHECK dout0_11 Vdout0_11ck96 = 1.8 time = 970
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=970.05n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 970
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=970.05n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 970
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=970.05n

* CHECK dout0_14 Vdout0_14ck96 = 0 time = 970
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=970.05n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 970
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=970.05n

* CHECK dout0_16 Vdout0_16ck96 = 0 time = 970
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=970.05n

* CHECK dout0_17 Vdout0_17ck96 = 1.8 time = 970
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=970.05n

* CHECK dout0_18 Vdout0_18ck96 = 0 time = 970
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=970.05n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 970
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=970.05n

* CHECK dout0_20 Vdout0_20ck96 = 1.8 time = 970
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=970.05n

* CHECK dout0_21 Vdout0_21ck96 = 1.8 time = 970
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=970.05n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 970
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=970.05n

* CHECK dout0_23 Vdout0_23ck96 = 0 time = 970
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=970.05n

* CHECK dout0_24 Vdout0_24ck96 = 1.8 time = 970
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=970.05n

* CHECK dout0_25 Vdout0_25ck96 = 0 time = 970
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=970.05n

* CHECK dout0_26 Vdout0_26ck96 = 1.8 time = 970
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=970.05n

* CHECK dout0_27 Vdout0_27ck96 = 0 time = 970
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=970.05n

* CHECK dout0_28 Vdout0_28ck96 = 1.8 time = 970
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=970.05n

* CHECK dout0_29 Vdout0_29ck96 = 1.8 time = 970
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=970.05n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 970
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=970.05n

* CHECK dout0_31 Vdout0_31ck96 = 0 time = 970
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=970.05n

* CHECK dout0_32 Vdout0_32ck96 = 0 time = 970
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=970.05n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 1000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=1000.05n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 1000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=1000.05n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 1000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=1000.05n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 1000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=1000.05n

* CHECK dout0_4 Vdout0_4ck99 = 1.8 time = 1000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=1000.05n

* CHECK dout0_5 Vdout0_5ck99 = 1.8 time = 1000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=1000.05n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 1000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=1000.05n

* CHECK dout0_7 Vdout0_7ck99 = 1.8 time = 1000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=1000.05n

* CHECK dout0_8 Vdout0_8ck99 = 1.8 time = 1000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=1000.05n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 1000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=1000.05n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 1000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=1000.05n

* CHECK dout0_11 Vdout0_11ck99 = 1.8 time = 1000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=1000.05n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 1000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=1000.05n

* CHECK dout0_13 Vdout0_13ck99 = 0 time = 1000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=1000.05n

* CHECK dout0_14 Vdout0_14ck99 = 0 time = 1000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=1000.05n

* CHECK dout0_15 Vdout0_15ck99 = 0 time = 1000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=1000.05n

* CHECK dout0_16 Vdout0_16ck99 = 0 time = 1000
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=1000.05n

* CHECK dout0_17 Vdout0_17ck99 = 0 time = 1000
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=1000.05n

* CHECK dout0_18 Vdout0_18ck99 = 0 time = 1000
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=1000.05n

* CHECK dout0_19 Vdout0_19ck99 = 0 time = 1000
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=1000.05n

* CHECK dout0_20 Vdout0_20ck99 = 1.8 time = 1000
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=1000.05n

* CHECK dout0_21 Vdout0_21ck99 = 0 time = 1000
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=1000.05n

* CHECK dout0_22 Vdout0_22ck99 = 0 time = 1000
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=1000.05n

* CHECK dout0_23 Vdout0_23ck99 = 0 time = 1000
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=1000.05n

* CHECK dout0_24 Vdout0_24ck99 = 1.8 time = 1000
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=1000.05n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 1000
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=1000.05n

* CHECK dout0_26 Vdout0_26ck99 = 1.8 time = 1000
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=1000.05n

* CHECK dout0_27 Vdout0_27ck99 = 0 time = 1000
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=1000.05n

* CHECK dout0_28 Vdout0_28ck99 = 0 time = 1000
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=1000.05n

* CHECK dout0_29 Vdout0_29ck99 = 0 time = 1000
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=1000.05n

* CHECK dout0_30 Vdout0_30ck99 = 1.8 time = 1000
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=1000.05n

* CHECK dout0_31 Vdout0_31ck99 = 1.8 time = 1000
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=1000.05n

* CHECK dout0_32 Vdout0_32ck99 = 0 time = 1000
.meas tran vdout0_32ck99 FIND v(dout0_32) AT=1000.05n

* CHECK dout0_0 Vdout0_0ck101 = 1.8 time = 1020
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=1020.05n

* CHECK dout0_1 Vdout0_1ck101 = 1.8 time = 1020
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=1020.05n

* CHECK dout0_2 Vdout0_2ck101 = 1.8 time = 1020
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=1020.05n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 1020
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=1020.05n

* CHECK dout0_4 Vdout0_4ck101 = 1.8 time = 1020
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=1020.05n

* CHECK dout0_5 Vdout0_5ck101 = 1.8 time = 1020
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=1020.05n

* CHECK dout0_6 Vdout0_6ck101 = 1.8 time = 1020
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=1020.05n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 1020
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=1020.05n

* CHECK dout0_8 Vdout0_8ck101 = 1.8 time = 1020
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=1020.05n

* CHECK dout0_9 Vdout0_9ck101 = 0 time = 1020
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=1020.05n

* CHECK dout0_10 Vdout0_10ck101 = 1.8 time = 1020
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=1020.05n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 1020
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=1020.05n

* CHECK dout0_12 Vdout0_12ck101 = 1.8 time = 1020
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=1020.05n

* CHECK dout0_13 Vdout0_13ck101 = 0 time = 1020
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=1020.05n

* CHECK dout0_14 Vdout0_14ck101 = 1.8 time = 1020
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=1020.05n

* CHECK dout0_15 Vdout0_15ck101 = 1.8 time = 1020
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=1020.05n

* CHECK dout0_16 Vdout0_16ck101 = 0 time = 1020
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=1020.05n

* CHECK dout0_17 Vdout0_17ck101 = 1.8 time = 1020
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=1020.05n

* CHECK dout0_18 Vdout0_18ck101 = 1.8 time = 1020
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=1020.05n

* CHECK dout0_19 Vdout0_19ck101 = 1.8 time = 1020
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=1020.05n

* CHECK dout0_20 Vdout0_20ck101 = 1.8 time = 1020
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=1020.05n

* CHECK dout0_21 Vdout0_21ck101 = 1.8 time = 1020
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=1020.05n

* CHECK dout0_22 Vdout0_22ck101 = 1.8 time = 1020
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=1020.05n

* CHECK dout0_23 Vdout0_23ck101 = 0 time = 1020
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=1020.05n

* CHECK dout0_24 Vdout0_24ck101 = 0 time = 1020
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=1020.05n

* CHECK dout0_25 Vdout0_25ck101 = 0 time = 1020
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=1020.05n

* CHECK dout0_26 Vdout0_26ck101 = 1.8 time = 1020
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=1020.05n

* CHECK dout0_27 Vdout0_27ck101 = 1.8 time = 1020
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=1020.05n

* CHECK dout0_28 Vdout0_28ck101 = 1.8 time = 1020
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=1020.05n

* CHECK dout0_29 Vdout0_29ck101 = 0 time = 1020
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=1020.05n

* CHECK dout0_30 Vdout0_30ck101 = 1.8 time = 1020
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=1020.05n

* CHECK dout0_31 Vdout0_31ck101 = 0 time = 1020
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=1020.05n

* CHECK dout0_32 Vdout0_32ck101 = 0 time = 1020
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=1020.05n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 1030
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=1030.05n

* CHECK dout0_1 Vdout0_1ck102 = 1.8 time = 1030
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=1030.05n

* CHECK dout0_2 Vdout0_2ck102 = 1.8 time = 1030
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=1030.05n

* CHECK dout0_3 Vdout0_3ck102 = 1.8 time = 1030
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=1030.05n

* CHECK dout0_4 Vdout0_4ck102 = 0 time = 1030
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=1030.05n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 1030
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=1030.05n

* CHECK dout0_6 Vdout0_6ck102 = 1.8 time = 1030
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=1030.05n

* CHECK dout0_7 Vdout0_7ck102 = 1.8 time = 1030
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=1030.05n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 1030
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=1030.05n

* CHECK dout0_9 Vdout0_9ck102 = 0 time = 1030
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=1030.05n

* CHECK dout0_10 Vdout0_10ck102 = 1.8 time = 1030
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=1030.05n

* CHECK dout0_11 Vdout0_11ck102 = 0 time = 1030
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=1030.05n

* CHECK dout0_12 Vdout0_12ck102 = 1.8 time = 1030
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=1030.05n

* CHECK dout0_13 Vdout0_13ck102 = 1.8 time = 1030
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=1030.05n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 1030
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=1030.05n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 1030
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=1030.05n

* CHECK dout0_16 Vdout0_16ck102 = 1.8 time = 1030
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=1030.05n

* CHECK dout0_17 Vdout0_17ck102 = 1.8 time = 1030
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=1030.05n

* CHECK dout0_18 Vdout0_18ck102 = 1.8 time = 1030
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=1030.05n

* CHECK dout0_19 Vdout0_19ck102 = 0 time = 1030
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=1030.05n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 1030
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=1030.05n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 1030
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=1030.05n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 1030
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=1030.05n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 1030
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=1030.05n

* CHECK dout0_24 Vdout0_24ck102 = 1.8 time = 1030
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=1030.05n

* CHECK dout0_25 Vdout0_25ck102 = 0 time = 1030
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=1030.05n

* CHECK dout0_26 Vdout0_26ck102 = 0 time = 1030
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=1030.05n

* CHECK dout0_27 Vdout0_27ck102 = 1.8 time = 1030
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=1030.05n

* CHECK dout0_28 Vdout0_28ck102 = 1.8 time = 1030
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=1030.05n

* CHECK dout0_29 Vdout0_29ck102 = 1.8 time = 1030
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=1030.05n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 1030
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=1030.05n

* CHECK dout0_31 Vdout0_31ck102 = 1.8 time = 1030
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=1030.05n

* CHECK dout0_32 Vdout0_32ck102 = 0 time = 1030
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=1030.05n

* CHECK dout0_0 Vdout0_0ck103 = 1.8 time = 1040
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=1040.05n

* CHECK dout0_1 Vdout0_1ck103 = 0 time = 1040
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=1040.05n

* CHECK dout0_2 Vdout0_2ck103 = 0 time = 1040
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=1040.05n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 1040
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=1040.05n

* CHECK dout0_4 Vdout0_4ck103 = 1.8 time = 1040
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=1040.05n

* CHECK dout0_5 Vdout0_5ck103 = 1.8 time = 1040
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=1040.05n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 1040
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=1040.05n

* CHECK dout0_7 Vdout0_7ck103 = 1.8 time = 1040
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=1040.05n

* CHECK dout0_8 Vdout0_8ck103 = 1.8 time = 1040
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=1040.05n

* CHECK dout0_9 Vdout0_9ck103 = 0 time = 1040
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=1040.05n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 1040
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=1040.05n

* CHECK dout0_11 Vdout0_11ck103 = 1.8 time = 1040
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=1040.05n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 1040
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=1040.05n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 1040
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=1040.05n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 1040
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=1040.05n

* CHECK dout0_15 Vdout0_15ck103 = 0 time = 1040
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=1040.05n

* CHECK dout0_16 Vdout0_16ck103 = 0 time = 1040
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=1040.05n

* CHECK dout0_17 Vdout0_17ck103 = 0 time = 1040
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=1040.05n

* CHECK dout0_18 Vdout0_18ck103 = 0 time = 1040
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=1040.05n

* CHECK dout0_19 Vdout0_19ck103 = 0 time = 1040
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=1040.05n

* CHECK dout0_20 Vdout0_20ck103 = 1.8 time = 1040
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=1040.05n

* CHECK dout0_21 Vdout0_21ck103 = 0 time = 1040
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=1040.05n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 1040
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=1040.05n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 1040
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=1040.05n

* CHECK dout0_24 Vdout0_24ck103 = 1.8 time = 1040
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=1040.05n

* CHECK dout0_25 Vdout0_25ck103 = 0 time = 1040
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=1040.05n

* CHECK dout0_26 Vdout0_26ck103 = 1.8 time = 1040
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=1040.05n

* CHECK dout0_27 Vdout0_27ck103 = 0 time = 1040
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=1040.05n

* CHECK dout0_28 Vdout0_28ck103 = 0 time = 1040
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=1040.05n

* CHECK dout0_29 Vdout0_29ck103 = 0 time = 1040
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=1040.05n

* CHECK dout0_30 Vdout0_30ck103 = 1.8 time = 1040
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=1040.05n

* CHECK dout0_31 Vdout0_31ck103 = 1.8 time = 1040
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=1040.05n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 1040
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=1040.05n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 1080
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=1080.05n

* CHECK dout0_1 Vdout0_1ck107 = 1.8 time = 1080
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=1080.05n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 1080
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=1080.05n

* CHECK dout0_3 Vdout0_3ck107 = 1.8 time = 1080
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=1080.05n

* CHECK dout0_4 Vdout0_4ck107 = 1.8 time = 1080
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=1080.05n

* CHECK dout0_5 Vdout0_5ck107 = 1.8 time = 1080
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=1080.05n

* CHECK dout0_6 Vdout0_6ck107 = 1.8 time = 1080
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=1080.05n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 1080
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=1080.05n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 1080
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=1080.05n

* CHECK dout0_9 Vdout0_9ck107 = 0 time = 1080
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=1080.05n

* CHECK dout0_10 Vdout0_10ck107 = 1.8 time = 1080
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=1080.05n

* CHECK dout0_11 Vdout0_11ck107 = 0 time = 1080
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=1080.05n

* CHECK dout0_12 Vdout0_12ck107 = 1.8 time = 1080
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=1080.05n

* CHECK dout0_13 Vdout0_13ck107 = 1.8 time = 1080
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=1080.05n

* CHECK dout0_14 Vdout0_14ck107 = 1.8 time = 1080
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=1080.05n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 1080
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=1080.05n

* CHECK dout0_16 Vdout0_16ck107 = 0 time = 1080
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=1080.05n

* CHECK dout0_17 Vdout0_17ck107 = 0 time = 1080
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=1080.05n

* CHECK dout0_18 Vdout0_18ck107 = 0 time = 1080
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=1080.05n

* CHECK dout0_19 Vdout0_19ck107 = 0 time = 1080
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=1080.05n

* CHECK dout0_20 Vdout0_20ck107 = 0 time = 1080
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=1080.05n

* CHECK dout0_21 Vdout0_21ck107 = 1.8 time = 1080
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=1080.05n

* CHECK dout0_22 Vdout0_22ck107 = 1.8 time = 1080
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=1080.05n

* CHECK dout0_23 Vdout0_23ck107 = 1.8 time = 1080
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=1080.05n

* CHECK dout0_24 Vdout0_24ck107 = 1.8 time = 1080
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=1080.05n

* CHECK dout0_25 Vdout0_25ck107 = 0 time = 1080
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=1080.05n

* CHECK dout0_26 Vdout0_26ck107 = 0 time = 1080
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=1080.05n

* CHECK dout0_27 Vdout0_27ck107 = 0 time = 1080
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=1080.05n

* CHECK dout0_28 Vdout0_28ck107 = 1.8 time = 1080
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=1080.05n

* CHECK dout0_29 Vdout0_29ck107 = 1.8 time = 1080
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=1080.05n

* CHECK dout0_30 Vdout0_30ck107 = 1.8 time = 1080
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=1080.05n

* CHECK dout0_31 Vdout0_31ck107 = 1.8 time = 1080
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=1080.05n

* CHECK dout0_32 Vdout0_32ck107 = 0 time = 1080
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=1080.05n

* CHECK dout0_0 Vdout0_0ck109 = 1.8 time = 1100
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=1100.05n

* CHECK dout0_1 Vdout0_1ck109 = 1.8 time = 1100
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=1100.05n

* CHECK dout0_2 Vdout0_2ck109 = 1.8 time = 1100
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=1100.05n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 1100
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=1100.05n

* CHECK dout0_4 Vdout0_4ck109 = 1.8 time = 1100
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=1100.05n

* CHECK dout0_5 Vdout0_5ck109 = 1.8 time = 1100
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=1100.05n

* CHECK dout0_6 Vdout0_6ck109 = 1.8 time = 1100
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=1100.05n

* CHECK dout0_7 Vdout0_7ck109 = 1.8 time = 1100
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=1100.05n

* CHECK dout0_8 Vdout0_8ck109 = 1.8 time = 1100
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=1100.05n

* CHECK dout0_9 Vdout0_9ck109 = 0 time = 1100
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=1100.05n

* CHECK dout0_10 Vdout0_10ck109 = 1.8 time = 1100
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=1100.05n

* CHECK dout0_11 Vdout0_11ck109 = 0 time = 1100
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=1100.05n

* CHECK dout0_12 Vdout0_12ck109 = 1.8 time = 1100
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=1100.05n

* CHECK dout0_13 Vdout0_13ck109 = 0 time = 1100
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=1100.05n

* CHECK dout0_14 Vdout0_14ck109 = 1.8 time = 1100
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=1100.05n

* CHECK dout0_15 Vdout0_15ck109 = 1.8 time = 1100
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=1100.05n

* CHECK dout0_16 Vdout0_16ck109 = 0 time = 1100
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=1100.05n

* CHECK dout0_17 Vdout0_17ck109 = 1.8 time = 1100
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=1100.05n

* CHECK dout0_18 Vdout0_18ck109 = 1.8 time = 1100
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=1100.05n

* CHECK dout0_19 Vdout0_19ck109 = 1.8 time = 1100
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=1100.05n

* CHECK dout0_20 Vdout0_20ck109 = 1.8 time = 1100
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=1100.05n

* CHECK dout0_21 Vdout0_21ck109 = 1.8 time = 1100
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=1100.05n

* CHECK dout0_22 Vdout0_22ck109 = 1.8 time = 1100
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=1100.05n

* CHECK dout0_23 Vdout0_23ck109 = 0 time = 1100
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=1100.05n

* CHECK dout0_24 Vdout0_24ck109 = 0 time = 1100
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=1100.05n

* CHECK dout0_25 Vdout0_25ck109 = 0 time = 1100
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=1100.05n

* CHECK dout0_26 Vdout0_26ck109 = 1.8 time = 1100
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=1100.05n

* CHECK dout0_27 Vdout0_27ck109 = 1.8 time = 1100
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=1100.05n

* CHECK dout0_28 Vdout0_28ck109 = 1.8 time = 1100
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=1100.05n

* CHECK dout0_29 Vdout0_29ck109 = 0 time = 1100
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=1100.05n

* CHECK dout0_30 Vdout0_30ck109 = 1.8 time = 1100
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=1100.05n

* CHECK dout0_31 Vdout0_31ck109 = 0 time = 1100
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=1100.05n

* CHECK dout0_32 Vdout0_32ck109 = 0 time = 1100
.meas tran vdout0_32ck109 FIND v(dout0_32) AT=1100.05n

* CHECK dout0_0 Vdout0_0ck114 = 1.8 time = 1150
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=1150.05n

* CHECK dout0_1 Vdout0_1ck114 = 1.8 time = 1150
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=1150.05n

* CHECK dout0_2 Vdout0_2ck114 = 1.8 time = 1150
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=1150.05n

* CHECK dout0_3 Vdout0_3ck114 = 0 time = 1150
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=1150.05n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 1150
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=1150.05n

* CHECK dout0_5 Vdout0_5ck114 = 1.8 time = 1150
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=1150.05n

* CHECK dout0_6 Vdout0_6ck114 = 1.8 time = 1150
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=1150.05n

* CHECK dout0_7 Vdout0_7ck114 = 1.8 time = 1150
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=1150.05n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 1150
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=1150.05n

* CHECK dout0_9 Vdout0_9ck114 = 1.8 time = 1150
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=1150.05n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 1150
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=1150.05n

* CHECK dout0_11 Vdout0_11ck114 = 1.8 time = 1150
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=1150.05n

* CHECK dout0_12 Vdout0_12ck114 = 0 time = 1150
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=1150.05n

* CHECK dout0_13 Vdout0_13ck114 = 1.8 time = 1150
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=1150.05n

* CHECK dout0_14 Vdout0_14ck114 = 0 time = 1150
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=1150.05n

* CHECK dout0_15 Vdout0_15ck114 = 0 time = 1150
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=1150.05n

* CHECK dout0_16 Vdout0_16ck114 = 1.8 time = 1150
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=1150.05n

* CHECK dout0_17 Vdout0_17ck114 = 0 time = 1150
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=1150.05n

* CHECK dout0_18 Vdout0_18ck114 = 0 time = 1150
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=1150.05n

* CHECK dout0_19 Vdout0_19ck114 = 0 time = 1150
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=1150.05n

* CHECK dout0_20 Vdout0_20ck114 = 1.8 time = 1150
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=1150.05n

* CHECK dout0_21 Vdout0_21ck114 = 0 time = 1150
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=1150.05n

* CHECK dout0_22 Vdout0_22ck114 = 0 time = 1150
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=1150.05n

* CHECK dout0_23 Vdout0_23ck114 = 1.8 time = 1150
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=1150.05n

* CHECK dout0_24 Vdout0_24ck114 = 0 time = 1150
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=1150.05n

* CHECK dout0_25 Vdout0_25ck114 = 0 time = 1150
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=1150.05n

* CHECK dout0_26 Vdout0_26ck114 = 0 time = 1150
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=1150.05n

* CHECK dout0_27 Vdout0_27ck114 = 0 time = 1150
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=1150.05n

* CHECK dout0_28 Vdout0_28ck114 = 0 time = 1150
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=1150.05n

* CHECK dout0_29 Vdout0_29ck114 = 0 time = 1150
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=1150.05n

* CHECK dout0_30 Vdout0_30ck114 = 1.8 time = 1150
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=1150.05n

* CHECK dout0_31 Vdout0_31ck114 = 0 time = 1150
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=1150.05n

* CHECK dout0_32 Vdout0_32ck114 = 0 time = 1150
.meas tran vdout0_32ck114 FIND v(dout0_32) AT=1150.05n

* CHECK dout0_0 Vdout0_0ck116 = 1.8 time = 1170
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=1170.05n

* CHECK dout0_1 Vdout0_1ck116 = 1.8 time = 1170
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=1170.05n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 1170
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=1170.05n

* CHECK dout0_3 Vdout0_3ck116 = 1.8 time = 1170
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=1170.05n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 1170
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=1170.05n

* CHECK dout0_5 Vdout0_5ck116 = 1.8 time = 1170
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=1170.05n

* CHECK dout0_6 Vdout0_6ck116 = 1.8 time = 1170
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=1170.05n

* CHECK dout0_7 Vdout0_7ck116 = 1.8 time = 1170
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=1170.05n

* CHECK dout0_8 Vdout0_8ck116 = 1.8 time = 1170
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=1170.05n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 1170
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=1170.05n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 1170
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=1170.05n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 1170
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=1170.05n

* CHECK dout0_12 Vdout0_12ck116 = 1.8 time = 1170
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=1170.05n

* CHECK dout0_13 Vdout0_13ck116 = 1.8 time = 1170
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=1170.05n

* CHECK dout0_14 Vdout0_14ck116 = 1.8 time = 1170
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=1170.05n

* CHECK dout0_15 Vdout0_15ck116 = 0 time = 1170
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=1170.05n

* CHECK dout0_16 Vdout0_16ck116 = 0 time = 1170
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=1170.05n

* CHECK dout0_17 Vdout0_17ck116 = 0 time = 1170
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=1170.05n

* CHECK dout0_18 Vdout0_18ck116 = 1.8 time = 1170
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=1170.05n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 1170
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=1170.05n

* CHECK dout0_20 Vdout0_20ck116 = 1.8 time = 1170
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=1170.05n

* CHECK dout0_21 Vdout0_21ck116 = 1.8 time = 1170
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=1170.05n

* CHECK dout0_22 Vdout0_22ck116 = 1.8 time = 1170
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=1170.05n

* CHECK dout0_23 Vdout0_23ck116 = 1.8 time = 1170
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=1170.05n

* CHECK dout0_24 Vdout0_24ck116 = 0 time = 1170
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=1170.05n

* CHECK dout0_25 Vdout0_25ck116 = 0 time = 1170
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=1170.05n

* CHECK dout0_26 Vdout0_26ck116 = 1.8 time = 1170
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=1170.05n

* CHECK dout0_27 Vdout0_27ck116 = 1.8 time = 1170
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=1170.05n

* CHECK dout0_28 Vdout0_28ck116 = 0 time = 1170
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=1170.05n

* CHECK dout0_29 Vdout0_29ck116 = 0 time = 1170
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=1170.05n

* CHECK dout0_30 Vdout0_30ck116 = 1.8 time = 1170
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=1170.05n

* CHECK dout0_31 Vdout0_31ck116 = 1.8 time = 1170
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=1170.05n

* CHECK dout0_32 Vdout0_32ck116 = 0 time = 1170
.meas tran vdout0_32ck116 FIND v(dout0_32) AT=1170.05n

* CHECK dout0_0 Vdout0_0ck117 = 1.8 time = 1180
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=1180.05n

* CHECK dout0_1 Vdout0_1ck117 = 1.8 time = 1180
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=1180.05n

* CHECK dout0_2 Vdout0_2ck117 = 1.8 time = 1180
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=1180.05n

* CHECK dout0_3 Vdout0_3ck117 = 0 time = 1180
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=1180.05n

* CHECK dout0_4 Vdout0_4ck117 = 1.8 time = 1180
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=1180.05n

* CHECK dout0_5 Vdout0_5ck117 = 1.8 time = 1180
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=1180.05n

* CHECK dout0_6 Vdout0_6ck117 = 1.8 time = 1180
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=1180.05n

* CHECK dout0_7 Vdout0_7ck117 = 1.8 time = 1180
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=1180.05n

* CHECK dout0_8 Vdout0_8ck117 = 1.8 time = 1180
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=1180.05n

* CHECK dout0_9 Vdout0_9ck117 = 0 time = 1180
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=1180.05n

* CHECK dout0_10 Vdout0_10ck117 = 1.8 time = 1180
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=1180.05n

* CHECK dout0_11 Vdout0_11ck117 = 0 time = 1180
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=1180.05n

* CHECK dout0_12 Vdout0_12ck117 = 1.8 time = 1180
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=1180.05n

* CHECK dout0_13 Vdout0_13ck117 = 0 time = 1180
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=1180.05n

* CHECK dout0_14 Vdout0_14ck117 = 1.8 time = 1180
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=1180.05n

* CHECK dout0_15 Vdout0_15ck117 = 1.8 time = 1180
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=1180.05n

* CHECK dout0_16 Vdout0_16ck117 = 0 time = 1180
.meas tran vdout0_16ck117 FIND v(dout0_16) AT=1180.05n

* CHECK dout0_17 Vdout0_17ck117 = 1.8 time = 1180
.meas tran vdout0_17ck117 FIND v(dout0_17) AT=1180.05n

* CHECK dout0_18 Vdout0_18ck117 = 1.8 time = 1180
.meas tran vdout0_18ck117 FIND v(dout0_18) AT=1180.05n

* CHECK dout0_19 Vdout0_19ck117 = 1.8 time = 1180
.meas tran vdout0_19ck117 FIND v(dout0_19) AT=1180.05n

* CHECK dout0_20 Vdout0_20ck117 = 1.8 time = 1180
.meas tran vdout0_20ck117 FIND v(dout0_20) AT=1180.05n

* CHECK dout0_21 Vdout0_21ck117 = 1.8 time = 1180
.meas tran vdout0_21ck117 FIND v(dout0_21) AT=1180.05n

* CHECK dout0_22 Vdout0_22ck117 = 1.8 time = 1180
.meas tran vdout0_22ck117 FIND v(dout0_22) AT=1180.05n

* CHECK dout0_23 Vdout0_23ck117 = 0 time = 1180
.meas tran vdout0_23ck117 FIND v(dout0_23) AT=1180.05n

* CHECK dout0_24 Vdout0_24ck117 = 0 time = 1180
.meas tran vdout0_24ck117 FIND v(dout0_24) AT=1180.05n

* CHECK dout0_25 Vdout0_25ck117 = 0 time = 1180
.meas tran vdout0_25ck117 FIND v(dout0_25) AT=1180.05n

* CHECK dout0_26 Vdout0_26ck117 = 1.8 time = 1180
.meas tran vdout0_26ck117 FIND v(dout0_26) AT=1180.05n

* CHECK dout0_27 Vdout0_27ck117 = 1.8 time = 1180
.meas tran vdout0_27ck117 FIND v(dout0_27) AT=1180.05n

* CHECK dout0_28 Vdout0_28ck117 = 1.8 time = 1180
.meas tran vdout0_28ck117 FIND v(dout0_28) AT=1180.05n

* CHECK dout0_29 Vdout0_29ck117 = 0 time = 1180
.meas tran vdout0_29ck117 FIND v(dout0_29) AT=1180.05n

* CHECK dout0_30 Vdout0_30ck117 = 1.8 time = 1180
.meas tran vdout0_30ck117 FIND v(dout0_30) AT=1180.05n

* CHECK dout0_31 Vdout0_31ck117 = 0 time = 1180
.meas tran vdout0_31ck117 FIND v(dout0_31) AT=1180.05n

* CHECK dout0_32 Vdout0_32ck117 = 0 time = 1180
.meas tran vdout0_32ck117 FIND v(dout0_32) AT=1180.05n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 1190
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=1190.05n

* CHECK dout0_1 Vdout0_1ck118 = 1.8 time = 1190
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=1190.05n

* CHECK dout0_2 Vdout0_2ck118 = 1.8 time = 1190
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=1190.05n

* CHECK dout0_3 Vdout0_3ck118 = 1.8 time = 1190
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=1190.05n

* CHECK dout0_4 Vdout0_4ck118 = 1.8 time = 1190
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=1190.05n

* CHECK dout0_5 Vdout0_5ck118 = 1.8 time = 1190
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=1190.05n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 1190
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=1190.05n

* CHECK dout0_7 Vdout0_7ck118 = 1.8 time = 1190
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=1190.05n

* CHECK dout0_8 Vdout0_8ck118 = 0 time = 1190
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=1190.05n

* CHECK dout0_9 Vdout0_9ck118 = 1.8 time = 1190
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=1190.05n

* CHECK dout0_10 Vdout0_10ck118 = 0 time = 1190
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=1190.05n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 1190
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=1190.05n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 1190
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=1190.05n

* CHECK dout0_13 Vdout0_13ck118 = 0 time = 1190
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=1190.05n

* CHECK dout0_14 Vdout0_14ck118 = 0 time = 1190
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=1190.05n

* CHECK dout0_15 Vdout0_15ck118 = 0 time = 1190
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=1190.05n

* CHECK dout0_16 Vdout0_16ck118 = 1.8 time = 1190
.meas tran vdout0_16ck118 FIND v(dout0_16) AT=1190.05n

* CHECK dout0_17 Vdout0_17ck118 = 1.8 time = 1190
.meas tran vdout0_17ck118 FIND v(dout0_17) AT=1190.05n

* CHECK dout0_18 Vdout0_18ck118 = 0 time = 1190
.meas tran vdout0_18ck118 FIND v(dout0_18) AT=1190.05n

* CHECK dout0_19 Vdout0_19ck118 = 0 time = 1190
.meas tran vdout0_19ck118 FIND v(dout0_19) AT=1190.05n

* CHECK dout0_20 Vdout0_20ck118 = 1.8 time = 1190
.meas tran vdout0_20ck118 FIND v(dout0_20) AT=1190.05n

* CHECK dout0_21 Vdout0_21ck118 = 0 time = 1190
.meas tran vdout0_21ck118 FIND v(dout0_21) AT=1190.05n

* CHECK dout0_22 Vdout0_22ck118 = 0 time = 1190
.meas tran vdout0_22ck118 FIND v(dout0_22) AT=1190.05n

* CHECK dout0_23 Vdout0_23ck118 = 1.8 time = 1190
.meas tran vdout0_23ck118 FIND v(dout0_23) AT=1190.05n

* CHECK dout0_24 Vdout0_24ck118 = 0 time = 1190
.meas tran vdout0_24ck118 FIND v(dout0_24) AT=1190.05n

* CHECK dout0_25 Vdout0_25ck118 = 1.8 time = 1190
.meas tran vdout0_25ck118 FIND v(dout0_25) AT=1190.05n

* CHECK dout0_26 Vdout0_26ck118 = 1.8 time = 1190
.meas tran vdout0_26ck118 FIND v(dout0_26) AT=1190.05n

* CHECK dout0_27 Vdout0_27ck118 = 0 time = 1190
.meas tran vdout0_27ck118 FIND v(dout0_27) AT=1190.05n

* CHECK dout0_28 Vdout0_28ck118 = 0 time = 1190
.meas tran vdout0_28ck118 FIND v(dout0_28) AT=1190.05n

* CHECK dout0_29 Vdout0_29ck118 = 0 time = 1190
.meas tran vdout0_29ck118 FIND v(dout0_29) AT=1190.05n

* CHECK dout0_30 Vdout0_30ck118 = 0 time = 1190
.meas tran vdout0_30ck118 FIND v(dout0_30) AT=1190.05n

* CHECK dout0_31 Vdout0_31ck118 = 1.8 time = 1190
.meas tran vdout0_31ck118 FIND v(dout0_31) AT=1190.05n

* CHECK dout0_32 Vdout0_32ck118 = 0 time = 1190
.meas tran vdout0_32ck118 FIND v(dout0_32) AT=1190.05n

* CHECK dout0_0 Vdout0_0ck120 = 1.8 time = 1210
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=1210.05n

* CHECK dout0_1 Vdout0_1ck120 = 1.8 time = 1210
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=1210.05n

* CHECK dout0_2 Vdout0_2ck120 = 1.8 time = 1210
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=1210.05n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 1210
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=1210.05n

* CHECK dout0_4 Vdout0_4ck120 = 1.8 time = 1210
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=1210.05n

* CHECK dout0_5 Vdout0_5ck120 = 1.8 time = 1210
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=1210.05n

* CHECK dout0_6 Vdout0_6ck120 = 1.8 time = 1210
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=1210.05n

* CHECK dout0_7 Vdout0_7ck120 = 1.8 time = 1210
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=1210.05n

* CHECK dout0_8 Vdout0_8ck120 = 1.8 time = 1210
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=1210.05n

* CHECK dout0_9 Vdout0_9ck120 = 0 time = 1210
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=1210.05n

* CHECK dout0_10 Vdout0_10ck120 = 1.8 time = 1210
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=1210.05n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 1210
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=1210.05n

* CHECK dout0_12 Vdout0_12ck120 = 1.8 time = 1210
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=1210.05n

* CHECK dout0_13 Vdout0_13ck120 = 0 time = 1210
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=1210.05n

* CHECK dout0_14 Vdout0_14ck120 = 1.8 time = 1210
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=1210.05n

* CHECK dout0_15 Vdout0_15ck120 = 1.8 time = 1210
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=1210.05n

* CHECK dout0_16 Vdout0_16ck120 = 0 time = 1210
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=1210.05n

* CHECK dout0_17 Vdout0_17ck120 = 1.8 time = 1210
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=1210.05n

* CHECK dout0_18 Vdout0_18ck120 = 1.8 time = 1210
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=1210.05n

* CHECK dout0_19 Vdout0_19ck120 = 1.8 time = 1210
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=1210.05n

* CHECK dout0_20 Vdout0_20ck120 = 1.8 time = 1210
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=1210.05n

* CHECK dout0_21 Vdout0_21ck120 = 1.8 time = 1210
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=1210.05n

* CHECK dout0_22 Vdout0_22ck120 = 1.8 time = 1210
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=1210.05n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 1210
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=1210.05n

* CHECK dout0_24 Vdout0_24ck120 = 0 time = 1210
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=1210.05n

* CHECK dout0_25 Vdout0_25ck120 = 0 time = 1210
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=1210.05n

* CHECK dout0_26 Vdout0_26ck120 = 1.8 time = 1210
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=1210.05n

* CHECK dout0_27 Vdout0_27ck120 = 1.8 time = 1210
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=1210.05n

* CHECK dout0_28 Vdout0_28ck120 = 1.8 time = 1210
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=1210.05n

* CHECK dout0_29 Vdout0_29ck120 = 0 time = 1210
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=1210.05n

* CHECK dout0_30 Vdout0_30ck120 = 1.8 time = 1210
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=1210.05n

* CHECK dout0_31 Vdout0_31ck120 = 0 time = 1210
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=1210.05n

* CHECK dout0_32 Vdout0_32ck120 = 0 time = 1210
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=1210.05n

* CHECK dout0_0 Vdout0_0ck122 = 1.8 time = 1230
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=1230.05n

* CHECK dout0_1 Vdout0_1ck122 = 1.8 time = 1230
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=1230.05n

* CHECK dout0_2 Vdout0_2ck122 = 1.8 time = 1230
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=1230.05n

* CHECK dout0_3 Vdout0_3ck122 = 1.8 time = 1230
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=1230.05n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 1230
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=1230.05n

* CHECK dout0_5 Vdout0_5ck122 = 1.8 time = 1230
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=1230.05n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 1230
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=1230.05n

* CHECK dout0_7 Vdout0_7ck122 = 0 time = 1230
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=1230.05n

* CHECK dout0_8 Vdout0_8ck122 = 1.8 time = 1230
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=1230.05n

* CHECK dout0_9 Vdout0_9ck122 = 0 time = 1230
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=1230.05n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 1230
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=1230.05n

* CHECK dout0_11 Vdout0_11ck122 = 1.8 time = 1230
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=1230.05n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 1230
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=1230.05n

* CHECK dout0_13 Vdout0_13ck122 = 1.8 time = 1230
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=1230.05n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 1230
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=1230.05n

* CHECK dout0_15 Vdout0_15ck122 = 1.8 time = 1230
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=1230.05n

* CHECK dout0_16 Vdout0_16ck122 = 0 time = 1230
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=1230.05n

* CHECK dout0_17 Vdout0_17ck122 = 1.8 time = 1230
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=1230.05n

* CHECK dout0_18 Vdout0_18ck122 = 0 time = 1230
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=1230.05n

* CHECK dout0_19 Vdout0_19ck122 = 1.8 time = 1230
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=1230.05n

* CHECK dout0_20 Vdout0_20ck122 = 1.8 time = 1230
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=1230.05n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 1230
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=1230.05n

* CHECK dout0_22 Vdout0_22ck122 = 1.8 time = 1230
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=1230.05n

* CHECK dout0_23 Vdout0_23ck122 = 0 time = 1230
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=1230.05n

* CHECK dout0_24 Vdout0_24ck122 = 1.8 time = 1230
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=1230.05n

* CHECK dout0_25 Vdout0_25ck122 = 0 time = 1230
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=1230.05n

* CHECK dout0_26 Vdout0_26ck122 = 1.8 time = 1230
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=1230.05n

* CHECK dout0_27 Vdout0_27ck122 = 0 time = 1230
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=1230.05n

* CHECK dout0_28 Vdout0_28ck122 = 1.8 time = 1230
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=1230.05n

* CHECK dout0_29 Vdout0_29ck122 = 0 time = 1230
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=1230.05n

* CHECK dout0_30 Vdout0_30ck122 = 1.8 time = 1230
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=1230.05n

* CHECK dout0_31 Vdout0_31ck122 = 0 time = 1230
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=1230.05n

* CHECK dout0_32 Vdout0_32ck122 = 0 time = 1230
.meas tran vdout0_32ck122 FIND v(dout0_32) AT=1230.05n

* CHECK dout0_0 Vdout0_0ck127 = 1.8 time = 1280
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=1280.05n

* CHECK dout0_1 Vdout0_1ck127 = 1.8 time = 1280
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=1280.05n

* CHECK dout0_2 Vdout0_2ck127 = 0 time = 1280
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=1280.05n

* CHECK dout0_3 Vdout0_3ck127 = 1.8 time = 1280
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=1280.05n

* CHECK dout0_4 Vdout0_4ck127 = 1.8 time = 1280
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=1280.05n

* CHECK dout0_5 Vdout0_5ck127 = 1.8 time = 1280
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=1280.05n

* CHECK dout0_6 Vdout0_6ck127 = 1.8 time = 1280
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=1280.05n

* CHECK dout0_7 Vdout0_7ck127 = 0 time = 1280
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=1280.05n

* CHECK dout0_8 Vdout0_8ck127 = 0 time = 1280
.meas tran vdout0_8ck127 FIND v(dout0_8) AT=1280.05n

* CHECK dout0_9 Vdout0_9ck127 = 0 time = 1280
.meas tran vdout0_9ck127 FIND v(dout0_9) AT=1280.05n

* CHECK dout0_10 Vdout0_10ck127 = 1.8 time = 1280
.meas tran vdout0_10ck127 FIND v(dout0_10) AT=1280.05n

* CHECK dout0_11 Vdout0_11ck127 = 0 time = 1280
.meas tran vdout0_11ck127 FIND v(dout0_11) AT=1280.05n

* CHECK dout0_12 Vdout0_12ck127 = 1.8 time = 1280
.meas tran vdout0_12ck127 FIND v(dout0_12) AT=1280.05n

* CHECK dout0_13 Vdout0_13ck127 = 1.8 time = 1280
.meas tran vdout0_13ck127 FIND v(dout0_13) AT=1280.05n

* CHECK dout0_14 Vdout0_14ck127 = 1.8 time = 1280
.meas tran vdout0_14ck127 FIND v(dout0_14) AT=1280.05n

* CHECK dout0_15 Vdout0_15ck127 = 0 time = 1280
.meas tran vdout0_15ck127 FIND v(dout0_15) AT=1280.05n

* CHECK dout0_16 Vdout0_16ck127 = 0 time = 1280
.meas tran vdout0_16ck127 FIND v(dout0_16) AT=1280.05n

* CHECK dout0_17 Vdout0_17ck127 = 0 time = 1280
.meas tran vdout0_17ck127 FIND v(dout0_17) AT=1280.05n

* CHECK dout0_18 Vdout0_18ck127 = 0 time = 1280
.meas tran vdout0_18ck127 FIND v(dout0_18) AT=1280.05n

* CHECK dout0_19 Vdout0_19ck127 = 0 time = 1280
.meas tran vdout0_19ck127 FIND v(dout0_19) AT=1280.05n

* CHECK dout0_20 Vdout0_20ck127 = 0 time = 1280
.meas tran vdout0_20ck127 FIND v(dout0_20) AT=1280.05n

* CHECK dout0_21 Vdout0_21ck127 = 1.8 time = 1280
.meas tran vdout0_21ck127 FIND v(dout0_21) AT=1280.05n

* CHECK dout0_22 Vdout0_22ck127 = 1.8 time = 1280
.meas tran vdout0_22ck127 FIND v(dout0_22) AT=1280.05n

* CHECK dout0_23 Vdout0_23ck127 = 1.8 time = 1280
.meas tran vdout0_23ck127 FIND v(dout0_23) AT=1280.05n

* CHECK dout0_24 Vdout0_24ck127 = 1.8 time = 1280
.meas tran vdout0_24ck127 FIND v(dout0_24) AT=1280.05n

* CHECK dout0_25 Vdout0_25ck127 = 0 time = 1280
.meas tran vdout0_25ck127 FIND v(dout0_25) AT=1280.05n

* CHECK dout0_26 Vdout0_26ck127 = 0 time = 1280
.meas tran vdout0_26ck127 FIND v(dout0_26) AT=1280.05n

* CHECK dout0_27 Vdout0_27ck127 = 0 time = 1280
.meas tran vdout0_27ck127 FIND v(dout0_27) AT=1280.05n

* CHECK dout0_28 Vdout0_28ck127 = 1.8 time = 1280
.meas tran vdout0_28ck127 FIND v(dout0_28) AT=1280.05n

* CHECK dout0_29 Vdout0_29ck127 = 1.8 time = 1280
.meas tran vdout0_29ck127 FIND v(dout0_29) AT=1280.05n

* CHECK dout0_30 Vdout0_30ck127 = 1.8 time = 1280
.meas tran vdout0_30ck127 FIND v(dout0_30) AT=1280.05n

* CHECK dout0_31 Vdout0_31ck127 = 1.8 time = 1280
.meas tran vdout0_31ck127 FIND v(dout0_31) AT=1280.05n

* CHECK dout0_32 Vdout0_32ck127 = 0 time = 1280
.meas tran vdout0_32ck127 FIND v(dout0_32) AT=1280.05n

* CHECK dout0_0 Vdout0_0ck130 = 1.8 time = 1310
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=1310.05n

* CHECK dout0_1 Vdout0_1ck130 = 1.8 time = 1310
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=1310.05n

* CHECK dout0_2 Vdout0_2ck130 = 1.8 time = 1310
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=1310.05n

* CHECK dout0_3 Vdout0_3ck130 = 1.8 time = 1310
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=1310.05n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 1310
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=1310.05n

* CHECK dout0_5 Vdout0_5ck130 = 1.8 time = 1310
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=1310.05n

* CHECK dout0_6 Vdout0_6ck130 = 0 time = 1310
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=1310.05n

* CHECK dout0_7 Vdout0_7ck130 = 0 time = 1310
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=1310.05n

* CHECK dout0_8 Vdout0_8ck130 = 1.8 time = 1310
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=1310.05n

* CHECK dout0_9 Vdout0_9ck130 = 0 time = 1310
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=1310.05n

* CHECK dout0_10 Vdout0_10ck130 = 0 time = 1310
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=1310.05n

* CHECK dout0_11 Vdout0_11ck130 = 1.8 time = 1310
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=1310.05n

* CHECK dout0_12 Vdout0_12ck130 = 1.8 time = 1310
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=1310.05n

* CHECK dout0_13 Vdout0_13ck130 = 1.8 time = 1310
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=1310.05n

* CHECK dout0_14 Vdout0_14ck130 = 0 time = 1310
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=1310.05n

* CHECK dout0_15 Vdout0_15ck130 = 1.8 time = 1310
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=1310.05n

* CHECK dout0_16 Vdout0_16ck130 = 0 time = 1310
.meas tran vdout0_16ck130 FIND v(dout0_16) AT=1310.05n

* CHECK dout0_17 Vdout0_17ck130 = 1.8 time = 1310
.meas tran vdout0_17ck130 FIND v(dout0_17) AT=1310.05n

* CHECK dout0_18 Vdout0_18ck130 = 0 time = 1310
.meas tran vdout0_18ck130 FIND v(dout0_18) AT=1310.05n

* CHECK dout0_19 Vdout0_19ck130 = 1.8 time = 1310
.meas tran vdout0_19ck130 FIND v(dout0_19) AT=1310.05n

* CHECK dout0_20 Vdout0_20ck130 = 1.8 time = 1310
.meas tran vdout0_20ck130 FIND v(dout0_20) AT=1310.05n

* CHECK dout0_21 Vdout0_21ck130 = 0 time = 1310
.meas tran vdout0_21ck130 FIND v(dout0_21) AT=1310.05n

* CHECK dout0_22 Vdout0_22ck130 = 1.8 time = 1310
.meas tran vdout0_22ck130 FIND v(dout0_22) AT=1310.05n

* CHECK dout0_23 Vdout0_23ck130 = 0 time = 1310
.meas tran vdout0_23ck130 FIND v(dout0_23) AT=1310.05n

* CHECK dout0_24 Vdout0_24ck130 = 1.8 time = 1310
.meas tran vdout0_24ck130 FIND v(dout0_24) AT=1310.05n

* CHECK dout0_25 Vdout0_25ck130 = 0 time = 1310
.meas tran vdout0_25ck130 FIND v(dout0_25) AT=1310.05n

* CHECK dout0_26 Vdout0_26ck130 = 1.8 time = 1310
.meas tran vdout0_26ck130 FIND v(dout0_26) AT=1310.05n

* CHECK dout0_27 Vdout0_27ck130 = 0 time = 1310
.meas tran vdout0_27ck130 FIND v(dout0_27) AT=1310.05n

* CHECK dout0_28 Vdout0_28ck130 = 1.8 time = 1310
.meas tran vdout0_28ck130 FIND v(dout0_28) AT=1310.05n

* CHECK dout0_29 Vdout0_29ck130 = 0 time = 1310
.meas tran vdout0_29ck130 FIND v(dout0_29) AT=1310.05n

* CHECK dout0_30 Vdout0_30ck130 = 1.8 time = 1310
.meas tran vdout0_30ck130 FIND v(dout0_30) AT=1310.05n

* CHECK dout0_31 Vdout0_31ck130 = 0 time = 1310
.meas tran vdout0_31ck130 FIND v(dout0_31) AT=1310.05n

* CHECK dout0_32 Vdout0_32ck130 = 0 time = 1310
.meas tran vdout0_32ck130 FIND v(dout0_32) AT=1310.05n

* CHECK dout0_0 Vdout0_0ck134 = 1.8 time = 1350
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=1350.05n

* CHECK dout0_1 Vdout0_1ck134 = 0 time = 1350
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=1350.05n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 1350
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=1350.05n

* CHECK dout0_3 Vdout0_3ck134 = 1.8 time = 1350
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=1350.05n

* CHECK dout0_4 Vdout0_4ck134 = 0 time = 1350
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=1350.05n

* CHECK dout0_5 Vdout0_5ck134 = 1.8 time = 1350
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=1350.05n

* CHECK dout0_6 Vdout0_6ck134 = 0 time = 1350
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=1350.05n

* CHECK dout0_7 Vdout0_7ck134 = 0 time = 1350
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=1350.05n

* CHECK dout0_8 Vdout0_8ck134 = 1.8 time = 1350
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=1350.05n

* CHECK dout0_9 Vdout0_9ck134 = 1.8 time = 1350
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=1350.05n

* CHECK dout0_10 Vdout0_10ck134 = 1.8 time = 1350
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=1350.05n

* CHECK dout0_11 Vdout0_11ck134 = 0 time = 1350
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=1350.05n

* CHECK dout0_12 Vdout0_12ck134 = 0 time = 1350
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=1350.05n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 1350
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=1350.05n

* CHECK dout0_14 Vdout0_14ck134 = 1.8 time = 1350
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=1350.05n

* CHECK dout0_15 Vdout0_15ck134 = 0 time = 1350
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=1350.05n

* CHECK dout0_16 Vdout0_16ck134 = 1.8 time = 1350
.meas tran vdout0_16ck134 FIND v(dout0_16) AT=1350.05n

* CHECK dout0_17 Vdout0_17ck134 = 0 time = 1350
.meas tran vdout0_17ck134 FIND v(dout0_17) AT=1350.05n

* CHECK dout0_18 Vdout0_18ck134 = 1.8 time = 1350
.meas tran vdout0_18ck134 FIND v(dout0_18) AT=1350.05n

* CHECK dout0_19 Vdout0_19ck134 = 0 time = 1350
.meas tran vdout0_19ck134 FIND v(dout0_19) AT=1350.05n

* CHECK dout0_20 Vdout0_20ck134 = 1.8 time = 1350
.meas tran vdout0_20ck134 FIND v(dout0_20) AT=1350.05n

* CHECK dout0_21 Vdout0_21ck134 = 1.8 time = 1350
.meas tran vdout0_21ck134 FIND v(dout0_21) AT=1350.05n

* CHECK dout0_22 Vdout0_22ck134 = 1.8 time = 1350
.meas tran vdout0_22ck134 FIND v(dout0_22) AT=1350.05n

* CHECK dout0_23 Vdout0_23ck134 = 0 time = 1350
.meas tran vdout0_23ck134 FIND v(dout0_23) AT=1350.05n

* CHECK dout0_24 Vdout0_24ck134 = 1.8 time = 1350
.meas tran vdout0_24ck134 FIND v(dout0_24) AT=1350.05n

* CHECK dout0_25 Vdout0_25ck134 = 1.8 time = 1350
.meas tran vdout0_25ck134 FIND v(dout0_25) AT=1350.05n

* CHECK dout0_26 Vdout0_26ck134 = 0 time = 1350
.meas tran vdout0_26ck134 FIND v(dout0_26) AT=1350.05n

* CHECK dout0_27 Vdout0_27ck134 = 0 time = 1350
.meas tran vdout0_27ck134 FIND v(dout0_27) AT=1350.05n

* CHECK dout0_28 Vdout0_28ck134 = 1.8 time = 1350
.meas tran vdout0_28ck134 FIND v(dout0_28) AT=1350.05n

* CHECK dout0_29 Vdout0_29ck134 = 0 time = 1350
.meas tran vdout0_29ck134 FIND v(dout0_29) AT=1350.05n

* CHECK dout0_30 Vdout0_30ck134 = 0 time = 1350
.meas tran vdout0_30ck134 FIND v(dout0_30) AT=1350.05n

* CHECK dout0_31 Vdout0_31ck134 = 1.8 time = 1350
.meas tran vdout0_31ck134 FIND v(dout0_31) AT=1350.05n

* CHECK dout0_32 Vdout0_32ck134 = 0 time = 1350
.meas tran vdout0_32ck134 FIND v(dout0_32) AT=1350.05n

* CHECK dout0_0 Vdout0_0ck136 = 1.8 time = 1370
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=1370.05n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 1370
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=1370.05n

* CHECK dout0_2 Vdout0_2ck136 = 0 time = 1370
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=1370.05n

* CHECK dout0_3 Vdout0_3ck136 = 0 time = 1370
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=1370.05n

* CHECK dout0_4 Vdout0_4ck136 = 1.8 time = 1370
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=1370.05n

* CHECK dout0_5 Vdout0_5ck136 = 1.8 time = 1370
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=1370.05n

* CHECK dout0_6 Vdout0_6ck136 = 1.8 time = 1370
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=1370.05n

* CHECK dout0_7 Vdout0_7ck136 = 0 time = 1370
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=1370.05n

* CHECK dout0_8 Vdout0_8ck136 = 1.8 time = 1370
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=1370.05n

* CHECK dout0_9 Vdout0_9ck136 = 0 time = 1370
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=1370.05n

* CHECK dout0_10 Vdout0_10ck136 = 1.8 time = 1370
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=1370.05n

* CHECK dout0_11 Vdout0_11ck136 = 0 time = 1370
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=1370.05n

* CHECK dout0_12 Vdout0_12ck136 = 1.8 time = 1370
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=1370.05n

* CHECK dout0_13 Vdout0_13ck136 = 0 time = 1370
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=1370.05n

* CHECK dout0_14 Vdout0_14ck136 = 1.8 time = 1370
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=1370.05n

* CHECK dout0_15 Vdout0_15ck136 = 1.8 time = 1370
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=1370.05n

* CHECK dout0_16 Vdout0_16ck136 = 1.8 time = 1370
.meas tran vdout0_16ck136 FIND v(dout0_16) AT=1370.05n

* CHECK dout0_17 Vdout0_17ck136 = 1.8 time = 1370
.meas tran vdout0_17ck136 FIND v(dout0_17) AT=1370.05n

* CHECK dout0_18 Vdout0_18ck136 = 1.8 time = 1370
.meas tran vdout0_18ck136 FIND v(dout0_18) AT=1370.05n

* CHECK dout0_19 Vdout0_19ck136 = 0 time = 1370
.meas tran vdout0_19ck136 FIND v(dout0_19) AT=1370.05n

* CHECK dout0_20 Vdout0_20ck136 = 0 time = 1370
.meas tran vdout0_20ck136 FIND v(dout0_20) AT=1370.05n

* CHECK dout0_21 Vdout0_21ck136 = 1.8 time = 1370
.meas tran vdout0_21ck136 FIND v(dout0_21) AT=1370.05n

* CHECK dout0_22 Vdout0_22ck136 = 1.8 time = 1370
.meas tran vdout0_22ck136 FIND v(dout0_22) AT=1370.05n

* CHECK dout0_23 Vdout0_23ck136 = 1.8 time = 1370
.meas tran vdout0_23ck136 FIND v(dout0_23) AT=1370.05n

* CHECK dout0_24 Vdout0_24ck136 = 0 time = 1370
.meas tran vdout0_24ck136 FIND v(dout0_24) AT=1370.05n

* CHECK dout0_25 Vdout0_25ck136 = 1.8 time = 1370
.meas tran vdout0_25ck136 FIND v(dout0_25) AT=1370.05n

* CHECK dout0_26 Vdout0_26ck136 = 1.8 time = 1370
.meas tran vdout0_26ck136 FIND v(dout0_26) AT=1370.05n

* CHECK dout0_27 Vdout0_27ck136 = 1.8 time = 1370
.meas tran vdout0_27ck136 FIND v(dout0_27) AT=1370.05n

* CHECK dout0_28 Vdout0_28ck136 = 0 time = 1370
.meas tran vdout0_28ck136 FIND v(dout0_28) AT=1370.05n

* CHECK dout0_29 Vdout0_29ck136 = 0 time = 1370
.meas tran vdout0_29ck136 FIND v(dout0_29) AT=1370.05n

* CHECK dout0_30 Vdout0_30ck136 = 1.8 time = 1370
.meas tran vdout0_30ck136 FIND v(dout0_30) AT=1370.05n

* CHECK dout0_31 Vdout0_31ck136 = 0 time = 1370
.meas tran vdout0_31ck136 FIND v(dout0_31) AT=1370.05n

* CHECK dout0_32 Vdout0_32ck136 = 0 time = 1370
.meas tran vdout0_32ck136 FIND v(dout0_32) AT=1370.05n

* CHECK dout0_0 Vdout0_0ck137 = 1.8 time = 1380
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=1380.05n

* CHECK dout0_1 Vdout0_1ck137 = 1.8 time = 1380
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=1380.05n

* CHECK dout0_2 Vdout0_2ck137 = 1.8 time = 1380
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=1380.05n

* CHECK dout0_3 Vdout0_3ck137 = 1.8 time = 1380
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=1380.05n

* CHECK dout0_4 Vdout0_4ck137 = 0 time = 1380
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=1380.05n

* CHECK dout0_5 Vdout0_5ck137 = 1.8 time = 1380
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=1380.05n

* CHECK dout0_6 Vdout0_6ck137 = 0 time = 1380
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=1380.05n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 1380
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=1380.05n

* CHECK dout0_8 Vdout0_8ck137 = 1.8 time = 1380
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=1380.05n

* CHECK dout0_9 Vdout0_9ck137 = 0 time = 1380
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=1380.05n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 1380
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=1380.05n

* CHECK dout0_11 Vdout0_11ck137 = 1.8 time = 1380
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=1380.05n

* CHECK dout0_12 Vdout0_12ck137 = 1.8 time = 1380
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=1380.05n

* CHECK dout0_13 Vdout0_13ck137 = 1.8 time = 1380
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=1380.05n

* CHECK dout0_14 Vdout0_14ck137 = 0 time = 1380
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=1380.05n

* CHECK dout0_15 Vdout0_15ck137 = 1.8 time = 1380
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=1380.05n

* CHECK dout0_16 Vdout0_16ck137 = 0 time = 1380
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=1380.05n

* CHECK dout0_17 Vdout0_17ck137 = 1.8 time = 1380
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=1380.05n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 1380
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=1380.05n

* CHECK dout0_19 Vdout0_19ck137 = 1.8 time = 1380
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=1380.05n

* CHECK dout0_20 Vdout0_20ck137 = 1.8 time = 1380
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=1380.05n

* CHECK dout0_21 Vdout0_21ck137 = 0 time = 1380
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=1380.05n

* CHECK dout0_22 Vdout0_22ck137 = 1.8 time = 1380
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=1380.05n

* CHECK dout0_23 Vdout0_23ck137 = 0 time = 1380
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=1380.05n

* CHECK dout0_24 Vdout0_24ck137 = 1.8 time = 1380
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=1380.05n

* CHECK dout0_25 Vdout0_25ck137 = 0 time = 1380
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=1380.05n

* CHECK dout0_26 Vdout0_26ck137 = 1.8 time = 1380
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=1380.05n

* CHECK dout0_27 Vdout0_27ck137 = 0 time = 1380
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=1380.05n

* CHECK dout0_28 Vdout0_28ck137 = 1.8 time = 1380
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=1380.05n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 1380
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=1380.05n

* CHECK dout0_30 Vdout0_30ck137 = 1.8 time = 1380
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=1380.05n

* CHECK dout0_31 Vdout0_31ck137 = 0 time = 1380
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=1380.05n

* CHECK dout0_32 Vdout0_32ck137 = 0 time = 1380
.meas tran vdout0_32ck137 FIND v(dout0_32) AT=1380.05n

* CHECK dout0_0 Vdout0_0ck141 = 0 time = 1420
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=1420.05n

* CHECK dout0_1 Vdout0_1ck141 = 0 time = 1420
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=1420.05n

* CHECK dout0_2 Vdout0_2ck141 = 1.8 time = 1420
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=1420.05n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 1420
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=1420.05n

* CHECK dout0_4 Vdout0_4ck141 = 1.8 time = 1420
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=1420.05n

* CHECK dout0_5 Vdout0_5ck141 = 1.8 time = 1420
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=1420.05n

* CHECK dout0_6 Vdout0_6ck141 = 1.8 time = 1420
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=1420.05n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 1420
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=1420.05n

* CHECK dout0_8 Vdout0_8ck141 = 1.8 time = 1420
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=1420.05n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 1420
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=1420.05n

* CHECK dout0_10 Vdout0_10ck141 = 1.8 time = 1420
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=1420.05n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 1420
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=1420.05n

* CHECK dout0_12 Vdout0_12ck141 = 1.8 time = 1420
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=1420.05n

* CHECK dout0_13 Vdout0_13ck141 = 0 time = 1420
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=1420.05n

* CHECK dout0_14 Vdout0_14ck141 = 1.8 time = 1420
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=1420.05n

* CHECK dout0_15 Vdout0_15ck141 = 0 time = 1420
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=1420.05n

* CHECK dout0_16 Vdout0_16ck141 = 1.8 time = 1420
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=1420.05n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 1420
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=1420.05n

* CHECK dout0_18 Vdout0_18ck141 = 1.8 time = 1420
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=1420.05n

* CHECK dout0_19 Vdout0_19ck141 = 1.8 time = 1420
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=1420.05n

* CHECK dout0_20 Vdout0_20ck141 = 0 time = 1420
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=1420.05n

* CHECK dout0_21 Vdout0_21ck141 = 1.8 time = 1420
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=1420.05n

* CHECK dout0_22 Vdout0_22ck141 = 1.8 time = 1420
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=1420.05n

* CHECK dout0_23 Vdout0_23ck141 = 0 time = 1420
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=1420.05n

* CHECK dout0_24 Vdout0_24ck141 = 1.8 time = 1420
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=1420.05n

* CHECK dout0_25 Vdout0_25ck141 = 1.8 time = 1420
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=1420.05n

* CHECK dout0_26 Vdout0_26ck141 = 1.8 time = 1420
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=1420.05n

* CHECK dout0_27 Vdout0_27ck141 = 1.8 time = 1420
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=1420.05n

* CHECK dout0_28 Vdout0_28ck141 = 0 time = 1420
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=1420.05n

* CHECK dout0_29 Vdout0_29ck141 = 1.8 time = 1420
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=1420.05n

* CHECK dout0_30 Vdout0_30ck141 = 0 time = 1420
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=1420.05n

* CHECK dout0_31 Vdout0_31ck141 = 1.8 time = 1420
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=1420.05n

* CHECK dout0_32 Vdout0_32ck141 = 0 time = 1420
.meas tran vdout0_32ck141 FIND v(dout0_32) AT=1420.05n

* CHECK dout0_0 Vdout0_0ck143 = 0 time = 1440
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=1440.05n

* CHECK dout0_1 Vdout0_1ck143 = 1.8 time = 1440
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=1440.05n

* CHECK dout0_2 Vdout0_2ck143 = 1.8 time = 1440
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=1440.05n

* CHECK dout0_3 Vdout0_3ck143 = 1.8 time = 1440
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=1440.05n

* CHECK dout0_4 Vdout0_4ck143 = 1.8 time = 1440
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=1440.05n

* CHECK dout0_5 Vdout0_5ck143 = 1.8 time = 1440
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=1440.05n

* CHECK dout0_6 Vdout0_6ck143 = 1.8 time = 1440
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=1440.05n

* CHECK dout0_7 Vdout0_7ck143 = 1.8 time = 1440
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=1440.05n

* CHECK dout0_8 Vdout0_8ck143 = 0 time = 1440
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=1440.05n

* CHECK dout0_9 Vdout0_9ck143 = 1.8 time = 1440
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=1440.05n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 1440
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=1440.05n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 1440
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=1440.05n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 1440
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=1440.05n

* CHECK dout0_13 Vdout0_13ck143 = 0 time = 1440
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=1440.05n

* CHECK dout0_14 Vdout0_14ck143 = 0 time = 1440
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=1440.05n

* CHECK dout0_15 Vdout0_15ck143 = 0 time = 1440
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=1440.05n

* CHECK dout0_16 Vdout0_16ck143 = 1.8 time = 1440
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=1440.05n

* CHECK dout0_17 Vdout0_17ck143 = 1.8 time = 1440
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=1440.05n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 1440
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=1440.05n

* CHECK dout0_19 Vdout0_19ck143 = 0 time = 1440
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=1440.05n

* CHECK dout0_20 Vdout0_20ck143 = 1.8 time = 1440
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=1440.05n

* CHECK dout0_21 Vdout0_21ck143 = 0 time = 1440
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=1440.05n

* CHECK dout0_22 Vdout0_22ck143 = 0 time = 1440
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=1440.05n

* CHECK dout0_23 Vdout0_23ck143 = 1.8 time = 1440
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=1440.05n

* CHECK dout0_24 Vdout0_24ck143 = 0 time = 1440
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=1440.05n

* CHECK dout0_25 Vdout0_25ck143 = 1.8 time = 1440
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=1440.05n

* CHECK dout0_26 Vdout0_26ck143 = 1.8 time = 1440
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=1440.05n

* CHECK dout0_27 Vdout0_27ck143 = 0 time = 1440
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=1440.05n

* CHECK dout0_28 Vdout0_28ck143 = 0 time = 1440
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=1440.05n

* CHECK dout0_29 Vdout0_29ck143 = 0 time = 1440
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=1440.05n

* CHECK dout0_30 Vdout0_30ck143 = 0 time = 1440
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=1440.05n

* CHECK dout0_31 Vdout0_31ck143 = 1.8 time = 1440
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=1440.05n

* CHECK dout0_32 Vdout0_32ck143 = 0 time = 1440
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=1440.05n

* CHECK dout0_0 Vdout0_0ck153 = 1.8 time = 1540
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=1540.05n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 1540
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=1540.05n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 1540
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=1540.05n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 1540
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=1540.05n

* CHECK dout0_4 Vdout0_4ck153 = 1.8 time = 1540
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=1540.05n

* CHECK dout0_5 Vdout0_5ck153 = 1.8 time = 1540
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=1540.05n

* CHECK dout0_6 Vdout0_6ck153 = 1.8 time = 1540
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=1540.05n

* CHECK dout0_7 Vdout0_7ck153 = 0 time = 1540
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=1540.05n

* CHECK dout0_8 Vdout0_8ck153 = 1.8 time = 1540
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=1540.05n

* CHECK dout0_9 Vdout0_9ck153 = 1.8 time = 1540
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=1540.05n

* CHECK dout0_10 Vdout0_10ck153 = 1.8 time = 1540
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=1540.05n

* CHECK dout0_11 Vdout0_11ck153 = 1.8 time = 1540
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=1540.05n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 1540
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=1540.05n

* CHECK dout0_13 Vdout0_13ck153 = 1.8 time = 1540
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=1540.05n

* CHECK dout0_14 Vdout0_14ck153 = 0 time = 1540
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=1540.05n

* CHECK dout0_15 Vdout0_15ck153 = 1.8 time = 1540
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=1540.05n

* CHECK dout0_16 Vdout0_16ck153 = 0 time = 1540
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=1540.05n

* CHECK dout0_17 Vdout0_17ck153 = 0 time = 1540
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=1540.05n

* CHECK dout0_18 Vdout0_18ck153 = 0 time = 1540
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=1540.05n

* CHECK dout0_19 Vdout0_19ck153 = 1.8 time = 1540
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=1540.05n

* CHECK dout0_20 Vdout0_20ck153 = 1.8 time = 1540
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=1540.05n

* CHECK dout0_21 Vdout0_21ck153 = 0 time = 1540
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=1540.05n

* CHECK dout0_22 Vdout0_22ck153 = 1.8 time = 1540
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=1540.05n

* CHECK dout0_23 Vdout0_23ck153 = 0 time = 1540
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=1540.05n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 1540
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=1540.05n

* CHECK dout0_25 Vdout0_25ck153 = 0 time = 1540
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=1540.05n

* CHECK dout0_26 Vdout0_26ck153 = 1.8 time = 1540
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=1540.05n

* CHECK dout0_27 Vdout0_27ck153 = 1.8 time = 1540
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=1540.05n

* CHECK dout0_28 Vdout0_28ck153 = 1.8 time = 1540
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=1540.05n

* CHECK dout0_29 Vdout0_29ck153 = 1.8 time = 1540
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=1540.05n

* CHECK dout0_30 Vdout0_30ck153 = 0 time = 1540
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=1540.05n

* CHECK dout0_31 Vdout0_31ck153 = 0 time = 1540
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=1540.05n

* CHECK dout0_32 Vdout0_32ck153 = 0 time = 1540
.meas tran vdout0_32ck153 FIND v(dout0_32) AT=1540.05n

* CHECK dout0_0 Vdout0_0ck157 = 0 time = 1580
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=1580.05n

* CHECK dout0_1 Vdout0_1ck157 = 1.8 time = 1580
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=1580.05n

* CHECK dout0_2 Vdout0_2ck157 = 1.8 time = 1580
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=1580.05n

* CHECK dout0_3 Vdout0_3ck157 = 0 time = 1580
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=1580.05n

* CHECK dout0_4 Vdout0_4ck157 = 1.8 time = 1580
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=1580.05n

* CHECK dout0_5 Vdout0_5ck157 = 1.8 time = 1580
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=1580.05n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 1580
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=1580.05n

* CHECK dout0_7 Vdout0_7ck157 = 1.8 time = 1580
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=1580.05n

* CHECK dout0_8 Vdout0_8ck157 = 0 time = 1580
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=1580.05n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 1580
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=1580.05n

* CHECK dout0_10 Vdout0_10ck157 = 0 time = 1580
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=1580.05n

* CHECK dout0_11 Vdout0_11ck157 = 0 time = 1580
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=1580.05n

* CHECK dout0_12 Vdout0_12ck157 = 1.8 time = 1580
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=1580.05n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 1580
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=1580.05n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 1580
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=1580.05n

* CHECK dout0_15 Vdout0_15ck157 = 1.8 time = 1580
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=1580.05n

* CHECK dout0_16 Vdout0_16ck157 = 0 time = 1580
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=1580.05n

* CHECK dout0_17 Vdout0_17ck157 = 0 time = 1580
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=1580.05n

* CHECK dout0_18 Vdout0_18ck157 = 0 time = 1580
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=1580.05n

* CHECK dout0_19 Vdout0_19ck157 = 0 time = 1580
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=1580.05n

* CHECK dout0_20 Vdout0_20ck157 = 0 time = 1580
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=1580.05n

* CHECK dout0_21 Vdout0_21ck157 = 1.8 time = 1580
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=1580.05n

* CHECK dout0_22 Vdout0_22ck157 = 1.8 time = 1580
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=1580.05n

* CHECK dout0_23 Vdout0_23ck157 = 0 time = 1580
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=1580.05n

* CHECK dout0_24 Vdout0_24ck157 = 0 time = 1580
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=1580.05n

* CHECK dout0_25 Vdout0_25ck157 = 1.8 time = 1580
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=1580.05n

* CHECK dout0_26 Vdout0_26ck157 = 1.8 time = 1580
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=1580.05n

* CHECK dout0_27 Vdout0_27ck157 = 1.8 time = 1580
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=1580.05n

* CHECK dout0_28 Vdout0_28ck157 = 0 time = 1580
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=1580.05n

* CHECK dout0_29 Vdout0_29ck157 = 0 time = 1580
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=1580.05n

* CHECK dout0_30 Vdout0_30ck157 = 0 time = 1580
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=1580.05n

* CHECK dout0_31 Vdout0_31ck157 = 1.8 time = 1580
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=1580.05n

* CHECK dout0_32 Vdout0_32ck157 = 0 time = 1580
.meas tran vdout0_32ck157 FIND v(dout0_32) AT=1580.05n

* CHECK dout0_0 Vdout0_0ck160 = 1.8 time = 1610
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=1610.05n

* CHECK dout0_1 Vdout0_1ck160 = 1.8 time = 1610
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=1610.05n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 1610
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=1610.05n

* CHECK dout0_3 Vdout0_3ck160 = 1.8 time = 1610
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=1610.05n

* CHECK dout0_4 Vdout0_4ck160 = 0 time = 1610
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=1610.05n

* CHECK dout0_5 Vdout0_5ck160 = 1.8 time = 1610
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=1610.05n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 1610
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=1610.05n

* CHECK dout0_7 Vdout0_7ck160 = 1.8 time = 1610
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=1610.05n

* CHECK dout0_8 Vdout0_8ck160 = 0 time = 1610
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=1610.05n

* CHECK dout0_9 Vdout0_9ck160 = 0 time = 1610
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=1610.05n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 1610
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=1610.05n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 1610
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=1610.05n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 1610
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=1610.05n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 1610
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=1610.05n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 1610
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=1610.05n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 1610
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=1610.05n

* CHECK dout0_16 Vdout0_16ck160 = 0 time = 1610
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=1610.05n

* CHECK dout0_17 Vdout0_17ck160 = 1.8 time = 1610
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=1610.05n

* CHECK dout0_18 Vdout0_18ck160 = 1.8 time = 1610
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=1610.05n

* CHECK dout0_19 Vdout0_19ck160 = 1.8 time = 1610
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=1610.05n

* CHECK dout0_20 Vdout0_20ck160 = 0 time = 1610
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=1610.05n

* CHECK dout0_21 Vdout0_21ck160 = 1.8 time = 1610
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=1610.05n

* CHECK dout0_22 Vdout0_22ck160 = 0 time = 1610
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=1610.05n

* CHECK dout0_23 Vdout0_23ck160 = 1.8 time = 1610
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=1610.05n

* CHECK dout0_24 Vdout0_24ck160 = 1.8 time = 1610
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=1610.05n

* CHECK dout0_25 Vdout0_25ck160 = 1.8 time = 1610
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=1610.05n

* CHECK dout0_26 Vdout0_26ck160 = 1.8 time = 1610
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=1610.05n

* CHECK dout0_27 Vdout0_27ck160 = 1.8 time = 1610
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=1610.05n

* CHECK dout0_28 Vdout0_28ck160 = 0 time = 1610
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=1610.05n

* CHECK dout0_29 Vdout0_29ck160 = 1.8 time = 1610
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=1610.05n

* CHECK dout0_30 Vdout0_30ck160 = 1.8 time = 1610
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=1610.05n

* CHECK dout0_31 Vdout0_31ck160 = 0 time = 1610
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=1610.05n

* CHECK dout0_32 Vdout0_32ck160 = 0 time = 1610
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=1610.05n

* CHECK dout0_0 Vdout0_0ck163 = 1.8 time = 1640
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=1640.05n

* CHECK dout0_1 Vdout0_1ck163 = 0 time = 1640
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=1640.05n

* CHECK dout0_2 Vdout0_2ck163 = 0 time = 1640
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=1640.05n

* CHECK dout0_3 Vdout0_3ck163 = 0 time = 1640
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=1640.05n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 1640
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=1640.05n

* CHECK dout0_5 Vdout0_5ck163 = 0 time = 1640
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=1640.05n

* CHECK dout0_6 Vdout0_6ck163 = 0 time = 1640
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=1640.05n

* CHECK dout0_7 Vdout0_7ck163 = 1.8 time = 1640
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=1640.05n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 1640
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=1640.05n

* CHECK dout0_9 Vdout0_9ck163 = 0 time = 1640
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=1640.05n

* CHECK dout0_10 Vdout0_10ck163 = 1.8 time = 1640
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=1640.05n

* CHECK dout0_11 Vdout0_11ck163 = 1.8 time = 1640
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=1640.05n

* CHECK dout0_12 Vdout0_12ck163 = 0 time = 1640
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=1640.05n

* CHECK dout0_13 Vdout0_13ck163 = 1.8 time = 1640
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=1640.05n

* CHECK dout0_14 Vdout0_14ck163 = 0 time = 1640
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=1640.05n

* CHECK dout0_15 Vdout0_15ck163 = 1.8 time = 1640
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=1640.05n

* CHECK dout0_16 Vdout0_16ck163 = 1.8 time = 1640
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=1640.05n

* CHECK dout0_17 Vdout0_17ck163 = 1.8 time = 1640
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=1640.05n

* CHECK dout0_18 Vdout0_18ck163 = 1.8 time = 1640
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=1640.05n

* CHECK dout0_19 Vdout0_19ck163 = 1.8 time = 1640
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=1640.05n

* CHECK dout0_20 Vdout0_20ck163 = 1.8 time = 1640
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=1640.05n

* CHECK dout0_21 Vdout0_21ck163 = 1.8 time = 1640
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=1640.05n

* CHECK dout0_22 Vdout0_22ck163 = 0 time = 1640
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=1640.05n

* CHECK dout0_23 Vdout0_23ck163 = 1.8 time = 1640
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=1640.05n

* CHECK dout0_24 Vdout0_24ck163 = 0 time = 1640
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=1640.05n

* CHECK dout0_25 Vdout0_25ck163 = 0 time = 1640
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=1640.05n

* CHECK dout0_26 Vdout0_26ck163 = 0 time = 1640
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=1640.05n

* CHECK dout0_27 Vdout0_27ck163 = 1.8 time = 1640
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=1640.05n

* CHECK dout0_28 Vdout0_28ck163 = 0 time = 1640
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=1640.05n

* CHECK dout0_29 Vdout0_29ck163 = 0 time = 1640
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=1640.05n

* CHECK dout0_30 Vdout0_30ck163 = 1.8 time = 1640
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=1640.05n

* CHECK dout0_31 Vdout0_31ck163 = 1.8 time = 1640
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=1640.05n

* CHECK dout0_32 Vdout0_32ck163 = 0 time = 1640
.meas tran vdout0_32ck163 FIND v(dout0_32) AT=1640.05n

* CHECK dout0_0 Vdout0_0ck164 = 1.8 time = 1650
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=1650.05n

* CHECK dout0_1 Vdout0_1ck164 = 0 time = 1650
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=1650.05n

* CHECK dout0_2 Vdout0_2ck164 = 1.8 time = 1650
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=1650.05n

* CHECK dout0_3 Vdout0_3ck164 = 1.8 time = 1650
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=1650.05n

* CHECK dout0_4 Vdout0_4ck164 = 1.8 time = 1650
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=1650.05n

* CHECK dout0_5 Vdout0_5ck164 = 0 time = 1650
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=1650.05n

* CHECK dout0_6 Vdout0_6ck164 = 0 time = 1650
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=1650.05n

* CHECK dout0_7 Vdout0_7ck164 = 1.8 time = 1650
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=1650.05n

* CHECK dout0_8 Vdout0_8ck164 = 1.8 time = 1650
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=1650.05n

* CHECK dout0_9 Vdout0_9ck164 = 1.8 time = 1650
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=1650.05n

* CHECK dout0_10 Vdout0_10ck164 = 1.8 time = 1650
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=1650.05n

* CHECK dout0_11 Vdout0_11ck164 = 1.8 time = 1650
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=1650.05n

* CHECK dout0_12 Vdout0_12ck164 = 1.8 time = 1650
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=1650.05n

* CHECK dout0_13 Vdout0_13ck164 = 1.8 time = 1650
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=1650.05n

* CHECK dout0_14 Vdout0_14ck164 = 1.8 time = 1650
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=1650.05n

* CHECK dout0_15 Vdout0_15ck164 = 0 time = 1650
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=1650.05n

* CHECK dout0_16 Vdout0_16ck164 = 1.8 time = 1650
.meas tran vdout0_16ck164 FIND v(dout0_16) AT=1650.05n

* CHECK dout0_17 Vdout0_17ck164 = 0 time = 1650
.meas tran vdout0_17ck164 FIND v(dout0_17) AT=1650.05n

* CHECK dout0_18 Vdout0_18ck164 = 1.8 time = 1650
.meas tran vdout0_18ck164 FIND v(dout0_18) AT=1650.05n

* CHECK dout0_19 Vdout0_19ck164 = 0 time = 1650
.meas tran vdout0_19ck164 FIND v(dout0_19) AT=1650.05n

* CHECK dout0_20 Vdout0_20ck164 = 1.8 time = 1650
.meas tran vdout0_20ck164 FIND v(dout0_20) AT=1650.05n

* CHECK dout0_21 Vdout0_21ck164 = 0 time = 1650
.meas tran vdout0_21ck164 FIND v(dout0_21) AT=1650.05n

* CHECK dout0_22 Vdout0_22ck164 = 1.8 time = 1650
.meas tran vdout0_22ck164 FIND v(dout0_22) AT=1650.05n

* CHECK dout0_23 Vdout0_23ck164 = 1.8 time = 1650
.meas tran vdout0_23ck164 FIND v(dout0_23) AT=1650.05n

* CHECK dout0_24 Vdout0_24ck164 = 0 time = 1650
.meas tran vdout0_24ck164 FIND v(dout0_24) AT=1650.05n

* CHECK dout0_25 Vdout0_25ck164 = 0 time = 1650
.meas tran vdout0_25ck164 FIND v(dout0_25) AT=1650.05n

* CHECK dout0_26 Vdout0_26ck164 = 1.8 time = 1650
.meas tran vdout0_26ck164 FIND v(dout0_26) AT=1650.05n

* CHECK dout0_27 Vdout0_27ck164 = 1.8 time = 1650
.meas tran vdout0_27ck164 FIND v(dout0_27) AT=1650.05n

* CHECK dout0_28 Vdout0_28ck164 = 0 time = 1650
.meas tran vdout0_28ck164 FIND v(dout0_28) AT=1650.05n

* CHECK dout0_29 Vdout0_29ck164 = 0 time = 1650
.meas tran vdout0_29ck164 FIND v(dout0_29) AT=1650.05n

* CHECK dout0_30 Vdout0_30ck164 = 0 time = 1650
.meas tran vdout0_30ck164 FIND v(dout0_30) AT=1650.05n

* CHECK dout0_31 Vdout0_31ck164 = 1.8 time = 1650
.meas tran vdout0_31ck164 FIND v(dout0_31) AT=1650.05n

* CHECK dout0_32 Vdout0_32ck164 = 0 time = 1650
.meas tran vdout0_32ck164 FIND v(dout0_32) AT=1650.05n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 1660
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=1660.05n

* CHECK dout0_1 Vdout0_1ck165 = 1.8 time = 1660
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=1660.05n

* CHECK dout0_2 Vdout0_2ck165 = 1.8 time = 1660
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=1660.05n

* CHECK dout0_3 Vdout0_3ck165 = 0 time = 1660
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=1660.05n

* CHECK dout0_4 Vdout0_4ck165 = 1.8 time = 1660
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=1660.05n

* CHECK dout0_5 Vdout0_5ck165 = 1.8 time = 1660
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=1660.05n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 1660
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=1660.05n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 1660
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=1660.05n

* CHECK dout0_8 Vdout0_8ck165 = 0 time = 1660
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=1660.05n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 1660
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=1660.05n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 1660
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=1660.05n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 1660
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=1660.05n

* CHECK dout0_12 Vdout0_12ck165 = 1.8 time = 1660
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=1660.05n

* CHECK dout0_13 Vdout0_13ck165 = 0 time = 1660
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=1660.05n

* CHECK dout0_14 Vdout0_14ck165 = 1.8 time = 1660
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=1660.05n

* CHECK dout0_15 Vdout0_15ck165 = 1.8 time = 1660
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=1660.05n

* CHECK dout0_16 Vdout0_16ck165 = 0 time = 1660
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=1660.05n

* CHECK dout0_17 Vdout0_17ck165 = 0 time = 1660
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=1660.05n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 1660
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=1660.05n

* CHECK dout0_19 Vdout0_19ck165 = 0 time = 1660
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=1660.05n

* CHECK dout0_20 Vdout0_20ck165 = 0 time = 1660
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=1660.05n

* CHECK dout0_21 Vdout0_21ck165 = 1.8 time = 1660
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=1660.05n

* CHECK dout0_22 Vdout0_22ck165 = 1.8 time = 1660
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=1660.05n

* CHECK dout0_23 Vdout0_23ck165 = 0 time = 1660
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=1660.05n

* CHECK dout0_24 Vdout0_24ck165 = 0 time = 1660
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=1660.05n

* CHECK dout0_25 Vdout0_25ck165 = 1.8 time = 1660
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=1660.05n

* CHECK dout0_26 Vdout0_26ck165 = 1.8 time = 1660
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=1660.05n

* CHECK dout0_27 Vdout0_27ck165 = 1.8 time = 1660
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=1660.05n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 1660
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=1660.05n

* CHECK dout0_29 Vdout0_29ck165 = 0 time = 1660
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=1660.05n

* CHECK dout0_30 Vdout0_30ck165 = 0 time = 1660
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=1660.05n

* CHECK dout0_31 Vdout0_31ck165 = 1.8 time = 1660
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=1660.05n

* CHECK dout0_32 Vdout0_32ck165 = 0 time = 1660
.meas tran vdout0_32ck165 FIND v(dout0_32) AT=1660.05n

* CHECK dout0_0 Vdout0_0ck167 = 0 time = 1680
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=1680.05n

* CHECK dout0_1 Vdout0_1ck167 = 0 time = 1680
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=1680.05n

* CHECK dout0_2 Vdout0_2ck167 = 0 time = 1680
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=1680.05n

* CHECK dout0_3 Vdout0_3ck167 = 1.8 time = 1680
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=1680.05n

* CHECK dout0_4 Vdout0_4ck167 = 0 time = 1680
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=1680.05n

* CHECK dout0_5 Vdout0_5ck167 = 0 time = 1680
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=1680.05n

* CHECK dout0_6 Vdout0_6ck167 = 1.8 time = 1680
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=1680.05n

* CHECK dout0_7 Vdout0_7ck167 = 0 time = 1680
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=1680.05n

* CHECK dout0_8 Vdout0_8ck167 = 0 time = 1680
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=1680.05n

* CHECK dout0_9 Vdout0_9ck167 = 1.8 time = 1680
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=1680.05n

* CHECK dout0_10 Vdout0_10ck167 = 1.8 time = 1680
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=1680.05n

* CHECK dout0_11 Vdout0_11ck167 = 0 time = 1680
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=1680.05n

* CHECK dout0_12 Vdout0_12ck167 = 1.8 time = 1680
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=1680.05n

* CHECK dout0_13 Vdout0_13ck167 = 0 time = 1680
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=1680.05n

* CHECK dout0_14 Vdout0_14ck167 = 1.8 time = 1680
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=1680.05n

* CHECK dout0_15 Vdout0_15ck167 = 0 time = 1680
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=1680.05n

* CHECK dout0_16 Vdout0_16ck167 = 1.8 time = 1680
.meas tran vdout0_16ck167 FIND v(dout0_16) AT=1680.05n

* CHECK dout0_17 Vdout0_17ck167 = 0 time = 1680
.meas tran vdout0_17ck167 FIND v(dout0_17) AT=1680.05n

* CHECK dout0_18 Vdout0_18ck167 = 1.8 time = 1680
.meas tran vdout0_18ck167 FIND v(dout0_18) AT=1680.05n

* CHECK dout0_19 Vdout0_19ck167 = 0 time = 1680
.meas tran vdout0_19ck167 FIND v(dout0_19) AT=1680.05n

* CHECK dout0_20 Vdout0_20ck167 = 1.8 time = 1680
.meas tran vdout0_20ck167 FIND v(dout0_20) AT=1680.05n

* CHECK dout0_21 Vdout0_21ck167 = 1.8 time = 1680
.meas tran vdout0_21ck167 FIND v(dout0_21) AT=1680.05n

* CHECK dout0_22 Vdout0_22ck167 = 1.8 time = 1680
.meas tran vdout0_22ck167 FIND v(dout0_22) AT=1680.05n

* CHECK dout0_23 Vdout0_23ck167 = 1.8 time = 1680
.meas tran vdout0_23ck167 FIND v(dout0_23) AT=1680.05n

* CHECK dout0_24 Vdout0_24ck167 = 1.8 time = 1680
.meas tran vdout0_24ck167 FIND v(dout0_24) AT=1680.05n

* CHECK dout0_25 Vdout0_25ck167 = 1.8 time = 1680
.meas tran vdout0_25ck167 FIND v(dout0_25) AT=1680.05n

* CHECK dout0_26 Vdout0_26ck167 = 0 time = 1680
.meas tran vdout0_26ck167 FIND v(dout0_26) AT=1680.05n

* CHECK dout0_27 Vdout0_27ck167 = 1.8 time = 1680
.meas tran vdout0_27ck167 FIND v(dout0_27) AT=1680.05n

* CHECK dout0_28 Vdout0_28ck167 = 1.8 time = 1680
.meas tran vdout0_28ck167 FIND v(dout0_28) AT=1680.05n

* CHECK dout0_29 Vdout0_29ck167 = 0 time = 1680
.meas tran vdout0_29ck167 FIND v(dout0_29) AT=1680.05n

* CHECK dout0_30 Vdout0_30ck167 = 1.8 time = 1680
.meas tran vdout0_30ck167 FIND v(dout0_30) AT=1680.05n

* CHECK dout0_31 Vdout0_31ck167 = 1.8 time = 1680
.meas tran vdout0_31ck167 FIND v(dout0_31) AT=1680.05n

* CHECK dout0_32 Vdout0_32ck167 = 0 time = 1680
.meas tran vdout0_32ck167 FIND v(dout0_32) AT=1680.05n

* CHECK dout0_0 Vdout0_0ck170 = 1.8 time = 1710
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=1710.05n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 1710
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=1710.05n

* CHECK dout0_2 Vdout0_2ck170 = 1.8 time = 1710
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=1710.05n

* CHECK dout0_3 Vdout0_3ck170 = 1.8 time = 1710
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=1710.05n

* CHECK dout0_4 Vdout0_4ck170 = 1.8 time = 1710
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=1710.05n

* CHECK dout0_5 Vdout0_5ck170 = 0 time = 1710
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=1710.05n

* CHECK dout0_6 Vdout0_6ck170 = 0 time = 1710
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=1710.05n

* CHECK dout0_7 Vdout0_7ck170 = 1.8 time = 1710
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=1710.05n

* CHECK dout0_8 Vdout0_8ck170 = 1.8 time = 1710
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=1710.05n

* CHECK dout0_9 Vdout0_9ck170 = 1.8 time = 1710
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=1710.05n

* CHECK dout0_10 Vdout0_10ck170 = 1.8 time = 1710
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=1710.05n

* CHECK dout0_11 Vdout0_11ck170 = 1.8 time = 1710
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=1710.05n

* CHECK dout0_12 Vdout0_12ck170 = 1.8 time = 1710
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=1710.05n

* CHECK dout0_13 Vdout0_13ck170 = 1.8 time = 1710
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=1710.05n

* CHECK dout0_14 Vdout0_14ck170 = 1.8 time = 1710
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=1710.05n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 1710
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=1710.05n

* CHECK dout0_16 Vdout0_16ck170 = 1.8 time = 1710
.meas tran vdout0_16ck170 FIND v(dout0_16) AT=1710.05n

* CHECK dout0_17 Vdout0_17ck170 = 0 time = 1710
.meas tran vdout0_17ck170 FIND v(dout0_17) AT=1710.05n

* CHECK dout0_18 Vdout0_18ck170 = 1.8 time = 1710
.meas tran vdout0_18ck170 FIND v(dout0_18) AT=1710.05n

* CHECK dout0_19 Vdout0_19ck170 = 0 time = 1710
.meas tran vdout0_19ck170 FIND v(dout0_19) AT=1710.05n

* CHECK dout0_20 Vdout0_20ck170 = 1.8 time = 1710
.meas tran vdout0_20ck170 FIND v(dout0_20) AT=1710.05n

* CHECK dout0_21 Vdout0_21ck170 = 0 time = 1710
.meas tran vdout0_21ck170 FIND v(dout0_21) AT=1710.05n

* CHECK dout0_22 Vdout0_22ck170 = 1.8 time = 1710
.meas tran vdout0_22ck170 FIND v(dout0_22) AT=1710.05n

* CHECK dout0_23 Vdout0_23ck170 = 1.8 time = 1710
.meas tran vdout0_23ck170 FIND v(dout0_23) AT=1710.05n

* CHECK dout0_24 Vdout0_24ck170 = 0 time = 1710
.meas tran vdout0_24ck170 FIND v(dout0_24) AT=1710.05n

* CHECK dout0_25 Vdout0_25ck170 = 0 time = 1710
.meas tran vdout0_25ck170 FIND v(dout0_25) AT=1710.05n

* CHECK dout0_26 Vdout0_26ck170 = 1.8 time = 1710
.meas tran vdout0_26ck170 FIND v(dout0_26) AT=1710.05n

* CHECK dout0_27 Vdout0_27ck170 = 1.8 time = 1710
.meas tran vdout0_27ck170 FIND v(dout0_27) AT=1710.05n

* CHECK dout0_28 Vdout0_28ck170 = 0 time = 1710
.meas tran vdout0_28ck170 FIND v(dout0_28) AT=1710.05n

* CHECK dout0_29 Vdout0_29ck170 = 0 time = 1710
.meas tran vdout0_29ck170 FIND v(dout0_29) AT=1710.05n

* CHECK dout0_30 Vdout0_30ck170 = 0 time = 1710
.meas tran vdout0_30ck170 FIND v(dout0_30) AT=1710.05n

* CHECK dout0_31 Vdout0_31ck170 = 1.8 time = 1710
.meas tran vdout0_31ck170 FIND v(dout0_31) AT=1710.05n

* CHECK dout0_32 Vdout0_32ck170 = 0 time = 1710
.meas tran vdout0_32ck170 FIND v(dout0_32) AT=1710.05n

* CHECK dout0_0 Vdout0_0ck172 = 1.8 time = 1730
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=1730.05n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 1730
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=1730.05n

* CHECK dout0_2 Vdout0_2ck172 = 1.8 time = 1730
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=1730.05n

* CHECK dout0_3 Vdout0_3ck172 = 0 time = 1730
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=1730.05n

* CHECK dout0_4 Vdout0_4ck172 = 0 time = 1730
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=1730.05n

* CHECK dout0_5 Vdout0_5ck172 = 0 time = 1730
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=1730.05n

* CHECK dout0_6 Vdout0_6ck172 = 1.8 time = 1730
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=1730.05n

* CHECK dout0_7 Vdout0_7ck172 = 1.8 time = 1730
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=1730.05n

* CHECK dout0_8 Vdout0_8ck172 = 0 time = 1730
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=1730.05n

* CHECK dout0_9 Vdout0_9ck172 = 0 time = 1730
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=1730.05n

* CHECK dout0_10 Vdout0_10ck172 = 0 time = 1730
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=1730.05n

* CHECK dout0_11 Vdout0_11ck172 = 0 time = 1730
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=1730.05n

* CHECK dout0_12 Vdout0_12ck172 = 0 time = 1730
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=1730.05n

* CHECK dout0_13 Vdout0_13ck172 = 0 time = 1730
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=1730.05n

* CHECK dout0_14 Vdout0_14ck172 = 1.8 time = 1730
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=1730.05n

* CHECK dout0_15 Vdout0_15ck172 = 1.8 time = 1730
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=1730.05n

* CHECK dout0_16 Vdout0_16ck172 = 1.8 time = 1730
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=1730.05n

* CHECK dout0_17 Vdout0_17ck172 = 0 time = 1730
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=1730.05n

* CHECK dout0_18 Vdout0_18ck172 = 1.8 time = 1730
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=1730.05n

* CHECK dout0_19 Vdout0_19ck172 = 0 time = 1730
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=1730.05n

* CHECK dout0_20 Vdout0_20ck172 = 1.8 time = 1730
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=1730.05n

* CHECK dout0_21 Vdout0_21ck172 = 1.8 time = 1730
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=1730.05n

* CHECK dout0_22 Vdout0_22ck172 = 0 time = 1730
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=1730.05n

* CHECK dout0_23 Vdout0_23ck172 = 0 time = 1730
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=1730.05n

* CHECK dout0_24 Vdout0_24ck172 = 1.8 time = 1730
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=1730.05n

* CHECK dout0_25 Vdout0_25ck172 = 1.8 time = 1730
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=1730.05n

* CHECK dout0_26 Vdout0_26ck172 = 0 time = 1730
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=1730.05n

* CHECK dout0_27 Vdout0_27ck172 = 0 time = 1730
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=1730.05n

* CHECK dout0_28 Vdout0_28ck172 = 1.8 time = 1730
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=1730.05n

* CHECK dout0_29 Vdout0_29ck172 = 1.8 time = 1730
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=1730.05n

* CHECK dout0_30 Vdout0_30ck172 = 1.8 time = 1730
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=1730.05n

* CHECK dout0_31 Vdout0_31ck172 = 0 time = 1730
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=1730.05n

* CHECK dout0_32 Vdout0_32ck172 = 0 time = 1730
.meas tran vdout0_32ck172 FIND v(dout0_32) AT=1730.05n

* CHECK dout0_0 Vdout0_0ck175 = 1.8 time = 1760
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=1760.05n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 1760
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=1760.05n

* CHECK dout0_2 Vdout0_2ck175 = 1.8 time = 1760
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=1760.05n

* CHECK dout0_3 Vdout0_3ck175 = 1.8 time = 1760
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=1760.05n

* CHECK dout0_4 Vdout0_4ck175 = 1.8 time = 1760
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=1760.05n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 1760
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=1760.05n

* CHECK dout0_6 Vdout0_6ck175 = 1.8 time = 1760
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=1760.05n

* CHECK dout0_7 Vdout0_7ck175 = 1.8 time = 1760
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=1760.05n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 1760
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=1760.05n

* CHECK dout0_9 Vdout0_9ck175 = 0 time = 1760
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=1760.05n

* CHECK dout0_10 Vdout0_10ck175 = 0 time = 1760
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=1760.05n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 1760
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=1760.05n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 1760
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=1760.05n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 1760
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=1760.05n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 1760
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=1760.05n

* CHECK dout0_15 Vdout0_15ck175 = 1.8 time = 1760
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=1760.05n

* CHECK dout0_16 Vdout0_16ck175 = 1.8 time = 1760
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=1760.05n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 1760
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=1760.05n

* CHECK dout0_18 Vdout0_18ck175 = 1.8 time = 1760
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=1760.05n

* CHECK dout0_19 Vdout0_19ck175 = 0 time = 1760
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=1760.05n

* CHECK dout0_20 Vdout0_20ck175 = 1.8 time = 1760
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=1760.05n

* CHECK dout0_21 Vdout0_21ck175 = 1.8 time = 1760
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=1760.05n

* CHECK dout0_22 Vdout0_22ck175 = 1.8 time = 1760
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=1760.05n

* CHECK dout0_23 Vdout0_23ck175 = 1.8 time = 1760
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=1760.05n

* CHECK dout0_24 Vdout0_24ck175 = 1.8 time = 1760
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=1760.05n

* CHECK dout0_25 Vdout0_25ck175 = 1.8 time = 1760
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=1760.05n

* CHECK dout0_26 Vdout0_26ck175 = 0 time = 1760
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=1760.05n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 1760
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=1760.05n

* CHECK dout0_28 Vdout0_28ck175 = 1.8 time = 1760
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=1760.05n

* CHECK dout0_29 Vdout0_29ck175 = 1.8 time = 1760
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=1760.05n

* CHECK dout0_30 Vdout0_30ck175 = 0 time = 1760
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=1760.05n

* CHECK dout0_31 Vdout0_31ck175 = 1.8 time = 1760
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=1760.05n

* CHECK dout0_32 Vdout0_32ck175 = 0 time = 1760
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=1760.05n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 1770
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=1770.05n

* CHECK dout0_1 Vdout0_1ck176 = 0 time = 1770
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=1770.05n

* CHECK dout0_2 Vdout0_2ck176 = 1.8 time = 1770
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=1770.05n

* CHECK dout0_3 Vdout0_3ck176 = 0 time = 1770
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=1770.05n

* CHECK dout0_4 Vdout0_4ck176 = 1.8 time = 1770
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=1770.05n

* CHECK dout0_5 Vdout0_5ck176 = 0 time = 1770
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=1770.05n

* CHECK dout0_6 Vdout0_6ck176 = 1.8 time = 1770
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=1770.05n

* CHECK dout0_7 Vdout0_7ck176 = 1.8 time = 1770
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=1770.05n

* CHECK dout0_8 Vdout0_8ck176 = 1.8 time = 1770
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=1770.05n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 1770
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=1770.05n

* CHECK dout0_10 Vdout0_10ck176 = 0 time = 1770
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=1770.05n

* CHECK dout0_11 Vdout0_11ck176 = 1.8 time = 1770
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=1770.05n

* CHECK dout0_12 Vdout0_12ck176 = 0 time = 1770
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=1770.05n

* CHECK dout0_13 Vdout0_13ck176 = 1.8 time = 1770
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=1770.05n

* CHECK dout0_14 Vdout0_14ck176 = 1.8 time = 1770
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=1770.05n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 1770
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=1770.05n

* CHECK dout0_16 Vdout0_16ck176 = 1.8 time = 1770
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=1770.05n

* CHECK dout0_17 Vdout0_17ck176 = 1.8 time = 1770
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=1770.05n

* CHECK dout0_18 Vdout0_18ck176 = 0 time = 1770
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=1770.05n

* CHECK dout0_19 Vdout0_19ck176 = 0 time = 1770
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=1770.05n

* CHECK dout0_20 Vdout0_20ck176 = 0 time = 1770
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=1770.05n

* CHECK dout0_21 Vdout0_21ck176 = 0 time = 1770
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=1770.05n

* CHECK dout0_22 Vdout0_22ck176 = 1.8 time = 1770
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=1770.05n

* CHECK dout0_23 Vdout0_23ck176 = 1.8 time = 1770
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=1770.05n

* CHECK dout0_24 Vdout0_24ck176 = 0 time = 1770
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=1770.05n

* CHECK dout0_25 Vdout0_25ck176 = 0 time = 1770
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=1770.05n

* CHECK dout0_26 Vdout0_26ck176 = 1.8 time = 1770
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=1770.05n

* CHECK dout0_27 Vdout0_27ck176 = 0 time = 1770
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=1770.05n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 1770
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=1770.05n

* CHECK dout0_29 Vdout0_29ck176 = 1.8 time = 1770
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=1770.05n

* CHECK dout0_30 Vdout0_30ck176 = 1.8 time = 1770
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=1770.05n

* CHECK dout0_31 Vdout0_31ck176 = 1.8 time = 1770
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=1770.05n

* CHECK dout0_32 Vdout0_32ck176 = 0 time = 1770
.meas tran vdout0_32ck176 FIND v(dout0_32) AT=1770.05n

* CHECK dout0_0 Vdout0_0ck179 = 0 time = 1800
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=1800.05n

* CHECK dout0_1 Vdout0_1ck179 = 1.8 time = 1800
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=1800.05n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 1800
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=1800.05n

* CHECK dout0_3 Vdout0_3ck179 = 1.8 time = 1800
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=1800.05n

* CHECK dout0_4 Vdout0_4ck179 = 1.8 time = 1800
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=1800.05n

* CHECK dout0_5 Vdout0_5ck179 = 0 time = 1800
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=1800.05n

* CHECK dout0_6 Vdout0_6ck179 = 0 time = 1800
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=1800.05n

* CHECK dout0_7 Vdout0_7ck179 = 1.8 time = 1800
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=1800.05n

* CHECK dout0_8 Vdout0_8ck179 = 0 time = 1800
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=1800.05n

* CHECK dout0_9 Vdout0_9ck179 = 1.8 time = 1800
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=1800.05n

* CHECK dout0_10 Vdout0_10ck179 = 0 time = 1800
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=1800.05n

* CHECK dout0_11 Vdout0_11ck179 = 0 time = 1800
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=1800.05n

* CHECK dout0_12 Vdout0_12ck179 = 1.8 time = 1800
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=1800.05n

* CHECK dout0_13 Vdout0_13ck179 = 1.8 time = 1800
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=1800.05n

* CHECK dout0_14 Vdout0_14ck179 = 1.8 time = 1800
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=1800.05n

* CHECK dout0_15 Vdout0_15ck179 = 1.8 time = 1800
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=1800.05n

* CHECK dout0_16 Vdout0_16ck179 = 1.8 time = 1800
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=1800.05n

* CHECK dout0_17 Vdout0_17ck179 = 1.8 time = 1800
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=1800.05n

* CHECK dout0_18 Vdout0_18ck179 = 1.8 time = 1800
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=1800.05n

* CHECK dout0_19 Vdout0_19ck179 = 1.8 time = 1800
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=1800.05n

* CHECK dout0_20 Vdout0_20ck179 = 1.8 time = 1800
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=1800.05n

* CHECK dout0_21 Vdout0_21ck179 = 0 time = 1800
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=1800.05n

* CHECK dout0_22 Vdout0_22ck179 = 1.8 time = 1800
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=1800.05n

* CHECK dout0_23 Vdout0_23ck179 = 1.8 time = 1800
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=1800.05n

* CHECK dout0_24 Vdout0_24ck179 = 0 time = 1800
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=1800.05n

* CHECK dout0_25 Vdout0_25ck179 = 0 time = 1800
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=1800.05n

* CHECK dout0_26 Vdout0_26ck179 = 1.8 time = 1800
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=1800.05n

* CHECK dout0_27 Vdout0_27ck179 = 0 time = 1800
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=1800.05n

* CHECK dout0_28 Vdout0_28ck179 = 1.8 time = 1800
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=1800.05n

* CHECK dout0_29 Vdout0_29ck179 = 1.8 time = 1800
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=1800.05n

* CHECK dout0_30 Vdout0_30ck179 = 1.8 time = 1800
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=1800.05n

* CHECK dout0_31 Vdout0_31ck179 = 0 time = 1800
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=1800.05n

* CHECK dout0_32 Vdout0_32ck179 = 0 time = 1800
.meas tran vdout0_32ck179 FIND v(dout0_32) AT=1800.05n

* CHECK dout0_0 Vdout0_0ck182 = 0 time = 1830
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=1830.05n

* CHECK dout0_1 Vdout0_1ck182 = 1.8 time = 1830
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=1830.05n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 1830
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=1830.05n

* CHECK dout0_3 Vdout0_3ck182 = 1.8 time = 1830
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=1830.05n

* CHECK dout0_4 Vdout0_4ck182 = 1.8 time = 1830
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=1830.05n

* CHECK dout0_5 Vdout0_5ck182 = 1.8 time = 1830
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=1830.05n

* CHECK dout0_6 Vdout0_6ck182 = 0 time = 1830
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=1830.05n

* CHECK dout0_7 Vdout0_7ck182 = 1.8 time = 1830
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=1830.05n

* CHECK dout0_8 Vdout0_8ck182 = 0 time = 1830
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=1830.05n

* CHECK dout0_9 Vdout0_9ck182 = 0 time = 1830
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=1830.05n

* CHECK dout0_10 Vdout0_10ck182 = 1.8 time = 1830
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=1830.05n

* CHECK dout0_11 Vdout0_11ck182 = 1.8 time = 1830
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=1830.05n

* CHECK dout0_12 Vdout0_12ck182 = 0 time = 1830
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=1830.05n

* CHECK dout0_13 Vdout0_13ck182 = 0 time = 1830
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=1830.05n

* CHECK dout0_14 Vdout0_14ck182 = 1.8 time = 1830
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=1830.05n

* CHECK dout0_15 Vdout0_15ck182 = 1.8 time = 1830
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=1830.05n

* CHECK dout0_16 Vdout0_16ck182 = 1.8 time = 1830
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=1830.05n

* CHECK dout0_17 Vdout0_17ck182 = 0 time = 1830
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=1830.05n

* CHECK dout0_18 Vdout0_18ck182 = 1.8 time = 1830
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=1830.05n

* CHECK dout0_19 Vdout0_19ck182 = 1.8 time = 1830
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=1830.05n

* CHECK dout0_20 Vdout0_20ck182 = 1.8 time = 1830
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=1830.05n

* CHECK dout0_21 Vdout0_21ck182 = 1.8 time = 1830
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=1830.05n

* CHECK dout0_22 Vdout0_22ck182 = 1.8 time = 1830
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=1830.05n

* CHECK dout0_23 Vdout0_23ck182 = 1.8 time = 1830
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=1830.05n

* CHECK dout0_24 Vdout0_24ck182 = 1.8 time = 1830
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=1830.05n

* CHECK dout0_25 Vdout0_25ck182 = 0 time = 1830
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=1830.05n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 1830
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=1830.05n

* CHECK dout0_27 Vdout0_27ck182 = 1.8 time = 1830
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=1830.05n

* CHECK dout0_28 Vdout0_28ck182 = 0 time = 1830
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=1830.05n

* CHECK dout0_29 Vdout0_29ck182 = 1.8 time = 1830
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=1830.05n

* CHECK dout0_30 Vdout0_30ck182 = 0 time = 1830
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=1830.05n

* CHECK dout0_31 Vdout0_31ck182 = 1.8 time = 1830
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=1830.05n

* CHECK dout0_32 Vdout0_32ck182 = 0 time = 1830
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=1830.05n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 1840
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=1840.05n

* CHECK dout0_1 Vdout0_1ck183 = 0 time = 1840
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=1840.05n

* CHECK dout0_2 Vdout0_2ck183 = 0 time = 1840
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=1840.05n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 1840
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=1840.05n

* CHECK dout0_4 Vdout0_4ck183 = 0 time = 1840
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=1840.05n

* CHECK dout0_5 Vdout0_5ck183 = 0 time = 1840
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=1840.05n

* CHECK dout0_6 Vdout0_6ck183 = 1.8 time = 1840
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=1840.05n

* CHECK dout0_7 Vdout0_7ck183 = 0 time = 1840
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=1840.05n

* CHECK dout0_8 Vdout0_8ck183 = 0 time = 1840
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=1840.05n

* CHECK dout0_9 Vdout0_9ck183 = 1.8 time = 1840
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=1840.05n

* CHECK dout0_10 Vdout0_10ck183 = 1.8 time = 1840
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=1840.05n

* CHECK dout0_11 Vdout0_11ck183 = 0 time = 1840
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=1840.05n

* CHECK dout0_12 Vdout0_12ck183 = 1.8 time = 1840
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=1840.05n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 1840
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=1840.05n

* CHECK dout0_14 Vdout0_14ck183 = 1.8 time = 1840
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=1840.05n

* CHECK dout0_15 Vdout0_15ck183 = 0 time = 1840
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=1840.05n

* CHECK dout0_16 Vdout0_16ck183 = 1.8 time = 1840
.meas tran vdout0_16ck183 FIND v(dout0_16) AT=1840.05n

* CHECK dout0_17 Vdout0_17ck183 = 0 time = 1840
.meas tran vdout0_17ck183 FIND v(dout0_17) AT=1840.05n

* CHECK dout0_18 Vdout0_18ck183 = 1.8 time = 1840
.meas tran vdout0_18ck183 FIND v(dout0_18) AT=1840.05n

* CHECK dout0_19 Vdout0_19ck183 = 0 time = 1840
.meas tran vdout0_19ck183 FIND v(dout0_19) AT=1840.05n

* CHECK dout0_20 Vdout0_20ck183 = 1.8 time = 1840
.meas tran vdout0_20ck183 FIND v(dout0_20) AT=1840.05n

* CHECK dout0_21 Vdout0_21ck183 = 1.8 time = 1840
.meas tran vdout0_21ck183 FIND v(dout0_21) AT=1840.05n

* CHECK dout0_22 Vdout0_22ck183 = 1.8 time = 1840
.meas tran vdout0_22ck183 FIND v(dout0_22) AT=1840.05n

* CHECK dout0_23 Vdout0_23ck183 = 1.8 time = 1840
.meas tran vdout0_23ck183 FIND v(dout0_23) AT=1840.05n

* CHECK dout0_24 Vdout0_24ck183 = 1.8 time = 1840
.meas tran vdout0_24ck183 FIND v(dout0_24) AT=1840.05n

* CHECK dout0_25 Vdout0_25ck183 = 1.8 time = 1840
.meas tran vdout0_25ck183 FIND v(dout0_25) AT=1840.05n

* CHECK dout0_26 Vdout0_26ck183 = 0 time = 1840
.meas tran vdout0_26ck183 FIND v(dout0_26) AT=1840.05n

* CHECK dout0_27 Vdout0_27ck183 = 1.8 time = 1840
.meas tran vdout0_27ck183 FIND v(dout0_27) AT=1840.05n

* CHECK dout0_28 Vdout0_28ck183 = 1.8 time = 1840
.meas tran vdout0_28ck183 FIND v(dout0_28) AT=1840.05n

* CHECK dout0_29 Vdout0_29ck183 = 0 time = 1840
.meas tran vdout0_29ck183 FIND v(dout0_29) AT=1840.05n

* CHECK dout0_30 Vdout0_30ck183 = 1.8 time = 1840
.meas tran vdout0_30ck183 FIND v(dout0_30) AT=1840.05n

* CHECK dout0_31 Vdout0_31ck183 = 1.8 time = 1840
.meas tran vdout0_31ck183 FIND v(dout0_31) AT=1840.05n

* CHECK dout0_32 Vdout0_32ck183 = 0 time = 1840
.meas tran vdout0_32ck183 FIND v(dout0_32) AT=1840.05n

* CHECK dout0_0 Vdout0_0ck188 = 1.8 time = 1890
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=1890.05n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 1890
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=1890.05n

* CHECK dout0_2 Vdout0_2ck188 = 1.8 time = 1890
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=1890.05n

* CHECK dout0_3 Vdout0_3ck188 = 1.8 time = 1890
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=1890.05n

* CHECK dout0_4 Vdout0_4ck188 = 1.8 time = 1890
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=1890.05n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 1890
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=1890.05n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 1890
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=1890.05n

* CHECK dout0_7 Vdout0_7ck188 = 1.8 time = 1890
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=1890.05n

* CHECK dout0_8 Vdout0_8ck188 = 0 time = 1890
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=1890.05n

* CHECK dout0_9 Vdout0_9ck188 = 1.8 time = 1890
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=1890.05n

* CHECK dout0_10 Vdout0_10ck188 = 1.8 time = 1890
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=1890.05n

* CHECK dout0_11 Vdout0_11ck188 = 0 time = 1890
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=1890.05n

* CHECK dout0_12 Vdout0_12ck188 = 1.8 time = 1890
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=1890.05n

* CHECK dout0_13 Vdout0_13ck188 = 1.8 time = 1890
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=1890.05n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 1890
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=1890.05n

* CHECK dout0_15 Vdout0_15ck188 = 1.8 time = 1890
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=1890.05n

* CHECK dout0_16 Vdout0_16ck188 = 1.8 time = 1890
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=1890.05n

* CHECK dout0_17 Vdout0_17ck188 = 0 time = 1890
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=1890.05n

* CHECK dout0_18 Vdout0_18ck188 = 1.8 time = 1890
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=1890.05n

* CHECK dout0_19 Vdout0_19ck188 = 0 time = 1890
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=1890.05n

* CHECK dout0_20 Vdout0_20ck188 = 1.8 time = 1890
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=1890.05n

* CHECK dout0_21 Vdout0_21ck188 = 0 time = 1890
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=1890.05n

* CHECK dout0_22 Vdout0_22ck188 = 1.8 time = 1890
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=1890.05n

* CHECK dout0_23 Vdout0_23ck188 = 1.8 time = 1890
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=1890.05n

* CHECK dout0_24 Vdout0_24ck188 = 1.8 time = 1890
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=1890.05n

* CHECK dout0_25 Vdout0_25ck188 = 1.8 time = 1890
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=1890.05n

* CHECK dout0_26 Vdout0_26ck188 = 0 time = 1890
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=1890.05n

* CHECK dout0_27 Vdout0_27ck188 = 0 time = 1890
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=1890.05n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 1890
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=1890.05n

* CHECK dout0_29 Vdout0_29ck188 = 1.8 time = 1890
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=1890.05n

* CHECK dout0_30 Vdout0_30ck188 = 1.8 time = 1890
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=1890.05n

* CHECK dout0_31 Vdout0_31ck188 = 1.8 time = 1890
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=1890.05n

* CHECK dout0_32 Vdout0_32ck188 = 0 time = 1890
.meas tran vdout0_32ck188 FIND v(dout0_32) AT=1890.05n

* CHECK dout0_0 Vdout0_0ck190 = 0 time = 1910
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=1910.05n

* CHECK dout0_1 Vdout0_1ck190 = 1.8 time = 1910
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=1910.05n

* CHECK dout0_2 Vdout0_2ck190 = 0 time = 1910
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=1910.05n

* CHECK dout0_3 Vdout0_3ck190 = 0 time = 1910
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=1910.05n

* CHECK dout0_4 Vdout0_4ck190 = 1.8 time = 1910
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=1910.05n

* CHECK dout0_5 Vdout0_5ck190 = 0 time = 1910
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=1910.05n

* CHECK dout0_6 Vdout0_6ck190 = 1.8 time = 1910
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=1910.05n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 1910
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=1910.05n

* CHECK dout0_8 Vdout0_8ck190 = 0 time = 1910
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=1910.05n

* CHECK dout0_9 Vdout0_9ck190 = 0 time = 1910
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=1910.05n

* CHECK dout0_10 Vdout0_10ck190 = 1.8 time = 1910
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=1910.05n

* CHECK dout0_11 Vdout0_11ck190 = 1.8 time = 1910
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=1910.05n

* CHECK dout0_12 Vdout0_12ck190 = 0 time = 1910
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=1910.05n

* CHECK dout0_13 Vdout0_13ck190 = 1.8 time = 1910
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=1910.05n

* CHECK dout0_14 Vdout0_14ck190 = 0 time = 1910
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=1910.05n

* CHECK dout0_15 Vdout0_15ck190 = 1.8 time = 1910
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=1910.05n

* CHECK dout0_16 Vdout0_16ck190 = 1.8 time = 1910
.meas tran vdout0_16ck190 FIND v(dout0_16) AT=1910.05n

* CHECK dout0_17 Vdout0_17ck190 = 0 time = 1910
.meas tran vdout0_17ck190 FIND v(dout0_17) AT=1910.05n

* CHECK dout0_18 Vdout0_18ck190 = 0 time = 1910
.meas tran vdout0_18ck190 FIND v(dout0_18) AT=1910.05n

* CHECK dout0_19 Vdout0_19ck190 = 1.8 time = 1910
.meas tran vdout0_19ck190 FIND v(dout0_19) AT=1910.05n

* CHECK dout0_20 Vdout0_20ck190 = 1.8 time = 1910
.meas tran vdout0_20ck190 FIND v(dout0_20) AT=1910.05n

* CHECK dout0_21 Vdout0_21ck190 = 1.8 time = 1910
.meas tran vdout0_21ck190 FIND v(dout0_21) AT=1910.05n

* CHECK dout0_22 Vdout0_22ck190 = 1.8 time = 1910
.meas tran vdout0_22ck190 FIND v(dout0_22) AT=1910.05n

* CHECK dout0_23 Vdout0_23ck190 = 0 time = 1910
.meas tran vdout0_23ck190 FIND v(dout0_23) AT=1910.05n

* CHECK dout0_24 Vdout0_24ck190 = 0 time = 1910
.meas tran vdout0_24ck190 FIND v(dout0_24) AT=1910.05n

* CHECK dout0_25 Vdout0_25ck190 = 0 time = 1910
.meas tran vdout0_25ck190 FIND v(dout0_25) AT=1910.05n

* CHECK dout0_26 Vdout0_26ck190 = 0 time = 1910
.meas tran vdout0_26ck190 FIND v(dout0_26) AT=1910.05n

* CHECK dout0_27 Vdout0_27ck190 = 0 time = 1910
.meas tran vdout0_27ck190 FIND v(dout0_27) AT=1910.05n

* CHECK dout0_28 Vdout0_28ck190 = 1.8 time = 1910
.meas tran vdout0_28ck190 FIND v(dout0_28) AT=1910.05n

* CHECK dout0_29 Vdout0_29ck190 = 0 time = 1910
.meas tran vdout0_29ck190 FIND v(dout0_29) AT=1910.05n

* CHECK dout0_30 Vdout0_30ck190 = 0 time = 1910
.meas tran vdout0_30ck190 FIND v(dout0_30) AT=1910.05n

* CHECK dout0_31 Vdout0_31ck190 = 1.8 time = 1910
.meas tran vdout0_31ck190 FIND v(dout0_31) AT=1910.05n

* CHECK dout0_32 Vdout0_32ck190 = 0 time = 1910
.meas tran vdout0_32ck190 FIND v(dout0_32) AT=1910.05n

* CHECK dout0_0 Vdout0_0ck191 = 1.8 time = 1920
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=1920.05n

* CHECK dout0_1 Vdout0_1ck191 = 0 time = 1920
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=1920.05n

* CHECK dout0_2 Vdout0_2ck191 = 1.8 time = 1920
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=1920.05n

* CHECK dout0_3 Vdout0_3ck191 = 1.8 time = 1920
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=1920.05n

* CHECK dout0_4 Vdout0_4ck191 = 1.8 time = 1920
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=1920.05n

* CHECK dout0_5 Vdout0_5ck191 = 0 time = 1920
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=1920.05n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 1920
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=1920.05n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 1920
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=1920.05n

* CHECK dout0_8 Vdout0_8ck191 = 0 time = 1920
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=1920.05n

* CHECK dout0_9 Vdout0_9ck191 = 1.8 time = 1920
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=1920.05n

* CHECK dout0_10 Vdout0_10ck191 = 1.8 time = 1920
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=1920.05n

* CHECK dout0_11 Vdout0_11ck191 = 0 time = 1920
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=1920.05n

* CHECK dout0_12 Vdout0_12ck191 = 1.8 time = 1920
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=1920.05n

* CHECK dout0_13 Vdout0_13ck191 = 1.8 time = 1920
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=1920.05n

* CHECK dout0_14 Vdout0_14ck191 = 0 time = 1920
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=1920.05n

* CHECK dout0_15 Vdout0_15ck191 = 1.8 time = 1920
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=1920.05n

* CHECK dout0_16 Vdout0_16ck191 = 1.8 time = 1920
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=1920.05n

* CHECK dout0_17 Vdout0_17ck191 = 0 time = 1920
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=1920.05n

* CHECK dout0_18 Vdout0_18ck191 = 1.8 time = 1920
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=1920.05n

* CHECK dout0_19 Vdout0_19ck191 = 0 time = 1920
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=1920.05n

* CHECK dout0_20 Vdout0_20ck191 = 1.8 time = 1920
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=1920.05n

* CHECK dout0_21 Vdout0_21ck191 = 0 time = 1920
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=1920.05n

* CHECK dout0_22 Vdout0_22ck191 = 1.8 time = 1920
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=1920.05n

* CHECK dout0_23 Vdout0_23ck191 = 1.8 time = 1920
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=1920.05n

* CHECK dout0_24 Vdout0_24ck191 = 1.8 time = 1920
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=1920.05n

* CHECK dout0_25 Vdout0_25ck191 = 1.8 time = 1920
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=1920.05n

* CHECK dout0_26 Vdout0_26ck191 = 0 time = 1920
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=1920.05n

* CHECK dout0_27 Vdout0_27ck191 = 0 time = 1920
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=1920.05n

* CHECK dout0_28 Vdout0_28ck191 = 0 time = 1920
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=1920.05n

* CHECK dout0_29 Vdout0_29ck191 = 1.8 time = 1920
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=1920.05n

* CHECK dout0_30 Vdout0_30ck191 = 1.8 time = 1920
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=1920.05n

* CHECK dout0_31 Vdout0_31ck191 = 1.8 time = 1920
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=1920.05n

* CHECK dout0_32 Vdout0_32ck191 = 0 time = 1920
.meas tran vdout0_32ck191 FIND v(dout0_32) AT=1920.05n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 1930
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=1930.05n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 1930
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=1930.05n

* CHECK dout0_2 Vdout0_2ck192 = 1.8 time = 1930
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=1930.05n

* CHECK dout0_3 Vdout0_3ck192 = 1.8 time = 1930
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=1930.05n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 1930
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=1930.05n

* CHECK dout0_5 Vdout0_5ck192 = 1.8 time = 1930
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=1930.05n

* CHECK dout0_6 Vdout0_6ck192 = 1.8 time = 1930
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=1930.05n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 1930
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=1930.05n

* CHECK dout0_8 Vdout0_8ck192 = 0 time = 1930
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=1930.05n

* CHECK dout0_9 Vdout0_9ck192 = 1.8 time = 1930
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=1930.05n

* CHECK dout0_10 Vdout0_10ck192 = 1.8 time = 1930
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=1930.05n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 1930
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=1930.05n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 1930
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=1930.05n

* CHECK dout0_13 Vdout0_13ck192 = 1.8 time = 1930
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=1930.05n

* CHECK dout0_14 Vdout0_14ck192 = 1.8 time = 1930
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=1930.05n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 1930
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=1930.05n

* CHECK dout0_16 Vdout0_16ck192 = 1.8 time = 1930
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=1930.05n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 1930
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=1930.05n

* CHECK dout0_18 Vdout0_18ck192 = 0 time = 1930
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=1930.05n

* CHECK dout0_19 Vdout0_19ck192 = 0 time = 1930
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=1930.05n

* CHECK dout0_20 Vdout0_20ck192 = 0 time = 1930
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=1930.05n

* CHECK dout0_21 Vdout0_21ck192 = 1.8 time = 1930
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=1930.05n

* CHECK dout0_22 Vdout0_22ck192 = 0 time = 1930
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=1930.05n

* CHECK dout0_23 Vdout0_23ck192 = 0 time = 1930
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=1930.05n

* CHECK dout0_24 Vdout0_24ck192 = 1.8 time = 1930
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=1930.05n

* CHECK dout0_25 Vdout0_25ck192 = 1.8 time = 1930
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=1930.05n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 1930
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=1930.05n

* CHECK dout0_27 Vdout0_27ck192 = 1.8 time = 1930
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=1930.05n

* CHECK dout0_28 Vdout0_28ck192 = 0 time = 1930
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=1930.05n

* CHECK dout0_29 Vdout0_29ck192 = 1.8 time = 1930
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=1930.05n

* CHECK dout0_30 Vdout0_30ck192 = 1.8 time = 1930
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=1930.05n

* CHECK dout0_31 Vdout0_31ck192 = 0 time = 1930
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=1930.05n

* CHECK dout0_32 Vdout0_32ck192 = 0 time = 1930
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=1930.05n

* CHECK dout0_0 Vdout0_0ck194 = 0 time = 1950
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=1950.05n

* CHECK dout0_1 Vdout0_1ck194 = 0 time = 1950
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=1950.05n

* CHECK dout0_2 Vdout0_2ck194 = 0 time = 1950
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=1950.05n

* CHECK dout0_3 Vdout0_3ck194 = 1.8 time = 1950
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=1950.05n

* CHECK dout0_4 Vdout0_4ck194 = 0 time = 1950
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=1950.05n

* CHECK dout0_5 Vdout0_5ck194 = 0 time = 1950
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=1950.05n

* CHECK dout0_6 Vdout0_6ck194 = 1.8 time = 1950
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=1950.05n

* CHECK dout0_7 Vdout0_7ck194 = 0 time = 1950
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=1950.05n

* CHECK dout0_8 Vdout0_8ck194 = 0 time = 1950
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=1950.05n

* CHECK dout0_9 Vdout0_9ck194 = 1.8 time = 1950
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=1950.05n

* CHECK dout0_10 Vdout0_10ck194 = 1.8 time = 1950
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=1950.05n

* CHECK dout0_11 Vdout0_11ck194 = 0 time = 1950
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=1950.05n

* CHECK dout0_12 Vdout0_12ck194 = 1.8 time = 1950
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=1950.05n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 1950
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=1950.05n

* CHECK dout0_14 Vdout0_14ck194 = 1.8 time = 1950
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=1950.05n

* CHECK dout0_15 Vdout0_15ck194 = 0 time = 1950
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=1950.05n

* CHECK dout0_16 Vdout0_16ck194 = 1.8 time = 1950
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=1950.05n

* CHECK dout0_17 Vdout0_17ck194 = 0 time = 1950
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=1950.05n

* CHECK dout0_18 Vdout0_18ck194 = 1.8 time = 1950
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=1950.05n

* CHECK dout0_19 Vdout0_19ck194 = 0 time = 1950
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=1950.05n

* CHECK dout0_20 Vdout0_20ck194 = 1.8 time = 1950
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=1950.05n

* CHECK dout0_21 Vdout0_21ck194 = 1.8 time = 1950
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=1950.05n

* CHECK dout0_22 Vdout0_22ck194 = 1.8 time = 1950
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=1950.05n

* CHECK dout0_23 Vdout0_23ck194 = 1.8 time = 1950
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=1950.05n

* CHECK dout0_24 Vdout0_24ck194 = 1.8 time = 1950
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=1950.05n

* CHECK dout0_25 Vdout0_25ck194 = 1.8 time = 1950
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=1950.05n

* CHECK dout0_26 Vdout0_26ck194 = 0 time = 1950
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=1950.05n

* CHECK dout0_27 Vdout0_27ck194 = 1.8 time = 1950
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=1950.05n

* CHECK dout0_28 Vdout0_28ck194 = 1.8 time = 1950
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=1950.05n

* CHECK dout0_29 Vdout0_29ck194 = 0 time = 1950
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=1950.05n

* CHECK dout0_30 Vdout0_30ck194 = 1.8 time = 1950
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=1950.05n

* CHECK dout0_31 Vdout0_31ck194 = 1.8 time = 1950
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=1950.05n

* CHECK dout0_32 Vdout0_32ck194 = 0 time = 1950
.meas tran vdout0_32ck194 FIND v(dout0_32) AT=1950.05n

* CHECK dout0_0 Vdout0_0ck196 = 1.8 time = 1970
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=1970.05n

* CHECK dout0_1 Vdout0_1ck196 = 0 time = 1970
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=1970.05n

* CHECK dout0_2 Vdout0_2ck196 = 1.8 time = 1970
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=1970.05n

* CHECK dout0_3 Vdout0_3ck196 = 1.8 time = 1970
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=1970.05n

* CHECK dout0_4 Vdout0_4ck196 = 1.8 time = 1970
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=1970.05n

* CHECK dout0_5 Vdout0_5ck196 = 0 time = 1970
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=1970.05n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 1970
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=1970.05n

* CHECK dout0_7 Vdout0_7ck196 = 1.8 time = 1970
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=1970.05n

* CHECK dout0_8 Vdout0_8ck196 = 0 time = 1970
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=1970.05n

* CHECK dout0_9 Vdout0_9ck196 = 1.8 time = 1970
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=1970.05n

* CHECK dout0_10 Vdout0_10ck196 = 1.8 time = 1970
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=1970.05n

* CHECK dout0_11 Vdout0_11ck196 = 0 time = 1970
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=1970.05n

* CHECK dout0_12 Vdout0_12ck196 = 1.8 time = 1970
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=1970.05n

* CHECK dout0_13 Vdout0_13ck196 = 1.8 time = 1970
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=1970.05n

* CHECK dout0_14 Vdout0_14ck196 = 0 time = 1970
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=1970.05n

* CHECK dout0_15 Vdout0_15ck196 = 1.8 time = 1970
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=1970.05n

* CHECK dout0_16 Vdout0_16ck196 = 1.8 time = 1970
.meas tran vdout0_16ck196 FIND v(dout0_16) AT=1970.05n

* CHECK dout0_17 Vdout0_17ck196 = 0 time = 1970
.meas tran vdout0_17ck196 FIND v(dout0_17) AT=1970.05n

* CHECK dout0_18 Vdout0_18ck196 = 1.8 time = 1970
.meas tran vdout0_18ck196 FIND v(dout0_18) AT=1970.05n

* CHECK dout0_19 Vdout0_19ck196 = 0 time = 1970
.meas tran vdout0_19ck196 FIND v(dout0_19) AT=1970.05n

* CHECK dout0_20 Vdout0_20ck196 = 1.8 time = 1970
.meas tran vdout0_20ck196 FIND v(dout0_20) AT=1970.05n

* CHECK dout0_21 Vdout0_21ck196 = 0 time = 1970
.meas tran vdout0_21ck196 FIND v(dout0_21) AT=1970.05n

* CHECK dout0_22 Vdout0_22ck196 = 1.8 time = 1970
.meas tran vdout0_22ck196 FIND v(dout0_22) AT=1970.05n

* CHECK dout0_23 Vdout0_23ck196 = 1.8 time = 1970
.meas tran vdout0_23ck196 FIND v(dout0_23) AT=1970.05n

* CHECK dout0_24 Vdout0_24ck196 = 1.8 time = 1970
.meas tran vdout0_24ck196 FIND v(dout0_24) AT=1970.05n

* CHECK dout0_25 Vdout0_25ck196 = 1.8 time = 1970
.meas tran vdout0_25ck196 FIND v(dout0_25) AT=1970.05n

* CHECK dout0_26 Vdout0_26ck196 = 0 time = 1970
.meas tran vdout0_26ck196 FIND v(dout0_26) AT=1970.05n

* CHECK dout0_27 Vdout0_27ck196 = 0 time = 1970
.meas tran vdout0_27ck196 FIND v(dout0_27) AT=1970.05n

* CHECK dout0_28 Vdout0_28ck196 = 0 time = 1970
.meas tran vdout0_28ck196 FIND v(dout0_28) AT=1970.05n

* CHECK dout0_29 Vdout0_29ck196 = 1.8 time = 1970
.meas tran vdout0_29ck196 FIND v(dout0_29) AT=1970.05n

* CHECK dout0_30 Vdout0_30ck196 = 1.8 time = 1970
.meas tran vdout0_30ck196 FIND v(dout0_30) AT=1970.05n

* CHECK dout0_31 Vdout0_31ck196 = 1.8 time = 1970
.meas tran vdout0_31ck196 FIND v(dout0_31) AT=1970.05n

* CHECK dout0_32 Vdout0_32ck196 = 0 time = 1970
.meas tran vdout0_32ck196 FIND v(dout0_32) AT=1970.05n

* CHECK dout0_0 Vdout0_0ck200 = 1.8 time = 2010
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=2010.05n

* CHECK dout0_1 Vdout0_1ck200 = 0 time = 2010
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=2010.05n

* CHECK dout0_2 Vdout0_2ck200 = 1.8 time = 2010
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=2010.05n

* CHECK dout0_3 Vdout0_3ck200 = 0 time = 2010
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=2010.05n

* CHECK dout0_4 Vdout0_4ck200 = 1.8 time = 2010
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=2010.05n

* CHECK dout0_5 Vdout0_5ck200 = 0 time = 2010
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=2010.05n

* CHECK dout0_6 Vdout0_6ck200 = 1.8 time = 2010
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=2010.05n

* CHECK dout0_7 Vdout0_7ck200 = 1.8 time = 2010
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=2010.05n

* CHECK dout0_8 Vdout0_8ck200 = 0 time = 2010
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=2010.05n

* CHECK dout0_9 Vdout0_9ck200 = 0 time = 2010
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=2010.05n

* CHECK dout0_10 Vdout0_10ck200 = 1.8 time = 2010
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=2010.05n

* CHECK dout0_11 Vdout0_11ck200 = 1.8 time = 2010
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=2010.05n

* CHECK dout0_12 Vdout0_12ck200 = 0 time = 2010
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=2010.05n

* CHECK dout0_13 Vdout0_13ck200 = 1.8 time = 2010
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=2010.05n

* CHECK dout0_14 Vdout0_14ck200 = 0 time = 2010
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=2010.05n

* CHECK dout0_15 Vdout0_15ck200 = 1.8 time = 2010
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=2010.05n

* CHECK dout0_16 Vdout0_16ck200 = 0 time = 2010
.meas tran vdout0_16ck200 FIND v(dout0_16) AT=2010.05n

* CHECK dout0_17 Vdout0_17ck200 = 0 time = 2010
.meas tran vdout0_17ck200 FIND v(dout0_17) AT=2010.05n

* CHECK dout0_18 Vdout0_18ck200 = 1.8 time = 2010
.meas tran vdout0_18ck200 FIND v(dout0_18) AT=2010.05n

* CHECK dout0_19 Vdout0_19ck200 = 1.8 time = 2010
.meas tran vdout0_19ck200 FIND v(dout0_19) AT=2010.05n

* CHECK dout0_20 Vdout0_20ck200 = 0 time = 2010
.meas tran vdout0_20ck200 FIND v(dout0_20) AT=2010.05n

* CHECK dout0_21 Vdout0_21ck200 = 1.8 time = 2010
.meas tran vdout0_21ck200 FIND v(dout0_21) AT=2010.05n

* CHECK dout0_22 Vdout0_22ck200 = 1.8 time = 2010
.meas tran vdout0_22ck200 FIND v(dout0_22) AT=2010.05n

* CHECK dout0_23 Vdout0_23ck200 = 0 time = 2010
.meas tran vdout0_23ck200 FIND v(dout0_23) AT=2010.05n

* CHECK dout0_24 Vdout0_24ck200 = 1.8 time = 2010
.meas tran vdout0_24ck200 FIND v(dout0_24) AT=2010.05n

* CHECK dout0_25 Vdout0_25ck200 = 1.8 time = 2010
.meas tran vdout0_25ck200 FIND v(dout0_25) AT=2010.05n

* CHECK dout0_26 Vdout0_26ck200 = 0 time = 2010
.meas tran vdout0_26ck200 FIND v(dout0_26) AT=2010.05n

* CHECK dout0_27 Vdout0_27ck200 = 0 time = 2010
.meas tran vdout0_27ck200 FIND v(dout0_27) AT=2010.05n

* CHECK dout0_28 Vdout0_28ck200 = 1.8 time = 2010
.meas tran vdout0_28ck200 FIND v(dout0_28) AT=2010.05n

* CHECK dout0_29 Vdout0_29ck200 = 1.8 time = 2010
.meas tran vdout0_29ck200 FIND v(dout0_29) AT=2010.05n

* CHECK dout0_30 Vdout0_30ck200 = 0 time = 2010
.meas tran vdout0_30ck200 FIND v(dout0_30) AT=2010.05n

* CHECK dout0_31 Vdout0_31ck200 = 1.8 time = 2010
.meas tran vdout0_31ck200 FIND v(dout0_31) AT=2010.05n

* CHECK dout0_32 Vdout0_32ck200 = 0 time = 2010
.meas tran vdout0_32ck200 FIND v(dout0_32) AT=2010.05n

* CHECK dout0_0 Vdout0_0ck202 = 1.8 time = 2030
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=2030.05n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 2030
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=2030.05n

* CHECK dout0_2 Vdout0_2ck202 = 1.8 time = 2030
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=2030.05n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 2030
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=2030.05n

* CHECK dout0_4 Vdout0_4ck202 = 1.8 time = 2030
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=2030.05n

* CHECK dout0_5 Vdout0_5ck202 = 0 time = 2030
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=2030.05n

* CHECK dout0_6 Vdout0_6ck202 = 1.8 time = 2030
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=2030.05n

* CHECK dout0_7 Vdout0_7ck202 = 1.8 time = 2030
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=2030.05n

* CHECK dout0_8 Vdout0_8ck202 = 0 time = 2030
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=2030.05n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 2030
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=2030.05n

* CHECK dout0_10 Vdout0_10ck202 = 1.8 time = 2030
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=2030.05n

* CHECK dout0_11 Vdout0_11ck202 = 1.8 time = 2030
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=2030.05n

* CHECK dout0_12 Vdout0_12ck202 = 0 time = 2030
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=2030.05n

* CHECK dout0_13 Vdout0_13ck202 = 1.8 time = 2030
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=2030.05n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 2030
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=2030.05n

* CHECK dout0_15 Vdout0_15ck202 = 1.8 time = 2030
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=2030.05n

* CHECK dout0_16 Vdout0_16ck202 = 0 time = 2030
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=2030.05n

* CHECK dout0_17 Vdout0_17ck202 = 0 time = 2030
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=2030.05n

* CHECK dout0_18 Vdout0_18ck202 = 1.8 time = 2030
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=2030.05n

* CHECK dout0_19 Vdout0_19ck202 = 1.8 time = 2030
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=2030.05n

* CHECK dout0_20 Vdout0_20ck202 = 0 time = 2030
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=2030.05n

* CHECK dout0_21 Vdout0_21ck202 = 1.8 time = 2030
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=2030.05n

* CHECK dout0_22 Vdout0_22ck202 = 1.8 time = 2030
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=2030.05n

* CHECK dout0_23 Vdout0_23ck202 = 0 time = 2030
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=2030.05n

* CHECK dout0_24 Vdout0_24ck202 = 1.8 time = 2030
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=2030.05n

* CHECK dout0_25 Vdout0_25ck202 = 1.8 time = 2030
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=2030.05n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 2030
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=2030.05n

* CHECK dout0_27 Vdout0_27ck202 = 0 time = 2030
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=2030.05n

* CHECK dout0_28 Vdout0_28ck202 = 1.8 time = 2030
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=2030.05n

* CHECK dout0_29 Vdout0_29ck202 = 1.8 time = 2030
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=2030.05n

* CHECK dout0_30 Vdout0_30ck202 = 0 time = 2030
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=2030.05n

* CHECK dout0_31 Vdout0_31ck202 = 1.8 time = 2030
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=2030.05n

* CHECK dout0_32 Vdout0_32ck202 = 0 time = 2030
.meas tran vdout0_32ck202 FIND v(dout0_32) AT=2030.05n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
