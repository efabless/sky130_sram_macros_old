* Functional test stimulus file for 10ns period

* TT process corner
.lib "/home/software/PDKs/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "sky130_sram_2kbyte_1rw_32x512_8.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsky130_sram_2kbyte_1rw_32x512_8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 a0_9 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 vdd gnd sky130_sram_2kbyte_1rw_32x512_8

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f

* Important signals for debug
* bl:	xsky130_sram_2kbyte_1rw_32x512_8.xbank0.bl_0_0
* br:	xsky130_sram_2kbyte_1rw_32x512_8.xbank0.br_0_0
* s_en:	xsky130_sram_2kbyte_1rw_32x512_8.s_en
* q:	xsky130_sram_2kbyte_1rw_32x512_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q
* qbar:	xsky130_sram_2kbyte_1rw_32x512_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+01000101110101100111000101111110  to  address 0000000001 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+11111000110010101010010111111010  to  address 1000000010 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+11000010111001101001011001110110  to  address 0000000001 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+11111000110010101010010111111010 from address 1000000010 (from port 0) during cycle 4 (40ns - 50ns)
*	Writing 0+00100011001111100101100000101010  to  address 1000000000 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 0+11000010111001101001011001110110 from address 0000000001 (from port 0) during cycle 6 (60ns - 70ns)
*	Writing (partial) 0+01011100011011001101110110000010  to  address 0000000001 with mask bit 0011 (from port 0) during cycle 8 (80ns - 90ns)
*	Reading 0+11111000110010101010010111111010 from address 1000000010 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 0+11000010111001101101110110000010 from address 0000000001 (from port 0) during cycle 10 (100ns - 110ns)
*	Writing (partial) 0+01010110001000001001000101111000  to  address 1000000010 with mask bit 1000 (from port 0) during cycle 11 (110ns - 120ns)
*	Writing (partial) 0+10010000011100101011010011000100  to  address 0000000001 with mask bit 0010 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 0+01100110011100100010110010101011  to  address 1000000001 (from port 0) during cycle 13 (130ns - 140ns)
*	Reading 0+01010110110010101010010111111010 from address 1000000010 (from port 0) during cycle 14 (140ns - 150ns)
*	Reading 0+01100110011100100010110010101011 from address 1000000001 (from port 0) during cycle 18 (180ns - 190ns)
*	Writing (partial) 0+00001100011100101001001000110001  to  address 0000000001 with mask bit 1100 (from port 0) during cycle 19 (190ns - 200ns)
*	Writing 0+11001001010011001001000011011110  to  address 1000000000 (from port 0) during cycle 20 (200ns - 210ns)
*	Writing (partial) 0+10111000010010010000011101010101  to  address 1000000001 with mask bit 0011 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 0+00001100011100101011010010000010 from address 0000000001 (from port 0) during cycle 22 (220ns - 230ns)
*	Writing 0+01011100101010001111011010010110  to  address 1000000010 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 0+11001001010011001001000011011110 from address 1000000000 (from port 0) during cycle 26 (260ns - 270ns)
*	Reading 0+11001001010011001001000011011110 from address 1000000000 (from port 0) during cycle 27 (270ns - 280ns)
*	Writing 0+11101100110110101110001011001010  to  address 0000000000 (from port 0) during cycle 28 (280ns - 290ns)
*	Reading 0+01011100101010001111011010010110 from address 1000000010 (from port 0) during cycle 29 (290ns - 300ns)
*	Reading 0+01100110011100100000011101010101 from address 1000000001 (from port 0) during cycle 31 (310ns - 320ns)
*	Reading 0+11101100110110101110001011001010 from address 0000000000 (from port 0) during cycle 32 (320ns - 330ns)
*	Writing 0+01101011111010101001010000111110  to  address 1000000010 (from port 0) during cycle 34 (340ns - 350ns)
*	Writing (partial) 0+11010011001010011001001101001000  to  address 1000000001 with mask bit 0001 (from port 0) during cycle 35 (350ns - 360ns)
*	Writing 0+01011000010101111110111001100000  to  address 0000000010 (from port 0) during cycle 36 (360ns - 370ns)
*	Writing (partial) 0+00000011001010001110000000111010  to  address 0000000010 with mask bit 0001 (from port 0) during cycle 37 (370ns - 380ns)
*	Reading 0+01011000010101111110111000111010 from address 0000000010 (from port 0) during cycle 38 (380ns - 390ns)
*	Writing (partial) 0+01100001111101010000100011100001  to  address 1000000000 with mask bit 0100 (from port 0) during cycle 39 (390ns - 400ns)
*	Writing 0+10111100010001110011001100010000  to  address 1000000000 (from port 0) during cycle 40 (400ns - 410ns)
*	Writing 0+01100010111011101000010100101101  to  address 1000000001 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 0+01101011111010101001010000111110 from address 1000000010 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 0+00001100011100101011010010000010 from address 0000000001 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 0+01101011111010101001010000111110 from address 1000000010 (from port 0) during cycle 47 (470ns - 480ns)
*	Writing (partial) 0+00011100011000010001010000001100  to  address 0000000000 with mask bit 1011 (from port 0) during cycle 48 (480ns - 490ns)
*	Writing 0+00101111001110010001011000111001  to  address 0111111111 (from port 0) during cycle 49 (490ns - 500ns)
*	Writing (partial) 0+10011000101110111101011001001100  to  address 1000000010 with mask bit 0111 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 0+00011100110110100001010000001100 from address 0000000000 (from port 0) during cycle 53 (530ns - 540ns)
*	Writing 0+10101000010011100000100001000000  to  address 0000000010 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 0+01100010111011101000010100101101 from address 1000000001 (from port 0) during cycle 56 (560ns - 570ns)
*	Writing (partial) 0+01100100000100001101110101111111  to  address 0000000010 with mask bit 1101 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 0+01101011101110111101011001001100 from address 1000000010 (from port 0) during cycle 58 (580ns - 590ns)
*	Reading 0+01100100000100000000100001111111 from address 0000000010 (from port 0) during cycle 60 (600ns - 610ns)
*	Writing 0+10000111111101101000111100011100  to  address 1000000001 (from port 0) during cycle 61 (610ns - 620ns)
*	Writing 0+10011000110001010001000100001100  to  address 0000000000 (from port 0) during cycle 62 (620ns - 630ns)
*	Writing (partial) 0+01010101111110010110101000011010  to  address 0000000010 with mask bit 0111 (from port 0) during cycle 63 (630ns - 640ns)
*	Writing (partial) 0+00010110100111111010100101110100  to  address 1000000010 with mask bit 1100 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 0+00010110100111111101011001001100 from address 1000000010 (from port 0) during cycle 66 (660ns - 670ns)
*	Writing (partial) 0+01111111000110011000011000101101  to  address 1000000000 with mask bit 1001 (from port 0) during cycle 67 (670ns - 680ns)
*	Reading 0+00101111001110010001011000111001 from address 0111111111 (from port 0) during cycle 68 (680ns - 690ns)
*	Reading 0+01111111010001110011001100101101 from address 1000000000 (from port 0) during cycle 69 (690ns - 700ns)
*	Writing (partial) 0+10011101010111111010100101000001  to  address 1000000001 with mask bit 1001 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 0+01100100111110010110101000011010 from address 0000000010 (from port 0) during cycle 71 (710ns - 720ns)
*	Writing (partial) 0+01111001110000100100110000111101  to  address 1000000001 with mask bit 1000 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 0+10011000110001010001000100001100 from address 0000000000 (from port 0) during cycle 74 (740ns - 750ns)
*	Reading 0+01111111010001110011001100101101 from address 1000000000 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 0+01111111010001110011001100101101 from address 1000000000 (from port 0) during cycle 76 (760ns - 770ns)
*	Writing (partial) 0+01010110011100111001111011110001  to  address 0000000010 with mask bit 0110 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 0+10011000110001010001000100001100 from address 0000000000 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing 0+10101000100000111010100101100010  to  address 0000000011 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 0+00010110100111111101011001001100 from address 1000000010 (from port 0) during cycle 81 (810ns - 820ns)
*	Writing (partial) 0+01111100010111111101000101101001  to  address 1000000010 with mask bit 1001 (from port 0) during cycle 82 (820ns - 830ns)
*	Writing (partial) 0+11011100111111010111110110000100  to  address 1000000001 with mask bit 0001 (from port 0) during cycle 84 (840ns - 850ns)
*	Writing (partial) 0+01010000001001101100100101000011  to  address 0111111111 with mask bit 0111 (from port 0) during cycle 85 (850ns - 860ns)
*	Writing (partial) 0+01000100101110111110111001110010  to  address 1000000001 with mask bit 1100 (from port 0) during cycle 87 (870ns - 880ns)
*	Writing 0+10010111001000111111100010101010  to  address 0000000000 (from port 0) during cycle 88 (880ns - 890ns)
*	Writing (partial) 0+00111001001111101001100100011100  to  address 1000000000 with mask bit 0010 (from port 0) during cycle 89 (890ns - 900ns)
*	Reading 0+01111100100111111101011001101001 from address 1000000010 (from port 0) during cycle 90 (900ns - 910ns)
*	Writing (partial) 0+01000010000010011101101111100100  to  address 0111111111 with mask bit 0111 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 0+01000100101110111000111110000100 from address 1000000001 (from port 0) during cycle 93 (930ns - 940ns)
*	Writing (partial) 0+11111111101110011011110011010001  to  address 0111111111 with mask bit 0110 (from port 0) during cycle 94 (940ns - 950ns)
*	Reading 0+01000100101110111000111110000100 from address 1000000001 (from port 0) during cycle 95 (950ns - 960ns)
*	Reading 0+01111111010001111001100100101101 from address 1000000000 (from port 0) during cycle 96 (960ns - 970ns)
*	Writing 0+10110001111110110010110111010011  to  address 1000000010 (from port 0) during cycle 97 (970ns - 980ns)
*	Writing 0+11110100011101100101101101100110  to  address 1000000000 (from port 0) during cycle 98 (980ns - 990ns)
*	Writing (partial) 0+00001000101101100101010111100001  to  address 0000000000 with mask bit 0110 (from port 0) during cycle 100 (1000ns - 1010ns)
*	Writing (partial) 0+00110010001011010010010111000100  to  address 0111111111 with mask bit 1100 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+10010111101101100101010110101010 from address 0000000000 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Writing 0+10001001001010111000001000000100  to  address 1000000001 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Writing 0+11101101100001010101110011000000  to  address 0000000010 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 0+10101000100000111010100101100010 from address 0000000011 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Reading 0+10001001001010111000001000000100 from address 1000000001 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 0+11110100011101100101101101100110 from address 1000000000 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Reading 0+10010111101101100101010110101010 from address 0000000000 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Writing (partial) 0+10101001000111110000110011111000  to  address 0000000010 with mask bit 1001 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 0+10001001001010111000001000000100 from address 1000000001 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Reading 0+10101000100000111010100101100010 from address 0000000011 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Writing (partial) 0+11011101100111010100011101010100  to  address 0111111111 with mask bit 1010 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Writing (partial) 0+00101000001100101110001101010010  to  address 0000000010 with mask bit 1000 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Reading 0+10101000100000111010100101100010 from address 0000000011 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Reading 0+11110100011101100101101101100110 from address 1000000000 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Writing (partial) 0+11110110100111111011111010010101  to  address 1000000000 with mask bit 1100 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 0+10110001111110110010110111010011 from address 1000000010 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 0+11110110100111110101101101100110 from address 1000000000 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 0+00101000100001010101110011111000 from address 0000000010 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Writing 0+10001111110010010111111010100101  to  address 0000000000 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 0+10001001001010111000001000000100 from address 1000000001 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Writing (partial) 0+10111110111001010011011101000101  to  address 0000000010 with mask bit 1001 (from port 0) during cycle 124 (1240ns - 1250ns)
*	Reading 0+10101000100000111010100101100010 from address 0000000011 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Reading 0+10001001001010111000001000000100 from address 1000000001 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Writing (partial) 0+01000100111101100110000111111100  to  address 1000000001 with mask bit 0001 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Writing 0+00001100011001111011011001101011  to  address 1000000000 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing (partial) 0+11000101000111111100101111110000  to  address 1000000010 with mask bit 0101 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Reading 0+00001100011001111011011001101011 from address 1000000000 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Reading 0+10001111110010010111111010100101 from address 0000000000 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Writing 0+01111101101110110001010110011000  to  address 0000000010 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Reading 0+10001001001010111000001011111100 from address 1000000001 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 0+10001001001010111000001011111100 from address 1000000001 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Writing 0+11101101000100011001100101000000  to  address 0000000011 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Reading 0+10110001000111110010110111110000 from address 1000000010 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Writing 0+10011100001110010000000100100101  to  address 0000000000 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Writing (partial) 0+00000111110011111101010110100000  to  address 0000000001 with mask bit 0101 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Writing (partial) 0+00111010110111010010011100111110  to  address 0000000000 with mask bit 0111 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Reading 0+00001100011001111011011001101011 from address 1000000000 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Writing 0+01000100000000101010010010010101  to  address 0111111111 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Reading 0+01111101101110110001010110011000 from address 0000000010 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Writing (partial) 0+00001010000011010001010101111001  to  address 0000000011 with mask bit 0111 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Writing (partial) 0+01111110100111101101111110001000  to  address 1000000010 with mask bit 0100 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Reading 0+01000100000000101010010010010101 from address 0111111111 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Reading 0+01111101101110110001010110011000 from address 0000000010 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 0+01111101101110110001010110011000 from address 0000000010 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Reading 0+10110001100111100010110111110000 from address 1000000010 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Reading 0+10110001100111100010110111110000 from address 1000000010 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Writing (partial) 0+11101110011011011111010111000011  to  address 0000000001 with mask bit 0100 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Writing (partial) 0+01001100110011000001110001000000  to  address 0000000010 with mask bit 1000 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Writing 0+01110100101111100010100010110010  to  address 0000000011 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Writing 0+10100111100111001000001101100101  to  address 0000000010 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Writing (partial) 0+11010110110101000000111011111011  to  address 0000000000 with mask bit 0001 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 0+00001100011011011011010010100000 from address 0000000001 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Writing 0+10000111101101010011010011101011  to  address 0111111111 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 0+10011100110111010010011111111011 from address 0000000000 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Reading 0+00001100011001111011011001101011 from address 1000000000 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 0+10100111100111001000001101100101 from address 0000000010 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Writing 0+00001001111111110101000111110011  to  address 0000000010 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Writing 0+01010011001110101000111111011010  to  address 0000000010 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Reading 0+10011100110111010010011111111011 from address 0000000000 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Writing 0+01010101001011110001000100100011  to  address 1000000001 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Writing 0+01100110001100100001010111101000  to  address 1000000010 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Writing (partial) 0+01010100001000001010101111100111  to  address 1000000000 with mask bit 0100 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Writing 0+10111101000110010101011111011000  to  address 0000000010 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Writing (partial) 0+00000100000000100110110111001110  to  address 0000000000 with mask bit 0011 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Writing (partial) 0+11101101011110010110100011101000  to  address 1000000010 with mask bit 0010 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 0+01100110001100100110100011101000 from address 1000000010 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Writing (partial) 0+11011111101001110110110110010000  to  address 1000000000 with mask bit 0111 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 0+01110100101111100010100010110010 from address 0000000011 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 0+10000111101101010011010011101011 from address 0111111111 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 0+01110100101111100010100010110010 from address 0000000011 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Reading 0+01010101001011110001000100100011 from address 1000000001 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Writing 0+11100111101111110011101010010100  to  address 0000000011 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing 0+01011111010000010111100000111010  to  address 1000000001 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Writing 0+11011100111000110111000010111110  to  address 1000000001 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Reading 0+11100111101111110011101010010100 from address 0000000011 (from port 0) during cycle 203 (2030ns - 2040ns)
*	Writing 0+01001011101011111000011101010011  to  address 0111111111 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 0), (100, 1), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 1), (710, 0), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 1), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 1), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 1), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_7  a0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Va0_8  a0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 1), (350, 1), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 1), (590, 1), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_9  a0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 1), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 0), (450, 1), (460, 1), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 1), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 0), (680, 1), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 1), (820, 0), (830, 1), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 0), (930, 1), (940, 0), (950, 1), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 1), (1240, 0), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 1), (2040, 0), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )

* Generation of wmask signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 1.8 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 1.8 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 1.8 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_8 Vdout0_8ck4 = 1.8 time = 50
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=50.05n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 50
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=50.05n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 50
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=50.05n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 50
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=50.05n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 50
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=50.05n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 50
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=50.05n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 50
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=50.05n

* CHECK dout0_15 Vdout0_15ck4 = 1.8 time = 50
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=50.05n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 50
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=50.05n

* CHECK dout0_17 Vdout0_17ck4 = 1.8 time = 50
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=50.05n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 50
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=50.05n

* CHECK dout0_19 Vdout0_19ck4 = 1.8 time = 50
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=50.05n

* CHECK dout0_20 Vdout0_20ck4 = 0 time = 50
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=50.05n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 50
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=50.05n

* CHECK dout0_22 Vdout0_22ck4 = 1.8 time = 50
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=50.05n

* CHECK dout0_23 Vdout0_23ck4 = 1.8 time = 50
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=50.05n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 50
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=50.05n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 50
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=50.05n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 50
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=50.05n

* CHECK dout0_27 Vdout0_27ck4 = 1.8 time = 50
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=50.05n

* CHECK dout0_28 Vdout0_28ck4 = 1.8 time = 50
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=50.05n

* CHECK dout0_29 Vdout0_29ck4 = 1.8 time = 50
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=50.05n

* CHECK dout0_30 Vdout0_30ck4 = 1.8 time = 50
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=50.05n

* CHECK dout0_31 Vdout0_31ck4 = 1.8 time = 50
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=50.05n

* CHECK dout0_32 Vdout0_32ck4 = 0 time = 50
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=50.05n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 70
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=70.05n

* CHECK dout0_1 Vdout0_1ck6 = 1.8 time = 70
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=70.05n

* CHECK dout0_2 Vdout0_2ck6 = 1.8 time = 70
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=70.05n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 70
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=70.05n

* CHECK dout0_4 Vdout0_4ck6 = 1.8 time = 70
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=70.05n

* CHECK dout0_5 Vdout0_5ck6 = 1.8 time = 70
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=70.05n

* CHECK dout0_6 Vdout0_6ck6 = 1.8 time = 70
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=70.05n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 70
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=70.05n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 70
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=70.05n

* CHECK dout0_9 Vdout0_9ck6 = 1.8 time = 70
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=70.05n

* CHECK dout0_10 Vdout0_10ck6 = 1.8 time = 70
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=70.05n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 70
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=70.05n

* CHECK dout0_12 Vdout0_12ck6 = 1.8 time = 70
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=70.05n

* CHECK dout0_13 Vdout0_13ck6 = 0 time = 70
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=70.05n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 70
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=70.05n

* CHECK dout0_15 Vdout0_15ck6 = 1.8 time = 70
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=70.05n

* CHECK dout0_16 Vdout0_16ck6 = 0 time = 70
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=70.05n

* CHECK dout0_17 Vdout0_17ck6 = 1.8 time = 70
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=70.05n

* CHECK dout0_18 Vdout0_18ck6 = 1.8 time = 70
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=70.05n

* CHECK dout0_19 Vdout0_19ck6 = 0 time = 70
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=70.05n

* CHECK dout0_20 Vdout0_20ck6 = 0 time = 70
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=70.05n

* CHECK dout0_21 Vdout0_21ck6 = 1.8 time = 70
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=70.05n

* CHECK dout0_22 Vdout0_22ck6 = 1.8 time = 70
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=70.05n

* CHECK dout0_23 Vdout0_23ck6 = 1.8 time = 70
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=70.05n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 70
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=70.05n

* CHECK dout0_25 Vdout0_25ck6 = 1.8 time = 70
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=70.05n

* CHECK dout0_26 Vdout0_26ck6 = 0 time = 70
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=70.05n

* CHECK dout0_27 Vdout0_27ck6 = 0 time = 70
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=70.05n

* CHECK dout0_28 Vdout0_28ck6 = 0 time = 70
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=70.05n

* CHECK dout0_29 Vdout0_29ck6 = 0 time = 70
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=70.05n

* CHECK dout0_30 Vdout0_30ck6 = 1.8 time = 70
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=70.05n

* CHECK dout0_31 Vdout0_31ck6 = 1.8 time = 70
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=70.05n

* CHECK dout0_32 Vdout0_32ck6 = 0 time = 70
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=70.05n

* CHECK dout0_0 Vdout0_0ck9 = 0 time = 100
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=100.05n

* CHECK dout0_1 Vdout0_1ck9 = 1.8 time = 100
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=100.05n

* CHECK dout0_2 Vdout0_2ck9 = 0 time = 100
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=100.05n

* CHECK dout0_3 Vdout0_3ck9 = 1.8 time = 100
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=100.05n

* CHECK dout0_4 Vdout0_4ck9 = 1.8 time = 100
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=100.05n

* CHECK dout0_5 Vdout0_5ck9 = 1.8 time = 100
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=100.05n

* CHECK dout0_6 Vdout0_6ck9 = 1.8 time = 100
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=100.05n

* CHECK dout0_7 Vdout0_7ck9 = 1.8 time = 100
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=100.05n

* CHECK dout0_8 Vdout0_8ck9 = 1.8 time = 100
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=100.05n

* CHECK dout0_9 Vdout0_9ck9 = 0 time = 100
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=100.05n

* CHECK dout0_10 Vdout0_10ck9 = 1.8 time = 100
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=100.05n

* CHECK dout0_11 Vdout0_11ck9 = 0 time = 100
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=100.05n

* CHECK dout0_12 Vdout0_12ck9 = 0 time = 100
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=100.05n

* CHECK dout0_13 Vdout0_13ck9 = 1.8 time = 100
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=100.05n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 100
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=100.05n

* CHECK dout0_15 Vdout0_15ck9 = 1.8 time = 100
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=100.05n

* CHECK dout0_16 Vdout0_16ck9 = 0 time = 100
.meas tran vdout0_16ck9 FIND v(dout0_16) AT=100.05n

* CHECK dout0_17 Vdout0_17ck9 = 1.8 time = 100
.meas tran vdout0_17ck9 FIND v(dout0_17) AT=100.05n

* CHECK dout0_18 Vdout0_18ck9 = 0 time = 100
.meas tran vdout0_18ck9 FIND v(dout0_18) AT=100.05n

* CHECK dout0_19 Vdout0_19ck9 = 1.8 time = 100
.meas tran vdout0_19ck9 FIND v(dout0_19) AT=100.05n

* CHECK dout0_20 Vdout0_20ck9 = 0 time = 100
.meas tran vdout0_20ck9 FIND v(dout0_20) AT=100.05n

* CHECK dout0_21 Vdout0_21ck9 = 0 time = 100
.meas tran vdout0_21ck9 FIND v(dout0_21) AT=100.05n

* CHECK dout0_22 Vdout0_22ck9 = 1.8 time = 100
.meas tran vdout0_22ck9 FIND v(dout0_22) AT=100.05n

* CHECK dout0_23 Vdout0_23ck9 = 1.8 time = 100
.meas tran vdout0_23ck9 FIND v(dout0_23) AT=100.05n

* CHECK dout0_24 Vdout0_24ck9 = 0 time = 100
.meas tran vdout0_24ck9 FIND v(dout0_24) AT=100.05n

* CHECK dout0_25 Vdout0_25ck9 = 0 time = 100
.meas tran vdout0_25ck9 FIND v(dout0_25) AT=100.05n

* CHECK dout0_26 Vdout0_26ck9 = 0 time = 100
.meas tran vdout0_26ck9 FIND v(dout0_26) AT=100.05n

* CHECK dout0_27 Vdout0_27ck9 = 1.8 time = 100
.meas tran vdout0_27ck9 FIND v(dout0_27) AT=100.05n

* CHECK dout0_28 Vdout0_28ck9 = 1.8 time = 100
.meas tran vdout0_28ck9 FIND v(dout0_28) AT=100.05n

* CHECK dout0_29 Vdout0_29ck9 = 1.8 time = 100
.meas tran vdout0_29ck9 FIND v(dout0_29) AT=100.05n

* CHECK dout0_30 Vdout0_30ck9 = 1.8 time = 100
.meas tran vdout0_30ck9 FIND v(dout0_30) AT=100.05n

* CHECK dout0_31 Vdout0_31ck9 = 1.8 time = 100
.meas tran vdout0_31ck9 FIND v(dout0_31) AT=100.05n

* CHECK dout0_32 Vdout0_32ck9 = 0 time = 100
.meas tran vdout0_32ck9 FIND v(dout0_32) AT=100.05n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 110
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=110.05n

* CHECK dout0_1 Vdout0_1ck10 = 1.8 time = 110
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=110.05n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 110
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=110.05n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 110
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=110.05n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 110
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=110.05n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 110
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=110.05n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 110
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=110.05n

* CHECK dout0_7 Vdout0_7ck10 = 1.8 time = 110
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=110.05n

* CHECK dout0_8 Vdout0_8ck10 = 1.8 time = 110
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=110.05n

* CHECK dout0_9 Vdout0_9ck10 = 0 time = 110
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=110.05n

* CHECK dout0_10 Vdout0_10ck10 = 1.8 time = 110
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=110.05n

* CHECK dout0_11 Vdout0_11ck10 = 1.8 time = 110
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=110.05n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 110
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=110.05n

* CHECK dout0_13 Vdout0_13ck10 = 0 time = 110
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=110.05n

* CHECK dout0_14 Vdout0_14ck10 = 1.8 time = 110
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=110.05n

* CHECK dout0_15 Vdout0_15ck10 = 1.8 time = 110
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=110.05n

* CHECK dout0_16 Vdout0_16ck10 = 0 time = 110
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=110.05n

* CHECK dout0_17 Vdout0_17ck10 = 1.8 time = 110
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=110.05n

* CHECK dout0_18 Vdout0_18ck10 = 1.8 time = 110
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=110.05n

* CHECK dout0_19 Vdout0_19ck10 = 0 time = 110
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=110.05n

* CHECK dout0_20 Vdout0_20ck10 = 0 time = 110
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=110.05n

* CHECK dout0_21 Vdout0_21ck10 = 1.8 time = 110
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=110.05n

* CHECK dout0_22 Vdout0_22ck10 = 1.8 time = 110
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=110.05n

* CHECK dout0_23 Vdout0_23ck10 = 1.8 time = 110
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=110.05n

* CHECK dout0_24 Vdout0_24ck10 = 0 time = 110
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=110.05n

* CHECK dout0_25 Vdout0_25ck10 = 1.8 time = 110
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=110.05n

* CHECK dout0_26 Vdout0_26ck10 = 0 time = 110
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=110.05n

* CHECK dout0_27 Vdout0_27ck10 = 0 time = 110
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=110.05n

* CHECK dout0_28 Vdout0_28ck10 = 0 time = 110
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=110.05n

* CHECK dout0_29 Vdout0_29ck10 = 0 time = 110
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=110.05n

* CHECK dout0_30 Vdout0_30ck10 = 1.8 time = 110
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=110.05n

* CHECK dout0_31 Vdout0_31ck10 = 1.8 time = 110
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=110.05n

* CHECK dout0_32 Vdout0_32ck10 = 0 time = 110
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=110.05n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 150
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=150.05n

* CHECK dout0_1 Vdout0_1ck14 = 1.8 time = 150
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=150.05n

* CHECK dout0_2 Vdout0_2ck14 = 0 time = 150
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=150.05n

* CHECK dout0_3 Vdout0_3ck14 = 1.8 time = 150
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=150.05n

* CHECK dout0_4 Vdout0_4ck14 = 1.8 time = 150
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=150.05n

* CHECK dout0_5 Vdout0_5ck14 = 1.8 time = 150
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=150.05n

* CHECK dout0_6 Vdout0_6ck14 = 1.8 time = 150
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=150.05n

* CHECK dout0_7 Vdout0_7ck14 = 1.8 time = 150
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=150.05n

* CHECK dout0_8 Vdout0_8ck14 = 1.8 time = 150
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=150.05n

* CHECK dout0_9 Vdout0_9ck14 = 0 time = 150
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=150.05n

* CHECK dout0_10 Vdout0_10ck14 = 1.8 time = 150
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=150.05n

* CHECK dout0_11 Vdout0_11ck14 = 0 time = 150
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=150.05n

* CHECK dout0_12 Vdout0_12ck14 = 0 time = 150
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=150.05n

* CHECK dout0_13 Vdout0_13ck14 = 1.8 time = 150
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=150.05n

* CHECK dout0_14 Vdout0_14ck14 = 0 time = 150
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=150.05n

* CHECK dout0_15 Vdout0_15ck14 = 1.8 time = 150
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=150.05n

* CHECK dout0_16 Vdout0_16ck14 = 0 time = 150
.meas tran vdout0_16ck14 FIND v(dout0_16) AT=150.05n

* CHECK dout0_17 Vdout0_17ck14 = 1.8 time = 150
.meas tran vdout0_17ck14 FIND v(dout0_17) AT=150.05n

* CHECK dout0_18 Vdout0_18ck14 = 0 time = 150
.meas tran vdout0_18ck14 FIND v(dout0_18) AT=150.05n

* CHECK dout0_19 Vdout0_19ck14 = 1.8 time = 150
.meas tran vdout0_19ck14 FIND v(dout0_19) AT=150.05n

* CHECK dout0_20 Vdout0_20ck14 = 0 time = 150
.meas tran vdout0_20ck14 FIND v(dout0_20) AT=150.05n

* CHECK dout0_21 Vdout0_21ck14 = 0 time = 150
.meas tran vdout0_21ck14 FIND v(dout0_21) AT=150.05n

* CHECK dout0_22 Vdout0_22ck14 = 1.8 time = 150
.meas tran vdout0_22ck14 FIND v(dout0_22) AT=150.05n

* CHECK dout0_23 Vdout0_23ck14 = 1.8 time = 150
.meas tran vdout0_23ck14 FIND v(dout0_23) AT=150.05n

* CHECK dout0_24 Vdout0_24ck14 = 0 time = 150
.meas tran vdout0_24ck14 FIND v(dout0_24) AT=150.05n

* CHECK dout0_25 Vdout0_25ck14 = 1.8 time = 150
.meas tran vdout0_25ck14 FIND v(dout0_25) AT=150.05n

* CHECK dout0_26 Vdout0_26ck14 = 1.8 time = 150
.meas tran vdout0_26ck14 FIND v(dout0_26) AT=150.05n

* CHECK dout0_27 Vdout0_27ck14 = 0 time = 150
.meas tran vdout0_27ck14 FIND v(dout0_27) AT=150.05n

* CHECK dout0_28 Vdout0_28ck14 = 1.8 time = 150
.meas tran vdout0_28ck14 FIND v(dout0_28) AT=150.05n

* CHECK dout0_29 Vdout0_29ck14 = 0 time = 150
.meas tran vdout0_29ck14 FIND v(dout0_29) AT=150.05n

* CHECK dout0_30 Vdout0_30ck14 = 1.8 time = 150
.meas tran vdout0_30ck14 FIND v(dout0_30) AT=150.05n

* CHECK dout0_31 Vdout0_31ck14 = 0 time = 150
.meas tran vdout0_31ck14 FIND v(dout0_31) AT=150.05n

* CHECK dout0_32 Vdout0_32ck14 = 0 time = 150
.meas tran vdout0_32ck14 FIND v(dout0_32) AT=150.05n

* CHECK dout0_0 Vdout0_0ck18 = 1.8 time = 190
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=190.05n

* CHECK dout0_1 Vdout0_1ck18 = 1.8 time = 190
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=190.05n

* CHECK dout0_2 Vdout0_2ck18 = 0 time = 190
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=190.05n

* CHECK dout0_3 Vdout0_3ck18 = 1.8 time = 190
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=190.05n

* CHECK dout0_4 Vdout0_4ck18 = 0 time = 190
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=190.05n

* CHECK dout0_5 Vdout0_5ck18 = 1.8 time = 190
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=190.05n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 190
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=190.05n

* CHECK dout0_7 Vdout0_7ck18 = 1.8 time = 190
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=190.05n

* CHECK dout0_8 Vdout0_8ck18 = 0 time = 190
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=190.05n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 190
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=190.05n

* CHECK dout0_10 Vdout0_10ck18 = 1.8 time = 190
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=190.05n

* CHECK dout0_11 Vdout0_11ck18 = 1.8 time = 190
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=190.05n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 190
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=190.05n

* CHECK dout0_13 Vdout0_13ck18 = 1.8 time = 190
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=190.05n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 190
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=190.05n

* CHECK dout0_15 Vdout0_15ck18 = 0 time = 190
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=190.05n

* CHECK dout0_16 Vdout0_16ck18 = 0 time = 190
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=190.05n

* CHECK dout0_17 Vdout0_17ck18 = 1.8 time = 190
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=190.05n

* CHECK dout0_18 Vdout0_18ck18 = 0 time = 190
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=190.05n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 190
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=190.05n

* CHECK dout0_20 Vdout0_20ck18 = 1.8 time = 190
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=190.05n

* CHECK dout0_21 Vdout0_21ck18 = 1.8 time = 190
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=190.05n

* CHECK dout0_22 Vdout0_22ck18 = 1.8 time = 190
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=190.05n

* CHECK dout0_23 Vdout0_23ck18 = 0 time = 190
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=190.05n

* CHECK dout0_24 Vdout0_24ck18 = 0 time = 190
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=190.05n

* CHECK dout0_25 Vdout0_25ck18 = 1.8 time = 190
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=190.05n

* CHECK dout0_26 Vdout0_26ck18 = 1.8 time = 190
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=190.05n

* CHECK dout0_27 Vdout0_27ck18 = 0 time = 190
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=190.05n

* CHECK dout0_28 Vdout0_28ck18 = 0 time = 190
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=190.05n

* CHECK dout0_29 Vdout0_29ck18 = 1.8 time = 190
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=190.05n

* CHECK dout0_30 Vdout0_30ck18 = 1.8 time = 190
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=190.05n

* CHECK dout0_31 Vdout0_31ck18 = 0 time = 190
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=190.05n

* CHECK dout0_32 Vdout0_32ck18 = 0 time = 190
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=190.05n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 230
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=230.05n

* CHECK dout0_1 Vdout0_1ck22 = 1.8 time = 230
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=230.05n

* CHECK dout0_2 Vdout0_2ck22 = 0 time = 230
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=230.05n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 230
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=230.05n

* CHECK dout0_4 Vdout0_4ck22 = 0 time = 230
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=230.05n

* CHECK dout0_5 Vdout0_5ck22 = 0 time = 230
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=230.05n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 230
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=230.05n

* CHECK dout0_7 Vdout0_7ck22 = 1.8 time = 230
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=230.05n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 230
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=230.05n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 230
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=230.05n

* CHECK dout0_10 Vdout0_10ck22 = 1.8 time = 230
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=230.05n

* CHECK dout0_11 Vdout0_11ck22 = 0 time = 230
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=230.05n

* CHECK dout0_12 Vdout0_12ck22 = 1.8 time = 230
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=230.05n

* CHECK dout0_13 Vdout0_13ck22 = 1.8 time = 230
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=230.05n

* CHECK dout0_14 Vdout0_14ck22 = 0 time = 230
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=230.05n

* CHECK dout0_15 Vdout0_15ck22 = 1.8 time = 230
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=230.05n

* CHECK dout0_16 Vdout0_16ck22 = 0 time = 230
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=230.05n

* CHECK dout0_17 Vdout0_17ck22 = 1.8 time = 230
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=230.05n

* CHECK dout0_18 Vdout0_18ck22 = 0 time = 230
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=230.05n

* CHECK dout0_19 Vdout0_19ck22 = 0 time = 230
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=230.05n

* CHECK dout0_20 Vdout0_20ck22 = 1.8 time = 230
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=230.05n

* CHECK dout0_21 Vdout0_21ck22 = 1.8 time = 230
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=230.05n

* CHECK dout0_22 Vdout0_22ck22 = 1.8 time = 230
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=230.05n

* CHECK dout0_23 Vdout0_23ck22 = 0 time = 230
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=230.05n

* CHECK dout0_24 Vdout0_24ck22 = 0 time = 230
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=230.05n

* CHECK dout0_25 Vdout0_25ck22 = 0 time = 230
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=230.05n

* CHECK dout0_26 Vdout0_26ck22 = 1.8 time = 230
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=230.05n

* CHECK dout0_27 Vdout0_27ck22 = 1.8 time = 230
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=230.05n

* CHECK dout0_28 Vdout0_28ck22 = 0 time = 230
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=230.05n

* CHECK dout0_29 Vdout0_29ck22 = 0 time = 230
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=230.05n

* CHECK dout0_30 Vdout0_30ck22 = 0 time = 230
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=230.05n

* CHECK dout0_31 Vdout0_31ck22 = 0 time = 230
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=230.05n

* CHECK dout0_32 Vdout0_32ck22 = 0 time = 230
.meas tran vdout0_32ck22 FIND v(dout0_32) AT=230.05n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 270
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=270.05n

* CHECK dout0_1 Vdout0_1ck26 = 1.8 time = 270
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=270.05n

* CHECK dout0_2 Vdout0_2ck26 = 1.8 time = 270
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=270.05n

* CHECK dout0_3 Vdout0_3ck26 = 1.8 time = 270
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=270.05n

* CHECK dout0_4 Vdout0_4ck26 = 1.8 time = 270
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=270.05n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 270
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=270.05n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 270
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=270.05n

* CHECK dout0_7 Vdout0_7ck26 = 1.8 time = 270
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=270.05n

* CHECK dout0_8 Vdout0_8ck26 = 0 time = 270
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=270.05n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 270
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=270.05n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 270
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=270.05n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 270
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=270.05n

* CHECK dout0_12 Vdout0_12ck26 = 1.8 time = 270
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=270.05n

* CHECK dout0_13 Vdout0_13ck26 = 0 time = 270
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=270.05n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 270
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=270.05n

* CHECK dout0_15 Vdout0_15ck26 = 1.8 time = 270
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=270.05n

* CHECK dout0_16 Vdout0_16ck26 = 0 time = 270
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=270.05n

* CHECK dout0_17 Vdout0_17ck26 = 0 time = 270
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=270.05n

* CHECK dout0_18 Vdout0_18ck26 = 1.8 time = 270
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=270.05n

* CHECK dout0_19 Vdout0_19ck26 = 1.8 time = 270
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=270.05n

* CHECK dout0_20 Vdout0_20ck26 = 0 time = 270
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=270.05n

* CHECK dout0_21 Vdout0_21ck26 = 0 time = 270
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=270.05n

* CHECK dout0_22 Vdout0_22ck26 = 1.8 time = 270
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=270.05n

* CHECK dout0_23 Vdout0_23ck26 = 0 time = 270
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=270.05n

* CHECK dout0_24 Vdout0_24ck26 = 1.8 time = 270
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=270.05n

* CHECK dout0_25 Vdout0_25ck26 = 0 time = 270
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=270.05n

* CHECK dout0_26 Vdout0_26ck26 = 0 time = 270
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=270.05n

* CHECK dout0_27 Vdout0_27ck26 = 1.8 time = 270
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=270.05n

* CHECK dout0_28 Vdout0_28ck26 = 0 time = 270
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=270.05n

* CHECK dout0_29 Vdout0_29ck26 = 0 time = 270
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=270.05n

* CHECK dout0_30 Vdout0_30ck26 = 1.8 time = 270
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=270.05n

* CHECK dout0_31 Vdout0_31ck26 = 1.8 time = 270
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=270.05n

* CHECK dout0_32 Vdout0_32ck26 = 0 time = 270
.meas tran vdout0_32ck26 FIND v(dout0_32) AT=270.05n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 280
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=280.05n

* CHECK dout0_1 Vdout0_1ck27 = 1.8 time = 280
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=280.05n

* CHECK dout0_2 Vdout0_2ck27 = 1.8 time = 280
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=280.05n

* CHECK dout0_3 Vdout0_3ck27 = 1.8 time = 280
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=280.05n

* CHECK dout0_4 Vdout0_4ck27 = 1.8 time = 280
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=280.05n

* CHECK dout0_5 Vdout0_5ck27 = 0 time = 280
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=280.05n

* CHECK dout0_6 Vdout0_6ck27 = 1.8 time = 280
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=280.05n

* CHECK dout0_7 Vdout0_7ck27 = 1.8 time = 280
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=280.05n

* CHECK dout0_8 Vdout0_8ck27 = 0 time = 280
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=280.05n

* CHECK dout0_9 Vdout0_9ck27 = 0 time = 280
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=280.05n

* CHECK dout0_10 Vdout0_10ck27 = 0 time = 280
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=280.05n

* CHECK dout0_11 Vdout0_11ck27 = 0 time = 280
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=280.05n

* CHECK dout0_12 Vdout0_12ck27 = 1.8 time = 280
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=280.05n

* CHECK dout0_13 Vdout0_13ck27 = 0 time = 280
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=280.05n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 280
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=280.05n

* CHECK dout0_15 Vdout0_15ck27 = 1.8 time = 280
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=280.05n

* CHECK dout0_16 Vdout0_16ck27 = 0 time = 280
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=280.05n

* CHECK dout0_17 Vdout0_17ck27 = 0 time = 280
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=280.05n

* CHECK dout0_18 Vdout0_18ck27 = 1.8 time = 280
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=280.05n

* CHECK dout0_19 Vdout0_19ck27 = 1.8 time = 280
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=280.05n

* CHECK dout0_20 Vdout0_20ck27 = 0 time = 280
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=280.05n

* CHECK dout0_21 Vdout0_21ck27 = 0 time = 280
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=280.05n

* CHECK dout0_22 Vdout0_22ck27 = 1.8 time = 280
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=280.05n

* CHECK dout0_23 Vdout0_23ck27 = 0 time = 280
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=280.05n

* CHECK dout0_24 Vdout0_24ck27 = 1.8 time = 280
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=280.05n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 280
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=280.05n

* CHECK dout0_26 Vdout0_26ck27 = 0 time = 280
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=280.05n

* CHECK dout0_27 Vdout0_27ck27 = 1.8 time = 280
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=280.05n

* CHECK dout0_28 Vdout0_28ck27 = 0 time = 280
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=280.05n

* CHECK dout0_29 Vdout0_29ck27 = 0 time = 280
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=280.05n

* CHECK dout0_30 Vdout0_30ck27 = 1.8 time = 280
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=280.05n

* CHECK dout0_31 Vdout0_31ck27 = 1.8 time = 280
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=280.05n

* CHECK dout0_32 Vdout0_32ck27 = 0 time = 280
.meas tran vdout0_32ck27 FIND v(dout0_32) AT=280.05n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 300
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=300.05n

* CHECK dout0_1 Vdout0_1ck29 = 1.8 time = 300
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=300.05n

* CHECK dout0_2 Vdout0_2ck29 = 1.8 time = 300
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=300.05n

* CHECK dout0_3 Vdout0_3ck29 = 0 time = 300
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=300.05n

* CHECK dout0_4 Vdout0_4ck29 = 1.8 time = 300
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=300.05n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 300
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=300.05n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 300
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=300.05n

* CHECK dout0_7 Vdout0_7ck29 = 1.8 time = 300
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=300.05n

* CHECK dout0_8 Vdout0_8ck29 = 0 time = 300
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=300.05n

* CHECK dout0_9 Vdout0_9ck29 = 1.8 time = 300
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=300.05n

* CHECK dout0_10 Vdout0_10ck29 = 1.8 time = 300
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=300.05n

* CHECK dout0_11 Vdout0_11ck29 = 0 time = 300
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=300.05n

* CHECK dout0_12 Vdout0_12ck29 = 1.8 time = 300
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=300.05n

* CHECK dout0_13 Vdout0_13ck29 = 1.8 time = 300
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=300.05n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 300
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=300.05n

* CHECK dout0_15 Vdout0_15ck29 = 1.8 time = 300
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=300.05n

* CHECK dout0_16 Vdout0_16ck29 = 0 time = 300
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=300.05n

* CHECK dout0_17 Vdout0_17ck29 = 0 time = 300
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=300.05n

* CHECK dout0_18 Vdout0_18ck29 = 0 time = 300
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=300.05n

* CHECK dout0_19 Vdout0_19ck29 = 1.8 time = 300
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=300.05n

* CHECK dout0_20 Vdout0_20ck29 = 0 time = 300
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=300.05n

* CHECK dout0_21 Vdout0_21ck29 = 1.8 time = 300
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=300.05n

* CHECK dout0_22 Vdout0_22ck29 = 0 time = 300
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=300.05n

* CHECK dout0_23 Vdout0_23ck29 = 1.8 time = 300
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=300.05n

* CHECK dout0_24 Vdout0_24ck29 = 0 time = 300
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=300.05n

* CHECK dout0_25 Vdout0_25ck29 = 0 time = 300
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=300.05n

* CHECK dout0_26 Vdout0_26ck29 = 1.8 time = 300
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=300.05n

* CHECK dout0_27 Vdout0_27ck29 = 1.8 time = 300
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=300.05n

* CHECK dout0_28 Vdout0_28ck29 = 1.8 time = 300
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=300.05n

* CHECK dout0_29 Vdout0_29ck29 = 0 time = 300
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=300.05n

* CHECK dout0_30 Vdout0_30ck29 = 1.8 time = 300
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=300.05n

* CHECK dout0_31 Vdout0_31ck29 = 0 time = 300
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=300.05n

* CHECK dout0_32 Vdout0_32ck29 = 0 time = 300
.meas tran vdout0_32ck29 FIND v(dout0_32) AT=300.05n

* CHECK dout0_0 Vdout0_0ck31 = 1.8 time = 320
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=320.05n

* CHECK dout0_1 Vdout0_1ck31 = 0 time = 320
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=320.05n

* CHECK dout0_2 Vdout0_2ck31 = 1.8 time = 320
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=320.05n

* CHECK dout0_3 Vdout0_3ck31 = 0 time = 320
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=320.05n

* CHECK dout0_4 Vdout0_4ck31 = 1.8 time = 320
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=320.05n

* CHECK dout0_5 Vdout0_5ck31 = 0 time = 320
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=320.05n

* CHECK dout0_6 Vdout0_6ck31 = 1.8 time = 320
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=320.05n

* CHECK dout0_7 Vdout0_7ck31 = 0 time = 320
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=320.05n

* CHECK dout0_8 Vdout0_8ck31 = 1.8 time = 320
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=320.05n

* CHECK dout0_9 Vdout0_9ck31 = 1.8 time = 320
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=320.05n

* CHECK dout0_10 Vdout0_10ck31 = 1.8 time = 320
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=320.05n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 320
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=320.05n

* CHECK dout0_12 Vdout0_12ck31 = 0 time = 320
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=320.05n

* CHECK dout0_13 Vdout0_13ck31 = 0 time = 320
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=320.05n

* CHECK dout0_14 Vdout0_14ck31 = 0 time = 320
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=320.05n

* CHECK dout0_15 Vdout0_15ck31 = 0 time = 320
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=320.05n

* CHECK dout0_16 Vdout0_16ck31 = 0 time = 320
.meas tran vdout0_16ck31 FIND v(dout0_16) AT=320.05n

* CHECK dout0_17 Vdout0_17ck31 = 1.8 time = 320
.meas tran vdout0_17ck31 FIND v(dout0_17) AT=320.05n

* CHECK dout0_18 Vdout0_18ck31 = 0 time = 320
.meas tran vdout0_18ck31 FIND v(dout0_18) AT=320.05n

* CHECK dout0_19 Vdout0_19ck31 = 0 time = 320
.meas tran vdout0_19ck31 FIND v(dout0_19) AT=320.05n

* CHECK dout0_20 Vdout0_20ck31 = 1.8 time = 320
.meas tran vdout0_20ck31 FIND v(dout0_20) AT=320.05n

* CHECK dout0_21 Vdout0_21ck31 = 1.8 time = 320
.meas tran vdout0_21ck31 FIND v(dout0_21) AT=320.05n

* CHECK dout0_22 Vdout0_22ck31 = 1.8 time = 320
.meas tran vdout0_22ck31 FIND v(dout0_22) AT=320.05n

* CHECK dout0_23 Vdout0_23ck31 = 0 time = 320
.meas tran vdout0_23ck31 FIND v(dout0_23) AT=320.05n

* CHECK dout0_24 Vdout0_24ck31 = 0 time = 320
.meas tran vdout0_24ck31 FIND v(dout0_24) AT=320.05n

* CHECK dout0_25 Vdout0_25ck31 = 1.8 time = 320
.meas tran vdout0_25ck31 FIND v(dout0_25) AT=320.05n

* CHECK dout0_26 Vdout0_26ck31 = 1.8 time = 320
.meas tran vdout0_26ck31 FIND v(dout0_26) AT=320.05n

* CHECK dout0_27 Vdout0_27ck31 = 0 time = 320
.meas tran vdout0_27ck31 FIND v(dout0_27) AT=320.05n

* CHECK dout0_28 Vdout0_28ck31 = 0 time = 320
.meas tran vdout0_28ck31 FIND v(dout0_28) AT=320.05n

* CHECK dout0_29 Vdout0_29ck31 = 1.8 time = 320
.meas tran vdout0_29ck31 FIND v(dout0_29) AT=320.05n

* CHECK dout0_30 Vdout0_30ck31 = 1.8 time = 320
.meas tran vdout0_30ck31 FIND v(dout0_30) AT=320.05n

* CHECK dout0_31 Vdout0_31ck31 = 0 time = 320
.meas tran vdout0_31ck31 FIND v(dout0_31) AT=320.05n

* CHECK dout0_32 Vdout0_32ck31 = 0 time = 320
.meas tran vdout0_32ck31 FIND v(dout0_32) AT=320.05n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 330
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=330.05n

* CHECK dout0_1 Vdout0_1ck32 = 1.8 time = 330
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=330.05n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 330
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=330.05n

* CHECK dout0_3 Vdout0_3ck32 = 1.8 time = 330
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=330.05n

* CHECK dout0_4 Vdout0_4ck32 = 0 time = 330
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=330.05n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 330
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=330.05n

* CHECK dout0_6 Vdout0_6ck32 = 1.8 time = 330
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=330.05n

* CHECK dout0_7 Vdout0_7ck32 = 1.8 time = 330
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=330.05n

* CHECK dout0_8 Vdout0_8ck32 = 0 time = 330
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=330.05n

* CHECK dout0_9 Vdout0_9ck32 = 1.8 time = 330
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=330.05n

* CHECK dout0_10 Vdout0_10ck32 = 0 time = 330
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=330.05n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 330
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=330.05n

* CHECK dout0_12 Vdout0_12ck32 = 0 time = 330
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=330.05n

* CHECK dout0_13 Vdout0_13ck32 = 1.8 time = 330
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=330.05n

* CHECK dout0_14 Vdout0_14ck32 = 1.8 time = 330
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=330.05n

* CHECK dout0_15 Vdout0_15ck32 = 1.8 time = 330
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=330.05n

* CHECK dout0_16 Vdout0_16ck32 = 0 time = 330
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=330.05n

* CHECK dout0_17 Vdout0_17ck32 = 1.8 time = 330
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=330.05n

* CHECK dout0_18 Vdout0_18ck32 = 0 time = 330
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=330.05n

* CHECK dout0_19 Vdout0_19ck32 = 1.8 time = 330
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=330.05n

* CHECK dout0_20 Vdout0_20ck32 = 1.8 time = 330
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=330.05n

* CHECK dout0_21 Vdout0_21ck32 = 0 time = 330
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=330.05n

* CHECK dout0_22 Vdout0_22ck32 = 1.8 time = 330
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=330.05n

* CHECK dout0_23 Vdout0_23ck32 = 1.8 time = 330
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=330.05n

* CHECK dout0_24 Vdout0_24ck32 = 0 time = 330
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=330.05n

* CHECK dout0_25 Vdout0_25ck32 = 0 time = 330
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=330.05n

* CHECK dout0_26 Vdout0_26ck32 = 1.8 time = 330
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=330.05n

* CHECK dout0_27 Vdout0_27ck32 = 1.8 time = 330
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=330.05n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 330
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=330.05n

* CHECK dout0_29 Vdout0_29ck32 = 1.8 time = 330
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=330.05n

* CHECK dout0_30 Vdout0_30ck32 = 1.8 time = 330
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=330.05n

* CHECK dout0_31 Vdout0_31ck32 = 1.8 time = 330
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=330.05n

* CHECK dout0_32 Vdout0_32ck32 = 0 time = 330
.meas tran vdout0_32ck32 FIND v(dout0_32) AT=330.05n

* CHECK dout0_0 Vdout0_0ck38 = 0 time = 390
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=390.05n

* CHECK dout0_1 Vdout0_1ck38 = 1.8 time = 390
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=390.05n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 390
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=390.05n

* CHECK dout0_3 Vdout0_3ck38 = 1.8 time = 390
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=390.05n

* CHECK dout0_4 Vdout0_4ck38 = 1.8 time = 390
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=390.05n

* CHECK dout0_5 Vdout0_5ck38 = 1.8 time = 390
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=390.05n

* CHECK dout0_6 Vdout0_6ck38 = 0 time = 390
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=390.05n

* CHECK dout0_7 Vdout0_7ck38 = 0 time = 390
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=390.05n

* CHECK dout0_8 Vdout0_8ck38 = 0 time = 390
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=390.05n

* CHECK dout0_9 Vdout0_9ck38 = 1.8 time = 390
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=390.05n

* CHECK dout0_10 Vdout0_10ck38 = 1.8 time = 390
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=390.05n

* CHECK dout0_11 Vdout0_11ck38 = 1.8 time = 390
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=390.05n

* CHECK dout0_12 Vdout0_12ck38 = 0 time = 390
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=390.05n

* CHECK dout0_13 Vdout0_13ck38 = 1.8 time = 390
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=390.05n

* CHECK dout0_14 Vdout0_14ck38 = 1.8 time = 390
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=390.05n

* CHECK dout0_15 Vdout0_15ck38 = 1.8 time = 390
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=390.05n

* CHECK dout0_16 Vdout0_16ck38 = 1.8 time = 390
.meas tran vdout0_16ck38 FIND v(dout0_16) AT=390.05n

* CHECK dout0_17 Vdout0_17ck38 = 1.8 time = 390
.meas tran vdout0_17ck38 FIND v(dout0_17) AT=390.05n

* CHECK dout0_18 Vdout0_18ck38 = 1.8 time = 390
.meas tran vdout0_18ck38 FIND v(dout0_18) AT=390.05n

* CHECK dout0_19 Vdout0_19ck38 = 0 time = 390
.meas tran vdout0_19ck38 FIND v(dout0_19) AT=390.05n

* CHECK dout0_20 Vdout0_20ck38 = 1.8 time = 390
.meas tran vdout0_20ck38 FIND v(dout0_20) AT=390.05n

* CHECK dout0_21 Vdout0_21ck38 = 0 time = 390
.meas tran vdout0_21ck38 FIND v(dout0_21) AT=390.05n

* CHECK dout0_22 Vdout0_22ck38 = 1.8 time = 390
.meas tran vdout0_22ck38 FIND v(dout0_22) AT=390.05n

* CHECK dout0_23 Vdout0_23ck38 = 0 time = 390
.meas tran vdout0_23ck38 FIND v(dout0_23) AT=390.05n

* CHECK dout0_24 Vdout0_24ck38 = 0 time = 390
.meas tran vdout0_24ck38 FIND v(dout0_24) AT=390.05n

* CHECK dout0_25 Vdout0_25ck38 = 0 time = 390
.meas tran vdout0_25ck38 FIND v(dout0_25) AT=390.05n

* CHECK dout0_26 Vdout0_26ck38 = 0 time = 390
.meas tran vdout0_26ck38 FIND v(dout0_26) AT=390.05n

* CHECK dout0_27 Vdout0_27ck38 = 1.8 time = 390
.meas tran vdout0_27ck38 FIND v(dout0_27) AT=390.05n

* CHECK dout0_28 Vdout0_28ck38 = 1.8 time = 390
.meas tran vdout0_28ck38 FIND v(dout0_28) AT=390.05n

* CHECK dout0_29 Vdout0_29ck38 = 0 time = 390
.meas tran vdout0_29ck38 FIND v(dout0_29) AT=390.05n

* CHECK dout0_30 Vdout0_30ck38 = 1.8 time = 390
.meas tran vdout0_30ck38 FIND v(dout0_30) AT=390.05n

* CHECK dout0_31 Vdout0_31ck38 = 0 time = 390
.meas tran vdout0_31ck38 FIND v(dout0_31) AT=390.05n

* CHECK dout0_32 Vdout0_32ck38 = 0 time = 390
.meas tran vdout0_32ck38 FIND v(dout0_32) AT=390.05n

* CHECK dout0_0 Vdout0_0ck42 = 0 time = 430
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=430.05n

* CHECK dout0_1 Vdout0_1ck42 = 1.8 time = 430
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=430.05n

* CHECK dout0_2 Vdout0_2ck42 = 1.8 time = 430
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=430.05n

* CHECK dout0_3 Vdout0_3ck42 = 1.8 time = 430
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=430.05n

* CHECK dout0_4 Vdout0_4ck42 = 1.8 time = 430
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=430.05n

* CHECK dout0_5 Vdout0_5ck42 = 1.8 time = 430
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=430.05n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 430
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=430.05n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 430
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=430.05n

* CHECK dout0_8 Vdout0_8ck42 = 0 time = 430
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=430.05n

* CHECK dout0_9 Vdout0_9ck42 = 0 time = 430
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=430.05n

* CHECK dout0_10 Vdout0_10ck42 = 1.8 time = 430
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=430.05n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 430
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=430.05n

* CHECK dout0_12 Vdout0_12ck42 = 1.8 time = 430
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=430.05n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 430
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=430.05n

* CHECK dout0_14 Vdout0_14ck42 = 0 time = 430
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=430.05n

* CHECK dout0_15 Vdout0_15ck42 = 1.8 time = 430
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=430.05n

* CHECK dout0_16 Vdout0_16ck42 = 0 time = 430
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=430.05n

* CHECK dout0_17 Vdout0_17ck42 = 1.8 time = 430
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=430.05n

* CHECK dout0_18 Vdout0_18ck42 = 0 time = 430
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=430.05n

* CHECK dout0_19 Vdout0_19ck42 = 1.8 time = 430
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=430.05n

* CHECK dout0_20 Vdout0_20ck42 = 0 time = 430
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=430.05n

* CHECK dout0_21 Vdout0_21ck42 = 1.8 time = 430
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=430.05n

* CHECK dout0_22 Vdout0_22ck42 = 1.8 time = 430
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=430.05n

* CHECK dout0_23 Vdout0_23ck42 = 1.8 time = 430
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=430.05n

* CHECK dout0_24 Vdout0_24ck42 = 1.8 time = 430
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=430.05n

* CHECK dout0_25 Vdout0_25ck42 = 1.8 time = 430
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=430.05n

* CHECK dout0_26 Vdout0_26ck42 = 0 time = 430
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=430.05n

* CHECK dout0_27 Vdout0_27ck42 = 1.8 time = 430
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=430.05n

* CHECK dout0_28 Vdout0_28ck42 = 0 time = 430
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=430.05n

* CHECK dout0_29 Vdout0_29ck42 = 1.8 time = 430
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=430.05n

* CHECK dout0_30 Vdout0_30ck42 = 1.8 time = 430
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=430.05n

* CHECK dout0_31 Vdout0_31ck42 = 0 time = 430
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=430.05n

* CHECK dout0_32 Vdout0_32ck42 = 0 time = 430
.meas tran vdout0_32ck42 FIND v(dout0_32) AT=430.05n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 450
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=450.05n

* CHECK dout0_1 Vdout0_1ck44 = 1.8 time = 450
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=450.05n

* CHECK dout0_2 Vdout0_2ck44 = 0 time = 450
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=450.05n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 450
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=450.05n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 450
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=450.05n

* CHECK dout0_5 Vdout0_5ck44 = 0 time = 450
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=450.05n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 450
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=450.05n

* CHECK dout0_7 Vdout0_7ck44 = 1.8 time = 450
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=450.05n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 450
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=450.05n

* CHECK dout0_9 Vdout0_9ck44 = 0 time = 450
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=450.05n

* CHECK dout0_10 Vdout0_10ck44 = 1.8 time = 450
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=450.05n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 450
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=450.05n

* CHECK dout0_12 Vdout0_12ck44 = 1.8 time = 450
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=450.05n

* CHECK dout0_13 Vdout0_13ck44 = 1.8 time = 450
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=450.05n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 450
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=450.05n

* CHECK dout0_15 Vdout0_15ck44 = 1.8 time = 450
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=450.05n

* CHECK dout0_16 Vdout0_16ck44 = 0 time = 450
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=450.05n

* CHECK dout0_17 Vdout0_17ck44 = 1.8 time = 450
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=450.05n

* CHECK dout0_18 Vdout0_18ck44 = 0 time = 450
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=450.05n

* CHECK dout0_19 Vdout0_19ck44 = 0 time = 450
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=450.05n

* CHECK dout0_20 Vdout0_20ck44 = 1.8 time = 450
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=450.05n

* CHECK dout0_21 Vdout0_21ck44 = 1.8 time = 450
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=450.05n

* CHECK dout0_22 Vdout0_22ck44 = 1.8 time = 450
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=450.05n

* CHECK dout0_23 Vdout0_23ck44 = 0 time = 450
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=450.05n

* CHECK dout0_24 Vdout0_24ck44 = 0 time = 450
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=450.05n

* CHECK dout0_25 Vdout0_25ck44 = 0 time = 450
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=450.05n

* CHECK dout0_26 Vdout0_26ck44 = 1.8 time = 450
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=450.05n

* CHECK dout0_27 Vdout0_27ck44 = 1.8 time = 450
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=450.05n

* CHECK dout0_28 Vdout0_28ck44 = 0 time = 450
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=450.05n

* CHECK dout0_29 Vdout0_29ck44 = 0 time = 450
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=450.05n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 450
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=450.05n

* CHECK dout0_31 Vdout0_31ck44 = 0 time = 450
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=450.05n

* CHECK dout0_32 Vdout0_32ck44 = 0 time = 450
.meas tran vdout0_32ck44 FIND v(dout0_32) AT=450.05n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 1.8 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 1.8 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 1.8 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 1.8 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 0 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 480
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=480.05n

* CHECK dout0_9 Vdout0_9ck47 = 0 time = 480
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=480.05n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 480
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=480.05n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 480
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=480.05n

* CHECK dout0_12 Vdout0_12ck47 = 1.8 time = 480
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=480.05n

* CHECK dout0_13 Vdout0_13ck47 = 0 time = 480
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=480.05n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 480
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=480.05n

* CHECK dout0_15 Vdout0_15ck47 = 1.8 time = 480
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=480.05n

* CHECK dout0_16 Vdout0_16ck47 = 0 time = 480
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=480.05n

* CHECK dout0_17 Vdout0_17ck47 = 1.8 time = 480
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=480.05n

* CHECK dout0_18 Vdout0_18ck47 = 0 time = 480
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=480.05n

* CHECK dout0_19 Vdout0_19ck47 = 1.8 time = 480
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=480.05n

* CHECK dout0_20 Vdout0_20ck47 = 0 time = 480
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=480.05n

* CHECK dout0_21 Vdout0_21ck47 = 1.8 time = 480
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=480.05n

* CHECK dout0_22 Vdout0_22ck47 = 1.8 time = 480
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=480.05n

* CHECK dout0_23 Vdout0_23ck47 = 1.8 time = 480
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=480.05n

* CHECK dout0_24 Vdout0_24ck47 = 1.8 time = 480
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=480.05n

* CHECK dout0_25 Vdout0_25ck47 = 1.8 time = 480
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=480.05n

* CHECK dout0_26 Vdout0_26ck47 = 0 time = 480
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=480.05n

* CHECK dout0_27 Vdout0_27ck47 = 1.8 time = 480
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=480.05n

* CHECK dout0_28 Vdout0_28ck47 = 0 time = 480
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=480.05n

* CHECK dout0_29 Vdout0_29ck47 = 1.8 time = 480
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=480.05n

* CHECK dout0_30 Vdout0_30ck47 = 1.8 time = 480
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=480.05n

* CHECK dout0_31 Vdout0_31ck47 = 0 time = 480
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=480.05n

* CHECK dout0_32 Vdout0_32ck47 = 0 time = 480
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=480.05n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 540
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=540.05n

* CHECK dout0_1 Vdout0_1ck53 = 0 time = 540
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=540.05n

* CHECK dout0_2 Vdout0_2ck53 = 1.8 time = 540
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=540.05n

* CHECK dout0_3 Vdout0_3ck53 = 1.8 time = 540
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=540.05n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 540
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=540.05n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 540
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=540.05n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 540
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=540.05n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 540
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=540.05n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 540
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=540.05n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 540
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=540.05n

* CHECK dout0_10 Vdout0_10ck53 = 1.8 time = 540
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=540.05n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 540
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=540.05n

* CHECK dout0_12 Vdout0_12ck53 = 1.8 time = 540
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=540.05n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 540
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=540.05n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 540
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=540.05n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 540
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=540.05n

* CHECK dout0_16 Vdout0_16ck53 = 0 time = 540
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=540.05n

* CHECK dout0_17 Vdout0_17ck53 = 1.8 time = 540
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=540.05n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 540
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=540.05n

* CHECK dout0_19 Vdout0_19ck53 = 1.8 time = 540
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=540.05n

* CHECK dout0_20 Vdout0_20ck53 = 1.8 time = 540
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=540.05n

* CHECK dout0_21 Vdout0_21ck53 = 0 time = 540
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=540.05n

* CHECK dout0_22 Vdout0_22ck53 = 1.8 time = 540
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=540.05n

* CHECK dout0_23 Vdout0_23ck53 = 1.8 time = 540
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=540.05n

* CHECK dout0_24 Vdout0_24ck53 = 0 time = 540
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=540.05n

* CHECK dout0_25 Vdout0_25ck53 = 0 time = 540
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=540.05n

* CHECK dout0_26 Vdout0_26ck53 = 1.8 time = 540
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=540.05n

* CHECK dout0_27 Vdout0_27ck53 = 1.8 time = 540
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=540.05n

* CHECK dout0_28 Vdout0_28ck53 = 1.8 time = 540
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=540.05n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 540
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=540.05n

* CHECK dout0_30 Vdout0_30ck53 = 0 time = 540
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=540.05n

* CHECK dout0_31 Vdout0_31ck53 = 0 time = 540
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=540.05n

* CHECK dout0_32 Vdout0_32ck53 = 0 time = 540
.meas tran vdout0_32ck53 FIND v(dout0_32) AT=540.05n

* CHECK dout0_0 Vdout0_0ck56 = 1.8 time = 570
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=570.05n

* CHECK dout0_1 Vdout0_1ck56 = 0 time = 570
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=570.05n

* CHECK dout0_2 Vdout0_2ck56 = 1.8 time = 570
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=570.05n

* CHECK dout0_3 Vdout0_3ck56 = 1.8 time = 570
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=570.05n

* CHECK dout0_4 Vdout0_4ck56 = 0 time = 570
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=570.05n

* CHECK dout0_5 Vdout0_5ck56 = 1.8 time = 570
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=570.05n

* CHECK dout0_6 Vdout0_6ck56 = 0 time = 570
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=570.05n

* CHECK dout0_7 Vdout0_7ck56 = 0 time = 570
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=570.05n

* CHECK dout0_8 Vdout0_8ck56 = 1.8 time = 570
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=570.05n

* CHECK dout0_9 Vdout0_9ck56 = 0 time = 570
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=570.05n

* CHECK dout0_10 Vdout0_10ck56 = 1.8 time = 570
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=570.05n

* CHECK dout0_11 Vdout0_11ck56 = 0 time = 570
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=570.05n

* CHECK dout0_12 Vdout0_12ck56 = 0 time = 570
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=570.05n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 570
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=570.05n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 570
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=570.05n

* CHECK dout0_15 Vdout0_15ck56 = 1.8 time = 570
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=570.05n

* CHECK dout0_16 Vdout0_16ck56 = 0 time = 570
.meas tran vdout0_16ck56 FIND v(dout0_16) AT=570.05n

* CHECK dout0_17 Vdout0_17ck56 = 1.8 time = 570
.meas tran vdout0_17ck56 FIND v(dout0_17) AT=570.05n

* CHECK dout0_18 Vdout0_18ck56 = 1.8 time = 570
.meas tran vdout0_18ck56 FIND v(dout0_18) AT=570.05n

* CHECK dout0_19 Vdout0_19ck56 = 1.8 time = 570
.meas tran vdout0_19ck56 FIND v(dout0_19) AT=570.05n

* CHECK dout0_20 Vdout0_20ck56 = 0 time = 570
.meas tran vdout0_20ck56 FIND v(dout0_20) AT=570.05n

* CHECK dout0_21 Vdout0_21ck56 = 1.8 time = 570
.meas tran vdout0_21ck56 FIND v(dout0_21) AT=570.05n

* CHECK dout0_22 Vdout0_22ck56 = 1.8 time = 570
.meas tran vdout0_22ck56 FIND v(dout0_22) AT=570.05n

* CHECK dout0_23 Vdout0_23ck56 = 1.8 time = 570
.meas tran vdout0_23ck56 FIND v(dout0_23) AT=570.05n

* CHECK dout0_24 Vdout0_24ck56 = 0 time = 570
.meas tran vdout0_24ck56 FIND v(dout0_24) AT=570.05n

* CHECK dout0_25 Vdout0_25ck56 = 1.8 time = 570
.meas tran vdout0_25ck56 FIND v(dout0_25) AT=570.05n

* CHECK dout0_26 Vdout0_26ck56 = 0 time = 570
.meas tran vdout0_26ck56 FIND v(dout0_26) AT=570.05n

* CHECK dout0_27 Vdout0_27ck56 = 0 time = 570
.meas tran vdout0_27ck56 FIND v(dout0_27) AT=570.05n

* CHECK dout0_28 Vdout0_28ck56 = 0 time = 570
.meas tran vdout0_28ck56 FIND v(dout0_28) AT=570.05n

* CHECK dout0_29 Vdout0_29ck56 = 1.8 time = 570
.meas tran vdout0_29ck56 FIND v(dout0_29) AT=570.05n

* CHECK dout0_30 Vdout0_30ck56 = 1.8 time = 570
.meas tran vdout0_30ck56 FIND v(dout0_30) AT=570.05n

* CHECK dout0_31 Vdout0_31ck56 = 0 time = 570
.meas tran vdout0_31ck56 FIND v(dout0_31) AT=570.05n

* CHECK dout0_32 Vdout0_32ck56 = 0 time = 570
.meas tran vdout0_32ck56 FIND v(dout0_32) AT=570.05n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 590
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=590.05n

* CHECK dout0_1 Vdout0_1ck58 = 0 time = 590
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=590.05n

* CHECK dout0_2 Vdout0_2ck58 = 1.8 time = 590
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=590.05n

* CHECK dout0_3 Vdout0_3ck58 = 1.8 time = 590
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=590.05n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 590
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=590.05n

* CHECK dout0_5 Vdout0_5ck58 = 0 time = 590
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=590.05n

* CHECK dout0_6 Vdout0_6ck58 = 1.8 time = 590
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=590.05n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 590
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=590.05n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 590
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=590.05n

* CHECK dout0_9 Vdout0_9ck58 = 1.8 time = 590
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=590.05n

* CHECK dout0_10 Vdout0_10ck58 = 1.8 time = 590
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=590.05n

* CHECK dout0_11 Vdout0_11ck58 = 0 time = 590
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=590.05n

* CHECK dout0_12 Vdout0_12ck58 = 1.8 time = 590
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=590.05n

* CHECK dout0_13 Vdout0_13ck58 = 0 time = 590
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=590.05n

* CHECK dout0_14 Vdout0_14ck58 = 1.8 time = 590
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=590.05n

* CHECK dout0_15 Vdout0_15ck58 = 1.8 time = 590
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=590.05n

* CHECK dout0_16 Vdout0_16ck58 = 1.8 time = 590
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=590.05n

* CHECK dout0_17 Vdout0_17ck58 = 1.8 time = 590
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=590.05n

* CHECK dout0_18 Vdout0_18ck58 = 0 time = 590
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=590.05n

* CHECK dout0_19 Vdout0_19ck58 = 1.8 time = 590
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=590.05n

* CHECK dout0_20 Vdout0_20ck58 = 1.8 time = 590
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=590.05n

* CHECK dout0_21 Vdout0_21ck58 = 1.8 time = 590
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=590.05n

* CHECK dout0_22 Vdout0_22ck58 = 0 time = 590
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=590.05n

* CHECK dout0_23 Vdout0_23ck58 = 1.8 time = 590
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=590.05n

* CHECK dout0_24 Vdout0_24ck58 = 1.8 time = 590
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=590.05n

* CHECK dout0_25 Vdout0_25ck58 = 1.8 time = 590
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=590.05n

* CHECK dout0_26 Vdout0_26ck58 = 0 time = 590
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=590.05n

* CHECK dout0_27 Vdout0_27ck58 = 1.8 time = 590
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=590.05n

* CHECK dout0_28 Vdout0_28ck58 = 0 time = 590
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=590.05n

* CHECK dout0_29 Vdout0_29ck58 = 1.8 time = 590
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=590.05n

* CHECK dout0_30 Vdout0_30ck58 = 1.8 time = 590
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=590.05n

* CHECK dout0_31 Vdout0_31ck58 = 0 time = 590
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=590.05n

* CHECK dout0_32 Vdout0_32ck58 = 0 time = 590
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=590.05n

* CHECK dout0_0 Vdout0_0ck60 = 1.8 time = 610
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=610.05n

* CHECK dout0_1 Vdout0_1ck60 = 1.8 time = 610
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=610.05n

* CHECK dout0_2 Vdout0_2ck60 = 1.8 time = 610
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=610.05n

* CHECK dout0_3 Vdout0_3ck60 = 1.8 time = 610
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=610.05n

* CHECK dout0_4 Vdout0_4ck60 = 1.8 time = 610
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=610.05n

* CHECK dout0_5 Vdout0_5ck60 = 1.8 time = 610
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=610.05n

* CHECK dout0_6 Vdout0_6ck60 = 1.8 time = 610
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=610.05n

* CHECK dout0_7 Vdout0_7ck60 = 0 time = 610
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=610.05n

* CHECK dout0_8 Vdout0_8ck60 = 0 time = 610
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=610.05n

* CHECK dout0_9 Vdout0_9ck60 = 0 time = 610
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=610.05n

* CHECK dout0_10 Vdout0_10ck60 = 0 time = 610
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=610.05n

* CHECK dout0_11 Vdout0_11ck60 = 1.8 time = 610
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=610.05n

* CHECK dout0_12 Vdout0_12ck60 = 0 time = 610
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=610.05n

* CHECK dout0_13 Vdout0_13ck60 = 0 time = 610
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=610.05n

* CHECK dout0_14 Vdout0_14ck60 = 0 time = 610
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=610.05n

* CHECK dout0_15 Vdout0_15ck60 = 0 time = 610
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=610.05n

* CHECK dout0_16 Vdout0_16ck60 = 0 time = 610
.meas tran vdout0_16ck60 FIND v(dout0_16) AT=610.05n

* CHECK dout0_17 Vdout0_17ck60 = 0 time = 610
.meas tran vdout0_17ck60 FIND v(dout0_17) AT=610.05n

* CHECK dout0_18 Vdout0_18ck60 = 0 time = 610
.meas tran vdout0_18ck60 FIND v(dout0_18) AT=610.05n

* CHECK dout0_19 Vdout0_19ck60 = 0 time = 610
.meas tran vdout0_19ck60 FIND v(dout0_19) AT=610.05n

* CHECK dout0_20 Vdout0_20ck60 = 1.8 time = 610
.meas tran vdout0_20ck60 FIND v(dout0_20) AT=610.05n

* CHECK dout0_21 Vdout0_21ck60 = 0 time = 610
.meas tran vdout0_21ck60 FIND v(dout0_21) AT=610.05n

* CHECK dout0_22 Vdout0_22ck60 = 0 time = 610
.meas tran vdout0_22ck60 FIND v(dout0_22) AT=610.05n

* CHECK dout0_23 Vdout0_23ck60 = 0 time = 610
.meas tran vdout0_23ck60 FIND v(dout0_23) AT=610.05n

* CHECK dout0_24 Vdout0_24ck60 = 0 time = 610
.meas tran vdout0_24ck60 FIND v(dout0_24) AT=610.05n

* CHECK dout0_25 Vdout0_25ck60 = 0 time = 610
.meas tran vdout0_25ck60 FIND v(dout0_25) AT=610.05n

* CHECK dout0_26 Vdout0_26ck60 = 1.8 time = 610
.meas tran vdout0_26ck60 FIND v(dout0_26) AT=610.05n

* CHECK dout0_27 Vdout0_27ck60 = 0 time = 610
.meas tran vdout0_27ck60 FIND v(dout0_27) AT=610.05n

* CHECK dout0_28 Vdout0_28ck60 = 0 time = 610
.meas tran vdout0_28ck60 FIND v(dout0_28) AT=610.05n

* CHECK dout0_29 Vdout0_29ck60 = 1.8 time = 610
.meas tran vdout0_29ck60 FIND v(dout0_29) AT=610.05n

* CHECK dout0_30 Vdout0_30ck60 = 1.8 time = 610
.meas tran vdout0_30ck60 FIND v(dout0_30) AT=610.05n

* CHECK dout0_31 Vdout0_31ck60 = 0 time = 610
.meas tran vdout0_31ck60 FIND v(dout0_31) AT=610.05n

* CHECK dout0_32 Vdout0_32ck60 = 0 time = 610
.meas tran vdout0_32ck60 FIND v(dout0_32) AT=610.05n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 670
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=670.05n

* CHECK dout0_1 Vdout0_1ck66 = 0 time = 670
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=670.05n

* CHECK dout0_2 Vdout0_2ck66 = 1.8 time = 670
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=670.05n

* CHECK dout0_3 Vdout0_3ck66 = 1.8 time = 670
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=670.05n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 670
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=670.05n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 670
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=670.05n

* CHECK dout0_6 Vdout0_6ck66 = 1.8 time = 670
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=670.05n

* CHECK dout0_7 Vdout0_7ck66 = 0 time = 670
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=670.05n

* CHECK dout0_8 Vdout0_8ck66 = 0 time = 670
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=670.05n

* CHECK dout0_9 Vdout0_9ck66 = 1.8 time = 670
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=670.05n

* CHECK dout0_10 Vdout0_10ck66 = 1.8 time = 670
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=670.05n

* CHECK dout0_11 Vdout0_11ck66 = 0 time = 670
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=670.05n

* CHECK dout0_12 Vdout0_12ck66 = 1.8 time = 670
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=670.05n

* CHECK dout0_13 Vdout0_13ck66 = 0 time = 670
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=670.05n

* CHECK dout0_14 Vdout0_14ck66 = 1.8 time = 670
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=670.05n

* CHECK dout0_15 Vdout0_15ck66 = 1.8 time = 670
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=670.05n

* CHECK dout0_16 Vdout0_16ck66 = 1.8 time = 670
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=670.05n

* CHECK dout0_17 Vdout0_17ck66 = 1.8 time = 670
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=670.05n

* CHECK dout0_18 Vdout0_18ck66 = 1.8 time = 670
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=670.05n

* CHECK dout0_19 Vdout0_19ck66 = 1.8 time = 670
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=670.05n

* CHECK dout0_20 Vdout0_20ck66 = 1.8 time = 670
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=670.05n

* CHECK dout0_21 Vdout0_21ck66 = 0 time = 670
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=670.05n

* CHECK dout0_22 Vdout0_22ck66 = 0 time = 670
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=670.05n

* CHECK dout0_23 Vdout0_23ck66 = 1.8 time = 670
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=670.05n

* CHECK dout0_24 Vdout0_24ck66 = 0 time = 670
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=670.05n

* CHECK dout0_25 Vdout0_25ck66 = 1.8 time = 670
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=670.05n

* CHECK dout0_26 Vdout0_26ck66 = 1.8 time = 670
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=670.05n

* CHECK dout0_27 Vdout0_27ck66 = 0 time = 670
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=670.05n

* CHECK dout0_28 Vdout0_28ck66 = 1.8 time = 670
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=670.05n

* CHECK dout0_29 Vdout0_29ck66 = 0 time = 670
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=670.05n

* CHECK dout0_30 Vdout0_30ck66 = 0 time = 670
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=670.05n

* CHECK dout0_31 Vdout0_31ck66 = 0 time = 670
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=670.05n

* CHECK dout0_32 Vdout0_32ck66 = 0 time = 670
.meas tran vdout0_32ck66 FIND v(dout0_32) AT=670.05n

* CHECK dout0_0 Vdout0_0ck68 = 1.8 time = 690
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=690.05n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 690
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=690.05n

* CHECK dout0_2 Vdout0_2ck68 = 0 time = 690
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=690.05n

* CHECK dout0_3 Vdout0_3ck68 = 1.8 time = 690
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=690.05n

* CHECK dout0_4 Vdout0_4ck68 = 1.8 time = 690
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=690.05n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 690
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=690.05n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 690
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=690.05n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 690
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=690.05n

* CHECK dout0_8 Vdout0_8ck68 = 0 time = 690
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=690.05n

* CHECK dout0_9 Vdout0_9ck68 = 1.8 time = 690
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=690.05n

* CHECK dout0_10 Vdout0_10ck68 = 1.8 time = 690
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=690.05n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 690
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=690.05n

* CHECK dout0_12 Vdout0_12ck68 = 1.8 time = 690
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=690.05n

* CHECK dout0_13 Vdout0_13ck68 = 0 time = 690
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=690.05n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 690
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=690.05n

* CHECK dout0_15 Vdout0_15ck68 = 0 time = 690
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=690.05n

* CHECK dout0_16 Vdout0_16ck68 = 1.8 time = 690
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=690.05n

* CHECK dout0_17 Vdout0_17ck68 = 0 time = 690
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=690.05n

* CHECK dout0_18 Vdout0_18ck68 = 0 time = 690
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=690.05n

* CHECK dout0_19 Vdout0_19ck68 = 1.8 time = 690
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=690.05n

* CHECK dout0_20 Vdout0_20ck68 = 1.8 time = 690
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=690.05n

* CHECK dout0_21 Vdout0_21ck68 = 1.8 time = 690
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=690.05n

* CHECK dout0_22 Vdout0_22ck68 = 0 time = 690
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=690.05n

* CHECK dout0_23 Vdout0_23ck68 = 0 time = 690
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=690.05n

* CHECK dout0_24 Vdout0_24ck68 = 1.8 time = 690
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=690.05n

* CHECK dout0_25 Vdout0_25ck68 = 1.8 time = 690
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=690.05n

* CHECK dout0_26 Vdout0_26ck68 = 1.8 time = 690
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=690.05n

* CHECK dout0_27 Vdout0_27ck68 = 1.8 time = 690
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=690.05n

* CHECK dout0_28 Vdout0_28ck68 = 0 time = 690
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=690.05n

* CHECK dout0_29 Vdout0_29ck68 = 1.8 time = 690
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=690.05n

* CHECK dout0_30 Vdout0_30ck68 = 0 time = 690
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=690.05n

* CHECK dout0_31 Vdout0_31ck68 = 0 time = 690
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=690.05n

* CHECK dout0_32 Vdout0_32ck68 = 0 time = 690
.meas tran vdout0_32ck68 FIND v(dout0_32) AT=690.05n

* CHECK dout0_0 Vdout0_0ck69 = 1.8 time = 700
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=700.05n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 700
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=700.05n

* CHECK dout0_2 Vdout0_2ck69 = 1.8 time = 700
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=700.05n

* CHECK dout0_3 Vdout0_3ck69 = 1.8 time = 700
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=700.05n

* CHECK dout0_4 Vdout0_4ck69 = 0 time = 700
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=700.05n

* CHECK dout0_5 Vdout0_5ck69 = 1.8 time = 700
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=700.05n

* CHECK dout0_6 Vdout0_6ck69 = 0 time = 700
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=700.05n

* CHECK dout0_7 Vdout0_7ck69 = 0 time = 700
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=700.05n

* CHECK dout0_8 Vdout0_8ck69 = 1.8 time = 700
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=700.05n

* CHECK dout0_9 Vdout0_9ck69 = 1.8 time = 700
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=700.05n

* CHECK dout0_10 Vdout0_10ck69 = 0 time = 700
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=700.05n

* CHECK dout0_11 Vdout0_11ck69 = 0 time = 700
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=700.05n

* CHECK dout0_12 Vdout0_12ck69 = 1.8 time = 700
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=700.05n

* CHECK dout0_13 Vdout0_13ck69 = 1.8 time = 700
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=700.05n

* CHECK dout0_14 Vdout0_14ck69 = 0 time = 700
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=700.05n

* CHECK dout0_15 Vdout0_15ck69 = 0 time = 700
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=700.05n

* CHECK dout0_16 Vdout0_16ck69 = 1.8 time = 700
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=700.05n

* CHECK dout0_17 Vdout0_17ck69 = 1.8 time = 700
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=700.05n

* CHECK dout0_18 Vdout0_18ck69 = 1.8 time = 700
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=700.05n

* CHECK dout0_19 Vdout0_19ck69 = 0 time = 700
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=700.05n

* CHECK dout0_20 Vdout0_20ck69 = 0 time = 700
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=700.05n

* CHECK dout0_21 Vdout0_21ck69 = 0 time = 700
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=700.05n

* CHECK dout0_22 Vdout0_22ck69 = 1.8 time = 700
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=700.05n

* CHECK dout0_23 Vdout0_23ck69 = 0 time = 700
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=700.05n

* CHECK dout0_24 Vdout0_24ck69 = 1.8 time = 700
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=700.05n

* CHECK dout0_25 Vdout0_25ck69 = 1.8 time = 700
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=700.05n

* CHECK dout0_26 Vdout0_26ck69 = 1.8 time = 700
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=700.05n

* CHECK dout0_27 Vdout0_27ck69 = 1.8 time = 700
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=700.05n

* CHECK dout0_28 Vdout0_28ck69 = 1.8 time = 700
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=700.05n

* CHECK dout0_29 Vdout0_29ck69 = 1.8 time = 700
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=700.05n

* CHECK dout0_30 Vdout0_30ck69 = 1.8 time = 700
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=700.05n

* CHECK dout0_31 Vdout0_31ck69 = 0 time = 700
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=700.05n

* CHECK dout0_32 Vdout0_32ck69 = 0 time = 700
.meas tran vdout0_32ck69 FIND v(dout0_32) AT=700.05n

* CHECK dout0_0 Vdout0_0ck71 = 0 time = 720
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=720.05n

* CHECK dout0_1 Vdout0_1ck71 = 1.8 time = 720
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=720.05n

* CHECK dout0_2 Vdout0_2ck71 = 0 time = 720
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=720.05n

* CHECK dout0_3 Vdout0_3ck71 = 1.8 time = 720
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=720.05n

* CHECK dout0_4 Vdout0_4ck71 = 1.8 time = 720
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=720.05n

* CHECK dout0_5 Vdout0_5ck71 = 0 time = 720
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=720.05n

* CHECK dout0_6 Vdout0_6ck71 = 0 time = 720
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=720.05n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 720
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=720.05n

* CHECK dout0_8 Vdout0_8ck71 = 0 time = 720
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=720.05n

* CHECK dout0_9 Vdout0_9ck71 = 1.8 time = 720
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=720.05n

* CHECK dout0_10 Vdout0_10ck71 = 0 time = 720
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=720.05n

* CHECK dout0_11 Vdout0_11ck71 = 1.8 time = 720
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=720.05n

* CHECK dout0_12 Vdout0_12ck71 = 0 time = 720
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=720.05n

* CHECK dout0_13 Vdout0_13ck71 = 1.8 time = 720
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=720.05n

* CHECK dout0_14 Vdout0_14ck71 = 1.8 time = 720
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=720.05n

* CHECK dout0_15 Vdout0_15ck71 = 0 time = 720
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=720.05n

* CHECK dout0_16 Vdout0_16ck71 = 1.8 time = 720
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=720.05n

* CHECK dout0_17 Vdout0_17ck71 = 0 time = 720
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=720.05n

* CHECK dout0_18 Vdout0_18ck71 = 0 time = 720
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=720.05n

* CHECK dout0_19 Vdout0_19ck71 = 1.8 time = 720
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=720.05n

* CHECK dout0_20 Vdout0_20ck71 = 1.8 time = 720
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=720.05n

* CHECK dout0_21 Vdout0_21ck71 = 1.8 time = 720
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=720.05n

* CHECK dout0_22 Vdout0_22ck71 = 1.8 time = 720
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=720.05n

* CHECK dout0_23 Vdout0_23ck71 = 1.8 time = 720
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=720.05n

* CHECK dout0_24 Vdout0_24ck71 = 0 time = 720
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=720.05n

* CHECK dout0_25 Vdout0_25ck71 = 0 time = 720
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=720.05n

* CHECK dout0_26 Vdout0_26ck71 = 1.8 time = 720
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=720.05n

* CHECK dout0_27 Vdout0_27ck71 = 0 time = 720
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=720.05n

* CHECK dout0_28 Vdout0_28ck71 = 0 time = 720
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=720.05n

* CHECK dout0_29 Vdout0_29ck71 = 1.8 time = 720
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=720.05n

* CHECK dout0_30 Vdout0_30ck71 = 1.8 time = 720
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=720.05n

* CHECK dout0_31 Vdout0_31ck71 = 0 time = 720
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=720.05n

* CHECK dout0_32 Vdout0_32ck71 = 0 time = 720
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=720.05n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 750
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=750.05n

* CHECK dout0_1 Vdout0_1ck74 = 0 time = 750
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=750.05n

* CHECK dout0_2 Vdout0_2ck74 = 1.8 time = 750
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=750.05n

* CHECK dout0_3 Vdout0_3ck74 = 1.8 time = 750
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=750.05n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 750
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=750.05n

* CHECK dout0_5 Vdout0_5ck74 = 0 time = 750
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=750.05n

* CHECK dout0_6 Vdout0_6ck74 = 0 time = 750
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=750.05n

* CHECK dout0_7 Vdout0_7ck74 = 0 time = 750
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=750.05n

* CHECK dout0_8 Vdout0_8ck74 = 1.8 time = 750
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=750.05n

* CHECK dout0_9 Vdout0_9ck74 = 0 time = 750
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=750.05n

* CHECK dout0_10 Vdout0_10ck74 = 0 time = 750
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=750.05n

* CHECK dout0_11 Vdout0_11ck74 = 0 time = 750
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=750.05n

* CHECK dout0_12 Vdout0_12ck74 = 1.8 time = 750
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=750.05n

* CHECK dout0_13 Vdout0_13ck74 = 0 time = 750
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=750.05n

* CHECK dout0_14 Vdout0_14ck74 = 0 time = 750
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=750.05n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 750
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=750.05n

* CHECK dout0_16 Vdout0_16ck74 = 1.8 time = 750
.meas tran vdout0_16ck74 FIND v(dout0_16) AT=750.05n

* CHECK dout0_17 Vdout0_17ck74 = 0 time = 750
.meas tran vdout0_17ck74 FIND v(dout0_17) AT=750.05n

* CHECK dout0_18 Vdout0_18ck74 = 1.8 time = 750
.meas tran vdout0_18ck74 FIND v(dout0_18) AT=750.05n

* CHECK dout0_19 Vdout0_19ck74 = 0 time = 750
.meas tran vdout0_19ck74 FIND v(dout0_19) AT=750.05n

* CHECK dout0_20 Vdout0_20ck74 = 0 time = 750
.meas tran vdout0_20ck74 FIND v(dout0_20) AT=750.05n

* CHECK dout0_21 Vdout0_21ck74 = 0 time = 750
.meas tran vdout0_21ck74 FIND v(dout0_21) AT=750.05n

* CHECK dout0_22 Vdout0_22ck74 = 1.8 time = 750
.meas tran vdout0_22ck74 FIND v(dout0_22) AT=750.05n

* CHECK dout0_23 Vdout0_23ck74 = 1.8 time = 750
.meas tran vdout0_23ck74 FIND v(dout0_23) AT=750.05n

* CHECK dout0_24 Vdout0_24ck74 = 0 time = 750
.meas tran vdout0_24ck74 FIND v(dout0_24) AT=750.05n

* CHECK dout0_25 Vdout0_25ck74 = 0 time = 750
.meas tran vdout0_25ck74 FIND v(dout0_25) AT=750.05n

* CHECK dout0_26 Vdout0_26ck74 = 0 time = 750
.meas tran vdout0_26ck74 FIND v(dout0_26) AT=750.05n

* CHECK dout0_27 Vdout0_27ck74 = 1.8 time = 750
.meas tran vdout0_27ck74 FIND v(dout0_27) AT=750.05n

* CHECK dout0_28 Vdout0_28ck74 = 1.8 time = 750
.meas tran vdout0_28ck74 FIND v(dout0_28) AT=750.05n

* CHECK dout0_29 Vdout0_29ck74 = 0 time = 750
.meas tran vdout0_29ck74 FIND v(dout0_29) AT=750.05n

* CHECK dout0_30 Vdout0_30ck74 = 0 time = 750
.meas tran vdout0_30ck74 FIND v(dout0_30) AT=750.05n

* CHECK dout0_31 Vdout0_31ck74 = 1.8 time = 750
.meas tran vdout0_31ck74 FIND v(dout0_31) AT=750.05n

* CHECK dout0_32 Vdout0_32ck74 = 0 time = 750
.meas tran vdout0_32ck74 FIND v(dout0_32) AT=750.05n

* CHECK dout0_0 Vdout0_0ck75 = 1.8 time = 760
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=760.05n

* CHECK dout0_1 Vdout0_1ck75 = 0 time = 760
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=760.05n

* CHECK dout0_2 Vdout0_2ck75 = 1.8 time = 760
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=760.05n

* CHECK dout0_3 Vdout0_3ck75 = 1.8 time = 760
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=760.05n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 760
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=760.05n

* CHECK dout0_5 Vdout0_5ck75 = 1.8 time = 760
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=760.05n

* CHECK dout0_6 Vdout0_6ck75 = 0 time = 760
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=760.05n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 760
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=760.05n

* CHECK dout0_8 Vdout0_8ck75 = 1.8 time = 760
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=760.05n

* CHECK dout0_9 Vdout0_9ck75 = 1.8 time = 760
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=760.05n

* CHECK dout0_10 Vdout0_10ck75 = 0 time = 760
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=760.05n

* CHECK dout0_11 Vdout0_11ck75 = 0 time = 760
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=760.05n

* CHECK dout0_12 Vdout0_12ck75 = 1.8 time = 760
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=760.05n

* CHECK dout0_13 Vdout0_13ck75 = 1.8 time = 760
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=760.05n

* CHECK dout0_14 Vdout0_14ck75 = 0 time = 760
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=760.05n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 760
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=760.05n

* CHECK dout0_16 Vdout0_16ck75 = 1.8 time = 760
.meas tran vdout0_16ck75 FIND v(dout0_16) AT=760.05n

* CHECK dout0_17 Vdout0_17ck75 = 1.8 time = 760
.meas tran vdout0_17ck75 FIND v(dout0_17) AT=760.05n

* CHECK dout0_18 Vdout0_18ck75 = 1.8 time = 760
.meas tran vdout0_18ck75 FIND v(dout0_18) AT=760.05n

* CHECK dout0_19 Vdout0_19ck75 = 0 time = 760
.meas tran vdout0_19ck75 FIND v(dout0_19) AT=760.05n

* CHECK dout0_20 Vdout0_20ck75 = 0 time = 760
.meas tran vdout0_20ck75 FIND v(dout0_20) AT=760.05n

* CHECK dout0_21 Vdout0_21ck75 = 0 time = 760
.meas tran vdout0_21ck75 FIND v(dout0_21) AT=760.05n

* CHECK dout0_22 Vdout0_22ck75 = 1.8 time = 760
.meas tran vdout0_22ck75 FIND v(dout0_22) AT=760.05n

* CHECK dout0_23 Vdout0_23ck75 = 0 time = 760
.meas tran vdout0_23ck75 FIND v(dout0_23) AT=760.05n

* CHECK dout0_24 Vdout0_24ck75 = 1.8 time = 760
.meas tran vdout0_24ck75 FIND v(dout0_24) AT=760.05n

* CHECK dout0_25 Vdout0_25ck75 = 1.8 time = 760
.meas tran vdout0_25ck75 FIND v(dout0_25) AT=760.05n

* CHECK dout0_26 Vdout0_26ck75 = 1.8 time = 760
.meas tran vdout0_26ck75 FIND v(dout0_26) AT=760.05n

* CHECK dout0_27 Vdout0_27ck75 = 1.8 time = 760
.meas tran vdout0_27ck75 FIND v(dout0_27) AT=760.05n

* CHECK dout0_28 Vdout0_28ck75 = 1.8 time = 760
.meas tran vdout0_28ck75 FIND v(dout0_28) AT=760.05n

* CHECK dout0_29 Vdout0_29ck75 = 1.8 time = 760
.meas tran vdout0_29ck75 FIND v(dout0_29) AT=760.05n

* CHECK dout0_30 Vdout0_30ck75 = 1.8 time = 760
.meas tran vdout0_30ck75 FIND v(dout0_30) AT=760.05n

* CHECK dout0_31 Vdout0_31ck75 = 0 time = 760
.meas tran vdout0_31ck75 FIND v(dout0_31) AT=760.05n

* CHECK dout0_32 Vdout0_32ck75 = 0 time = 760
.meas tran vdout0_32ck75 FIND v(dout0_32) AT=760.05n

* CHECK dout0_0 Vdout0_0ck76 = 1.8 time = 770
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=770.05n

* CHECK dout0_1 Vdout0_1ck76 = 0 time = 770
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=770.05n

* CHECK dout0_2 Vdout0_2ck76 = 1.8 time = 770
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=770.05n

* CHECK dout0_3 Vdout0_3ck76 = 1.8 time = 770
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=770.05n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 770
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=770.05n

* CHECK dout0_5 Vdout0_5ck76 = 1.8 time = 770
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=770.05n

* CHECK dout0_6 Vdout0_6ck76 = 0 time = 770
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=770.05n

* CHECK dout0_7 Vdout0_7ck76 = 0 time = 770
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=770.05n

* CHECK dout0_8 Vdout0_8ck76 = 1.8 time = 770
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=770.05n

* CHECK dout0_9 Vdout0_9ck76 = 1.8 time = 770
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=770.05n

* CHECK dout0_10 Vdout0_10ck76 = 0 time = 770
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=770.05n

* CHECK dout0_11 Vdout0_11ck76 = 0 time = 770
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=770.05n

* CHECK dout0_12 Vdout0_12ck76 = 1.8 time = 770
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=770.05n

* CHECK dout0_13 Vdout0_13ck76 = 1.8 time = 770
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=770.05n

* CHECK dout0_14 Vdout0_14ck76 = 0 time = 770
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=770.05n

* CHECK dout0_15 Vdout0_15ck76 = 0 time = 770
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=770.05n

* CHECK dout0_16 Vdout0_16ck76 = 1.8 time = 770
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=770.05n

* CHECK dout0_17 Vdout0_17ck76 = 1.8 time = 770
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=770.05n

* CHECK dout0_18 Vdout0_18ck76 = 1.8 time = 770
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=770.05n

* CHECK dout0_19 Vdout0_19ck76 = 0 time = 770
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=770.05n

* CHECK dout0_20 Vdout0_20ck76 = 0 time = 770
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=770.05n

* CHECK dout0_21 Vdout0_21ck76 = 0 time = 770
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=770.05n

* CHECK dout0_22 Vdout0_22ck76 = 1.8 time = 770
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=770.05n

* CHECK dout0_23 Vdout0_23ck76 = 0 time = 770
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=770.05n

* CHECK dout0_24 Vdout0_24ck76 = 1.8 time = 770
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=770.05n

* CHECK dout0_25 Vdout0_25ck76 = 1.8 time = 770
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=770.05n

* CHECK dout0_26 Vdout0_26ck76 = 1.8 time = 770
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=770.05n

* CHECK dout0_27 Vdout0_27ck76 = 1.8 time = 770
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=770.05n

* CHECK dout0_28 Vdout0_28ck76 = 1.8 time = 770
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=770.05n

* CHECK dout0_29 Vdout0_29ck76 = 1.8 time = 770
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=770.05n

* CHECK dout0_30 Vdout0_30ck76 = 1.8 time = 770
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=770.05n

* CHECK dout0_31 Vdout0_31ck76 = 0 time = 770
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=770.05n

* CHECK dout0_32 Vdout0_32ck76 = 0 time = 770
.meas tran vdout0_32ck76 FIND v(dout0_32) AT=770.05n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 800
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=800.05n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 800
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=800.05n

* CHECK dout0_2 Vdout0_2ck79 = 1.8 time = 800
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=800.05n

* CHECK dout0_3 Vdout0_3ck79 = 1.8 time = 800
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=800.05n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 800
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=800.05n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 800
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=800.05n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 800
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=800.05n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 800
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=800.05n

* CHECK dout0_8 Vdout0_8ck79 = 1.8 time = 800
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=800.05n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 800
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=800.05n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 800
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=800.05n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 800
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=800.05n

* CHECK dout0_12 Vdout0_12ck79 = 1.8 time = 800
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=800.05n

* CHECK dout0_13 Vdout0_13ck79 = 0 time = 800
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=800.05n

* CHECK dout0_14 Vdout0_14ck79 = 0 time = 800
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=800.05n

* CHECK dout0_15 Vdout0_15ck79 = 0 time = 800
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=800.05n

* CHECK dout0_16 Vdout0_16ck79 = 1.8 time = 800
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=800.05n

* CHECK dout0_17 Vdout0_17ck79 = 0 time = 800
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=800.05n

* CHECK dout0_18 Vdout0_18ck79 = 1.8 time = 800
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=800.05n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 800
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=800.05n

* CHECK dout0_20 Vdout0_20ck79 = 0 time = 800
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=800.05n

* CHECK dout0_21 Vdout0_21ck79 = 0 time = 800
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=800.05n

* CHECK dout0_22 Vdout0_22ck79 = 1.8 time = 800
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=800.05n

* CHECK dout0_23 Vdout0_23ck79 = 1.8 time = 800
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=800.05n

* CHECK dout0_24 Vdout0_24ck79 = 0 time = 800
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=800.05n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 800
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=800.05n

* CHECK dout0_26 Vdout0_26ck79 = 0 time = 800
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=800.05n

* CHECK dout0_27 Vdout0_27ck79 = 1.8 time = 800
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=800.05n

* CHECK dout0_28 Vdout0_28ck79 = 1.8 time = 800
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=800.05n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 800
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=800.05n

* CHECK dout0_30 Vdout0_30ck79 = 0 time = 800
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=800.05n

* CHECK dout0_31 Vdout0_31ck79 = 1.8 time = 800
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=800.05n

* CHECK dout0_32 Vdout0_32ck79 = 0 time = 800
.meas tran vdout0_32ck79 FIND v(dout0_32) AT=800.05n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 820
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=820.05n

* CHECK dout0_1 Vdout0_1ck81 = 0 time = 820
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=820.05n

* CHECK dout0_2 Vdout0_2ck81 = 1.8 time = 820
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=820.05n

* CHECK dout0_3 Vdout0_3ck81 = 1.8 time = 820
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=820.05n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 820
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=820.05n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 820
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=820.05n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 820
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=820.05n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 820
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=820.05n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 820
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=820.05n

* CHECK dout0_9 Vdout0_9ck81 = 1.8 time = 820
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=820.05n

* CHECK dout0_10 Vdout0_10ck81 = 1.8 time = 820
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=820.05n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 820
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=820.05n

* CHECK dout0_12 Vdout0_12ck81 = 1.8 time = 820
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=820.05n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 820
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=820.05n

* CHECK dout0_14 Vdout0_14ck81 = 1.8 time = 820
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=820.05n

* CHECK dout0_15 Vdout0_15ck81 = 1.8 time = 820
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=820.05n

* CHECK dout0_16 Vdout0_16ck81 = 1.8 time = 820
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=820.05n

* CHECK dout0_17 Vdout0_17ck81 = 1.8 time = 820
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=820.05n

* CHECK dout0_18 Vdout0_18ck81 = 1.8 time = 820
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=820.05n

* CHECK dout0_19 Vdout0_19ck81 = 1.8 time = 820
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=820.05n

* CHECK dout0_20 Vdout0_20ck81 = 1.8 time = 820
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=820.05n

* CHECK dout0_21 Vdout0_21ck81 = 0 time = 820
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=820.05n

* CHECK dout0_22 Vdout0_22ck81 = 0 time = 820
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=820.05n

* CHECK dout0_23 Vdout0_23ck81 = 1.8 time = 820
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=820.05n

* CHECK dout0_24 Vdout0_24ck81 = 0 time = 820
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=820.05n

* CHECK dout0_25 Vdout0_25ck81 = 1.8 time = 820
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=820.05n

* CHECK dout0_26 Vdout0_26ck81 = 1.8 time = 820
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=820.05n

* CHECK dout0_27 Vdout0_27ck81 = 0 time = 820
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=820.05n

* CHECK dout0_28 Vdout0_28ck81 = 1.8 time = 820
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=820.05n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 820
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=820.05n

* CHECK dout0_30 Vdout0_30ck81 = 0 time = 820
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=820.05n

* CHECK dout0_31 Vdout0_31ck81 = 0 time = 820
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=820.05n

* CHECK dout0_32 Vdout0_32ck81 = 0 time = 820
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=820.05n

* CHECK dout0_0 Vdout0_0ck90 = 1.8 time = 910
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=910.05n

* CHECK dout0_1 Vdout0_1ck90 = 0 time = 910
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=910.05n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 910
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=910.05n

* CHECK dout0_3 Vdout0_3ck90 = 1.8 time = 910
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=910.05n

* CHECK dout0_4 Vdout0_4ck90 = 0 time = 910
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=910.05n

* CHECK dout0_5 Vdout0_5ck90 = 1.8 time = 910
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=910.05n

* CHECK dout0_6 Vdout0_6ck90 = 1.8 time = 910
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=910.05n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 910
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=910.05n

* CHECK dout0_8 Vdout0_8ck90 = 0 time = 910
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=910.05n

* CHECK dout0_9 Vdout0_9ck90 = 1.8 time = 910
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=910.05n

* CHECK dout0_10 Vdout0_10ck90 = 1.8 time = 910
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=910.05n

* CHECK dout0_11 Vdout0_11ck90 = 0 time = 910
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=910.05n

* CHECK dout0_12 Vdout0_12ck90 = 1.8 time = 910
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=910.05n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 910
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=910.05n

* CHECK dout0_14 Vdout0_14ck90 = 1.8 time = 910
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=910.05n

* CHECK dout0_15 Vdout0_15ck90 = 1.8 time = 910
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=910.05n

* CHECK dout0_16 Vdout0_16ck90 = 1.8 time = 910
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=910.05n

* CHECK dout0_17 Vdout0_17ck90 = 1.8 time = 910
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=910.05n

* CHECK dout0_18 Vdout0_18ck90 = 1.8 time = 910
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=910.05n

* CHECK dout0_19 Vdout0_19ck90 = 1.8 time = 910
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=910.05n

* CHECK dout0_20 Vdout0_20ck90 = 1.8 time = 910
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=910.05n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 910
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=910.05n

* CHECK dout0_22 Vdout0_22ck90 = 0 time = 910
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=910.05n

* CHECK dout0_23 Vdout0_23ck90 = 1.8 time = 910
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=910.05n

* CHECK dout0_24 Vdout0_24ck90 = 0 time = 910
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=910.05n

* CHECK dout0_25 Vdout0_25ck90 = 0 time = 910
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=910.05n

* CHECK dout0_26 Vdout0_26ck90 = 1.8 time = 910
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=910.05n

* CHECK dout0_27 Vdout0_27ck90 = 1.8 time = 910
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=910.05n

* CHECK dout0_28 Vdout0_28ck90 = 1.8 time = 910
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=910.05n

* CHECK dout0_29 Vdout0_29ck90 = 1.8 time = 910
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=910.05n

* CHECK dout0_30 Vdout0_30ck90 = 1.8 time = 910
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=910.05n

* CHECK dout0_31 Vdout0_31ck90 = 0 time = 910
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=910.05n

* CHECK dout0_32 Vdout0_32ck90 = 0 time = 910
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=910.05n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 940
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=940.05n

* CHECK dout0_1 Vdout0_1ck93 = 0 time = 940
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=940.05n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 940
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=940.05n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 940
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=940.05n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 940
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=940.05n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 940
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=940.05n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 940
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=940.05n

* CHECK dout0_7 Vdout0_7ck93 = 1.8 time = 940
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=940.05n

* CHECK dout0_8 Vdout0_8ck93 = 1.8 time = 940
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=940.05n

* CHECK dout0_9 Vdout0_9ck93 = 1.8 time = 940
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=940.05n

* CHECK dout0_10 Vdout0_10ck93 = 1.8 time = 940
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=940.05n

* CHECK dout0_11 Vdout0_11ck93 = 1.8 time = 940
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=940.05n

* CHECK dout0_12 Vdout0_12ck93 = 0 time = 940
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=940.05n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 940
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=940.05n

* CHECK dout0_14 Vdout0_14ck93 = 0 time = 940
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=940.05n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 940
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=940.05n

* CHECK dout0_16 Vdout0_16ck93 = 1.8 time = 940
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=940.05n

* CHECK dout0_17 Vdout0_17ck93 = 1.8 time = 940
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=940.05n

* CHECK dout0_18 Vdout0_18ck93 = 0 time = 940
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=940.05n

* CHECK dout0_19 Vdout0_19ck93 = 1.8 time = 940
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=940.05n

* CHECK dout0_20 Vdout0_20ck93 = 1.8 time = 940
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=940.05n

* CHECK dout0_21 Vdout0_21ck93 = 1.8 time = 940
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=940.05n

* CHECK dout0_22 Vdout0_22ck93 = 0 time = 940
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=940.05n

* CHECK dout0_23 Vdout0_23ck93 = 1.8 time = 940
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=940.05n

* CHECK dout0_24 Vdout0_24ck93 = 0 time = 940
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=940.05n

* CHECK dout0_25 Vdout0_25ck93 = 0 time = 940
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=940.05n

* CHECK dout0_26 Vdout0_26ck93 = 1.8 time = 940
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=940.05n

* CHECK dout0_27 Vdout0_27ck93 = 0 time = 940
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=940.05n

* CHECK dout0_28 Vdout0_28ck93 = 0 time = 940
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=940.05n

* CHECK dout0_29 Vdout0_29ck93 = 0 time = 940
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=940.05n

* CHECK dout0_30 Vdout0_30ck93 = 1.8 time = 940
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=940.05n

* CHECK dout0_31 Vdout0_31ck93 = 0 time = 940
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=940.05n

* CHECK dout0_32 Vdout0_32ck93 = 0 time = 940
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=940.05n

* CHECK dout0_0 Vdout0_0ck95 = 0 time = 960
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=960.05n

* CHECK dout0_1 Vdout0_1ck95 = 0 time = 960
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=960.05n

* CHECK dout0_2 Vdout0_2ck95 = 1.8 time = 960
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=960.05n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 960
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=960.05n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 960
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=960.05n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 960
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=960.05n

* CHECK dout0_6 Vdout0_6ck95 = 0 time = 960
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=960.05n

* CHECK dout0_7 Vdout0_7ck95 = 1.8 time = 960
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=960.05n

* CHECK dout0_8 Vdout0_8ck95 = 1.8 time = 960
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=960.05n

* CHECK dout0_9 Vdout0_9ck95 = 1.8 time = 960
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=960.05n

* CHECK dout0_10 Vdout0_10ck95 = 1.8 time = 960
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=960.05n

* CHECK dout0_11 Vdout0_11ck95 = 1.8 time = 960
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=960.05n

* CHECK dout0_12 Vdout0_12ck95 = 0 time = 960
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=960.05n

* CHECK dout0_13 Vdout0_13ck95 = 0 time = 960
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=960.05n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 960
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=960.05n

* CHECK dout0_15 Vdout0_15ck95 = 1.8 time = 960
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=960.05n

* CHECK dout0_16 Vdout0_16ck95 = 1.8 time = 960
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=960.05n

* CHECK dout0_17 Vdout0_17ck95 = 1.8 time = 960
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=960.05n

* CHECK dout0_18 Vdout0_18ck95 = 0 time = 960
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=960.05n

* CHECK dout0_19 Vdout0_19ck95 = 1.8 time = 960
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=960.05n

* CHECK dout0_20 Vdout0_20ck95 = 1.8 time = 960
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=960.05n

* CHECK dout0_21 Vdout0_21ck95 = 1.8 time = 960
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=960.05n

* CHECK dout0_22 Vdout0_22ck95 = 0 time = 960
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=960.05n

* CHECK dout0_23 Vdout0_23ck95 = 1.8 time = 960
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=960.05n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 960
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=960.05n

* CHECK dout0_25 Vdout0_25ck95 = 0 time = 960
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=960.05n

* CHECK dout0_26 Vdout0_26ck95 = 1.8 time = 960
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=960.05n

* CHECK dout0_27 Vdout0_27ck95 = 0 time = 960
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=960.05n

* CHECK dout0_28 Vdout0_28ck95 = 0 time = 960
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=960.05n

* CHECK dout0_29 Vdout0_29ck95 = 0 time = 960
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=960.05n

* CHECK dout0_30 Vdout0_30ck95 = 1.8 time = 960
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=960.05n

* CHECK dout0_31 Vdout0_31ck95 = 0 time = 960
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=960.05n

* CHECK dout0_32 Vdout0_32ck95 = 0 time = 960
.meas tran vdout0_32ck95 FIND v(dout0_32) AT=960.05n

* CHECK dout0_0 Vdout0_0ck96 = 1.8 time = 970
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=970.05n

* CHECK dout0_1 Vdout0_1ck96 = 0 time = 970
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=970.05n

* CHECK dout0_2 Vdout0_2ck96 = 1.8 time = 970
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=970.05n

* CHECK dout0_3 Vdout0_3ck96 = 1.8 time = 970
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=970.05n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 970
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=970.05n

* CHECK dout0_5 Vdout0_5ck96 = 1.8 time = 970
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=970.05n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 970
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=970.05n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 970
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=970.05n

* CHECK dout0_8 Vdout0_8ck96 = 1.8 time = 970
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=970.05n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 970
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=970.05n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 970
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=970.05n

* CHECK dout0_11 Vdout0_11ck96 = 1.8 time = 970
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=970.05n

* CHECK dout0_12 Vdout0_12ck96 = 1.8 time = 970
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=970.05n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 970
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=970.05n

* CHECK dout0_14 Vdout0_14ck96 = 0 time = 970
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=970.05n

* CHECK dout0_15 Vdout0_15ck96 = 1.8 time = 970
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=970.05n

* CHECK dout0_16 Vdout0_16ck96 = 1.8 time = 970
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=970.05n

* CHECK dout0_17 Vdout0_17ck96 = 1.8 time = 970
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=970.05n

* CHECK dout0_18 Vdout0_18ck96 = 1.8 time = 970
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=970.05n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 970
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=970.05n

* CHECK dout0_20 Vdout0_20ck96 = 0 time = 970
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=970.05n

* CHECK dout0_21 Vdout0_21ck96 = 0 time = 970
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=970.05n

* CHECK dout0_22 Vdout0_22ck96 = 1.8 time = 970
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=970.05n

* CHECK dout0_23 Vdout0_23ck96 = 0 time = 970
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=970.05n

* CHECK dout0_24 Vdout0_24ck96 = 1.8 time = 970
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=970.05n

* CHECK dout0_25 Vdout0_25ck96 = 1.8 time = 970
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=970.05n

* CHECK dout0_26 Vdout0_26ck96 = 1.8 time = 970
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=970.05n

* CHECK dout0_27 Vdout0_27ck96 = 1.8 time = 970
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=970.05n

* CHECK dout0_28 Vdout0_28ck96 = 1.8 time = 970
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=970.05n

* CHECK dout0_29 Vdout0_29ck96 = 1.8 time = 970
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=970.05n

* CHECK dout0_30 Vdout0_30ck96 = 1.8 time = 970
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=970.05n

* CHECK dout0_31 Vdout0_31ck96 = 0 time = 970
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=970.05n

* CHECK dout0_32 Vdout0_32ck96 = 0 time = 970
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=970.05n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 1040
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=1040.05n

* CHECK dout0_1 Vdout0_1ck103 = 1.8 time = 1040
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=1040.05n

* CHECK dout0_2 Vdout0_2ck103 = 0 time = 1040
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=1040.05n

* CHECK dout0_3 Vdout0_3ck103 = 1.8 time = 1040
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=1040.05n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 1040
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=1040.05n

* CHECK dout0_5 Vdout0_5ck103 = 1.8 time = 1040
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=1040.05n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 1040
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=1040.05n

* CHECK dout0_7 Vdout0_7ck103 = 1.8 time = 1040
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=1040.05n

* CHECK dout0_8 Vdout0_8ck103 = 1.8 time = 1040
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=1040.05n

* CHECK dout0_9 Vdout0_9ck103 = 0 time = 1040
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=1040.05n

* CHECK dout0_10 Vdout0_10ck103 = 1.8 time = 1040
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=1040.05n

* CHECK dout0_11 Vdout0_11ck103 = 0 time = 1040
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=1040.05n

* CHECK dout0_12 Vdout0_12ck103 = 1.8 time = 1040
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=1040.05n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 1040
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=1040.05n

* CHECK dout0_14 Vdout0_14ck103 = 1.8 time = 1040
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=1040.05n

* CHECK dout0_15 Vdout0_15ck103 = 0 time = 1040
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=1040.05n

* CHECK dout0_16 Vdout0_16ck103 = 0 time = 1040
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=1040.05n

* CHECK dout0_17 Vdout0_17ck103 = 1.8 time = 1040
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=1040.05n

* CHECK dout0_18 Vdout0_18ck103 = 1.8 time = 1040
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=1040.05n

* CHECK dout0_19 Vdout0_19ck103 = 0 time = 1040
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=1040.05n

* CHECK dout0_20 Vdout0_20ck103 = 1.8 time = 1040
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=1040.05n

* CHECK dout0_21 Vdout0_21ck103 = 1.8 time = 1040
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=1040.05n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 1040
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=1040.05n

* CHECK dout0_23 Vdout0_23ck103 = 1.8 time = 1040
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=1040.05n

* CHECK dout0_24 Vdout0_24ck103 = 1.8 time = 1040
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=1040.05n

* CHECK dout0_25 Vdout0_25ck103 = 1.8 time = 1040
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=1040.05n

* CHECK dout0_26 Vdout0_26ck103 = 1.8 time = 1040
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=1040.05n

* CHECK dout0_27 Vdout0_27ck103 = 0 time = 1040
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=1040.05n

* CHECK dout0_28 Vdout0_28ck103 = 1.8 time = 1040
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=1040.05n

* CHECK dout0_29 Vdout0_29ck103 = 0 time = 1040
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=1040.05n

* CHECK dout0_30 Vdout0_30ck103 = 0 time = 1040
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=1040.05n

* CHECK dout0_31 Vdout0_31ck103 = 1.8 time = 1040
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=1040.05n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 1040
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=1040.05n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 1070
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=1070.05n

* CHECK dout0_1 Vdout0_1ck106 = 1.8 time = 1070
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=1070.05n

* CHECK dout0_2 Vdout0_2ck106 = 0 time = 1070
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=1070.05n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 1070
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=1070.05n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 1070
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=1070.05n

* CHECK dout0_5 Vdout0_5ck106 = 1.8 time = 1070
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=1070.05n

* CHECK dout0_6 Vdout0_6ck106 = 1.8 time = 1070
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=1070.05n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 1070
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=1070.05n

* CHECK dout0_8 Vdout0_8ck106 = 1.8 time = 1070
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=1070.05n

* CHECK dout0_9 Vdout0_9ck106 = 0 time = 1070
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=1070.05n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 1070
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=1070.05n

* CHECK dout0_11 Vdout0_11ck106 = 1.8 time = 1070
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=1070.05n

* CHECK dout0_12 Vdout0_12ck106 = 0 time = 1070
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=1070.05n

* CHECK dout0_13 Vdout0_13ck106 = 1.8 time = 1070
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=1070.05n

* CHECK dout0_14 Vdout0_14ck106 = 0 time = 1070
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=1070.05n

* CHECK dout0_15 Vdout0_15ck106 = 1.8 time = 1070
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=1070.05n

* CHECK dout0_16 Vdout0_16ck106 = 1.8 time = 1070
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=1070.05n

* CHECK dout0_17 Vdout0_17ck106 = 1.8 time = 1070
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=1070.05n

* CHECK dout0_18 Vdout0_18ck106 = 0 time = 1070
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=1070.05n

* CHECK dout0_19 Vdout0_19ck106 = 0 time = 1070
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=1070.05n

* CHECK dout0_20 Vdout0_20ck106 = 0 time = 1070
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=1070.05n

* CHECK dout0_21 Vdout0_21ck106 = 0 time = 1070
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=1070.05n

* CHECK dout0_22 Vdout0_22ck106 = 0 time = 1070
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=1070.05n

* CHECK dout0_23 Vdout0_23ck106 = 1.8 time = 1070
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=1070.05n

* CHECK dout0_24 Vdout0_24ck106 = 0 time = 1070
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=1070.05n

* CHECK dout0_25 Vdout0_25ck106 = 0 time = 1070
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=1070.05n

* CHECK dout0_26 Vdout0_26ck106 = 0 time = 1070
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=1070.05n

* CHECK dout0_27 Vdout0_27ck106 = 1.8 time = 1070
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=1070.05n

* CHECK dout0_28 Vdout0_28ck106 = 0 time = 1070
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=1070.05n

* CHECK dout0_29 Vdout0_29ck106 = 1.8 time = 1070
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=1070.05n

* CHECK dout0_30 Vdout0_30ck106 = 0 time = 1070
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=1070.05n

* CHECK dout0_31 Vdout0_31ck106 = 1.8 time = 1070
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=1070.05n

* CHECK dout0_32 Vdout0_32ck106 = 0 time = 1070
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=1070.05n

* CHECK dout0_0 Vdout0_0ck107 = 0 time = 1080
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=1080.05n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 1080
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=1080.05n

* CHECK dout0_2 Vdout0_2ck107 = 1.8 time = 1080
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=1080.05n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 1080
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=1080.05n

* CHECK dout0_4 Vdout0_4ck107 = 0 time = 1080
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=1080.05n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 1080
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=1080.05n

* CHECK dout0_6 Vdout0_6ck107 = 0 time = 1080
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=1080.05n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 1080
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=1080.05n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 1080
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=1080.05n

* CHECK dout0_9 Vdout0_9ck107 = 1.8 time = 1080
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=1080.05n

* CHECK dout0_10 Vdout0_10ck107 = 0 time = 1080
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=1080.05n

* CHECK dout0_11 Vdout0_11ck107 = 0 time = 1080
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=1080.05n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 1080
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=1080.05n

* CHECK dout0_13 Vdout0_13ck107 = 0 time = 1080
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=1080.05n

* CHECK dout0_14 Vdout0_14ck107 = 0 time = 1080
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=1080.05n

* CHECK dout0_15 Vdout0_15ck107 = 1.8 time = 1080
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=1080.05n

* CHECK dout0_16 Vdout0_16ck107 = 1.8 time = 1080
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=1080.05n

* CHECK dout0_17 Vdout0_17ck107 = 1.8 time = 1080
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=1080.05n

* CHECK dout0_18 Vdout0_18ck107 = 0 time = 1080
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=1080.05n

* CHECK dout0_19 Vdout0_19ck107 = 1.8 time = 1080
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=1080.05n

* CHECK dout0_20 Vdout0_20ck107 = 0 time = 1080
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=1080.05n

* CHECK dout0_21 Vdout0_21ck107 = 1.8 time = 1080
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=1080.05n

* CHECK dout0_22 Vdout0_22ck107 = 0 time = 1080
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=1080.05n

* CHECK dout0_23 Vdout0_23ck107 = 0 time = 1080
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=1080.05n

* CHECK dout0_24 Vdout0_24ck107 = 1.8 time = 1080
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=1080.05n

* CHECK dout0_25 Vdout0_25ck107 = 0 time = 1080
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=1080.05n

* CHECK dout0_26 Vdout0_26ck107 = 0 time = 1080
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=1080.05n

* CHECK dout0_27 Vdout0_27ck107 = 1.8 time = 1080
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=1080.05n

* CHECK dout0_28 Vdout0_28ck107 = 0 time = 1080
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=1080.05n

* CHECK dout0_29 Vdout0_29ck107 = 0 time = 1080
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=1080.05n

* CHECK dout0_30 Vdout0_30ck107 = 0 time = 1080
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=1080.05n

* CHECK dout0_31 Vdout0_31ck107 = 1.8 time = 1080
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=1080.05n

* CHECK dout0_32 Vdout0_32ck107 = 0 time = 1080
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=1080.05n

* CHECK dout0_0 Vdout0_0ck109 = 0 time = 1100
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=1100.05n

* CHECK dout0_1 Vdout0_1ck109 = 1.8 time = 1100
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=1100.05n

* CHECK dout0_2 Vdout0_2ck109 = 1.8 time = 1100
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=1100.05n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 1100
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=1100.05n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 1100
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=1100.05n

* CHECK dout0_5 Vdout0_5ck109 = 1.8 time = 1100
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=1100.05n

* CHECK dout0_6 Vdout0_6ck109 = 1.8 time = 1100
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=1100.05n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 1100
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=1100.05n

* CHECK dout0_8 Vdout0_8ck109 = 1.8 time = 1100
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=1100.05n

* CHECK dout0_9 Vdout0_9ck109 = 1.8 time = 1100
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=1100.05n

* CHECK dout0_10 Vdout0_10ck109 = 0 time = 1100
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=1100.05n

* CHECK dout0_11 Vdout0_11ck109 = 1.8 time = 1100
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=1100.05n

* CHECK dout0_12 Vdout0_12ck109 = 1.8 time = 1100
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=1100.05n

* CHECK dout0_13 Vdout0_13ck109 = 0 time = 1100
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=1100.05n

* CHECK dout0_14 Vdout0_14ck109 = 1.8 time = 1100
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=1100.05n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 1100
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=1100.05n

* CHECK dout0_16 Vdout0_16ck109 = 0 time = 1100
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=1100.05n

* CHECK dout0_17 Vdout0_17ck109 = 1.8 time = 1100
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=1100.05n

* CHECK dout0_18 Vdout0_18ck109 = 1.8 time = 1100
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=1100.05n

* CHECK dout0_19 Vdout0_19ck109 = 0 time = 1100
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=1100.05n

* CHECK dout0_20 Vdout0_20ck109 = 1.8 time = 1100
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=1100.05n

* CHECK dout0_21 Vdout0_21ck109 = 1.8 time = 1100
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=1100.05n

* CHECK dout0_22 Vdout0_22ck109 = 1.8 time = 1100
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=1100.05n

* CHECK dout0_23 Vdout0_23ck109 = 0 time = 1100
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=1100.05n

* CHECK dout0_24 Vdout0_24ck109 = 0 time = 1100
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=1100.05n

* CHECK dout0_25 Vdout0_25ck109 = 0 time = 1100
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=1100.05n

* CHECK dout0_26 Vdout0_26ck109 = 1.8 time = 1100
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=1100.05n

* CHECK dout0_27 Vdout0_27ck109 = 0 time = 1100
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=1100.05n

* CHECK dout0_28 Vdout0_28ck109 = 1.8 time = 1100
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=1100.05n

* CHECK dout0_29 Vdout0_29ck109 = 1.8 time = 1100
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=1100.05n

* CHECK dout0_30 Vdout0_30ck109 = 1.8 time = 1100
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=1100.05n

* CHECK dout0_31 Vdout0_31ck109 = 1.8 time = 1100
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=1100.05n

* CHECK dout0_32 Vdout0_32ck109 = 0 time = 1100
.meas tran vdout0_32ck109 FIND v(dout0_32) AT=1100.05n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 1110
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=1110.05n

* CHECK dout0_1 Vdout0_1ck110 = 1.8 time = 1110
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=1110.05n

* CHECK dout0_2 Vdout0_2ck110 = 0 time = 1110
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=1110.05n

* CHECK dout0_3 Vdout0_3ck110 = 1.8 time = 1110
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=1110.05n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 1110
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=1110.05n

* CHECK dout0_5 Vdout0_5ck110 = 1.8 time = 1110
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=1110.05n

* CHECK dout0_6 Vdout0_6ck110 = 0 time = 1110
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=1110.05n

* CHECK dout0_7 Vdout0_7ck110 = 1.8 time = 1110
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=1110.05n

* CHECK dout0_8 Vdout0_8ck110 = 1.8 time = 1110
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=1110.05n

* CHECK dout0_9 Vdout0_9ck110 = 0 time = 1110
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=1110.05n

* CHECK dout0_10 Vdout0_10ck110 = 1.8 time = 1110
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=1110.05n

* CHECK dout0_11 Vdout0_11ck110 = 0 time = 1110
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=1110.05n

* CHECK dout0_12 Vdout0_12ck110 = 1.8 time = 1110
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=1110.05n

* CHECK dout0_13 Vdout0_13ck110 = 0 time = 1110
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=1110.05n

* CHECK dout0_14 Vdout0_14ck110 = 1.8 time = 1110
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=1110.05n

* CHECK dout0_15 Vdout0_15ck110 = 0 time = 1110
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=1110.05n

* CHECK dout0_16 Vdout0_16ck110 = 0 time = 1110
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=1110.05n

* CHECK dout0_17 Vdout0_17ck110 = 1.8 time = 1110
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=1110.05n

* CHECK dout0_18 Vdout0_18ck110 = 1.8 time = 1110
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=1110.05n

* CHECK dout0_19 Vdout0_19ck110 = 0 time = 1110
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=1110.05n

* CHECK dout0_20 Vdout0_20ck110 = 1.8 time = 1110
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=1110.05n

* CHECK dout0_21 Vdout0_21ck110 = 1.8 time = 1110
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=1110.05n

* CHECK dout0_22 Vdout0_22ck110 = 0 time = 1110
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=1110.05n

* CHECK dout0_23 Vdout0_23ck110 = 1.8 time = 1110
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=1110.05n

* CHECK dout0_24 Vdout0_24ck110 = 1.8 time = 1110
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=1110.05n

* CHECK dout0_25 Vdout0_25ck110 = 1.8 time = 1110
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=1110.05n

* CHECK dout0_26 Vdout0_26ck110 = 1.8 time = 1110
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=1110.05n

* CHECK dout0_27 Vdout0_27ck110 = 0 time = 1110
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=1110.05n

* CHECK dout0_28 Vdout0_28ck110 = 1.8 time = 1110
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=1110.05n

* CHECK dout0_29 Vdout0_29ck110 = 0 time = 1110
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=1110.05n

* CHECK dout0_30 Vdout0_30ck110 = 0 time = 1110
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=1110.05n

* CHECK dout0_31 Vdout0_31ck110 = 1.8 time = 1110
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=1110.05n

* CHECK dout0_32 Vdout0_32ck110 = 0 time = 1110
.meas tran vdout0_32ck110 FIND v(dout0_32) AT=1110.05n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 1130
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=1130.05n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 1130
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=1130.05n

* CHECK dout0_2 Vdout0_2ck112 = 1.8 time = 1130
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=1130.05n

* CHECK dout0_3 Vdout0_3ck112 = 0 time = 1130
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=1130.05n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 1130
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=1130.05n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 1130
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=1130.05n

* CHECK dout0_6 Vdout0_6ck112 = 0 time = 1130
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=1130.05n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 1130
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=1130.05n

* CHECK dout0_8 Vdout0_8ck112 = 0 time = 1130
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=1130.05n

* CHECK dout0_9 Vdout0_9ck112 = 1.8 time = 1130
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=1130.05n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 1130
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=1130.05n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 1130
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=1130.05n

* CHECK dout0_12 Vdout0_12ck112 = 0 time = 1130
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=1130.05n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 1130
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=1130.05n

* CHECK dout0_14 Vdout0_14ck112 = 0 time = 1130
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=1130.05n

* CHECK dout0_15 Vdout0_15ck112 = 1.8 time = 1130
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=1130.05n

* CHECK dout0_16 Vdout0_16ck112 = 1.8 time = 1130
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=1130.05n

* CHECK dout0_17 Vdout0_17ck112 = 1.8 time = 1130
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=1130.05n

* CHECK dout0_18 Vdout0_18ck112 = 0 time = 1130
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=1130.05n

* CHECK dout0_19 Vdout0_19ck112 = 1.8 time = 1130
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=1130.05n

* CHECK dout0_20 Vdout0_20ck112 = 0 time = 1130
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=1130.05n

* CHECK dout0_21 Vdout0_21ck112 = 1.8 time = 1130
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=1130.05n

* CHECK dout0_22 Vdout0_22ck112 = 0 time = 1130
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=1130.05n

* CHECK dout0_23 Vdout0_23ck112 = 0 time = 1130
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=1130.05n

* CHECK dout0_24 Vdout0_24ck112 = 1.8 time = 1130
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=1130.05n

* CHECK dout0_25 Vdout0_25ck112 = 0 time = 1130
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=1130.05n

* CHECK dout0_26 Vdout0_26ck112 = 0 time = 1130
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=1130.05n

* CHECK dout0_27 Vdout0_27ck112 = 1.8 time = 1130
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=1130.05n

* CHECK dout0_28 Vdout0_28ck112 = 0 time = 1130
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=1130.05n

* CHECK dout0_29 Vdout0_29ck112 = 0 time = 1130
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=1130.05n

* CHECK dout0_30 Vdout0_30ck112 = 0 time = 1130
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=1130.05n

* CHECK dout0_31 Vdout0_31ck112 = 1.8 time = 1130
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=1130.05n

* CHECK dout0_32 Vdout0_32ck112 = 0 time = 1130
.meas tran vdout0_32ck112 FIND v(dout0_32) AT=1130.05n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 1140
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=1140.05n

* CHECK dout0_1 Vdout0_1ck113 = 1.8 time = 1140
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=1140.05n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 1140
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=1140.05n

* CHECK dout0_3 Vdout0_3ck113 = 0 time = 1140
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=1140.05n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 1140
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=1140.05n

* CHECK dout0_5 Vdout0_5ck113 = 1.8 time = 1140
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=1140.05n

* CHECK dout0_6 Vdout0_6ck113 = 1.8 time = 1140
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=1140.05n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 1140
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=1140.05n

* CHECK dout0_8 Vdout0_8ck113 = 1.8 time = 1140
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=1140.05n

* CHECK dout0_9 Vdout0_9ck113 = 0 time = 1140
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=1140.05n

* CHECK dout0_10 Vdout0_10ck113 = 0 time = 1140
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=1140.05n

* CHECK dout0_11 Vdout0_11ck113 = 1.8 time = 1140
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=1140.05n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 1140
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=1140.05n

* CHECK dout0_13 Vdout0_13ck113 = 1.8 time = 1140
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=1140.05n

* CHECK dout0_14 Vdout0_14ck113 = 0 time = 1140
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=1140.05n

* CHECK dout0_15 Vdout0_15ck113 = 1.8 time = 1140
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=1140.05n

* CHECK dout0_16 Vdout0_16ck113 = 1.8 time = 1140
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=1140.05n

* CHECK dout0_17 Vdout0_17ck113 = 1.8 time = 1140
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=1140.05n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 1140
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=1140.05n

* CHECK dout0_19 Vdout0_19ck113 = 0 time = 1140
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=1140.05n

* CHECK dout0_20 Vdout0_20ck113 = 0 time = 1140
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=1140.05n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 1140
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=1140.05n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 1140
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=1140.05n

* CHECK dout0_23 Vdout0_23ck113 = 1.8 time = 1140
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=1140.05n

* CHECK dout0_24 Vdout0_24ck113 = 0 time = 1140
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=1140.05n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 1140
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=1140.05n

* CHECK dout0_26 Vdout0_26ck113 = 0 time = 1140
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=1140.05n

* CHECK dout0_27 Vdout0_27ck113 = 1.8 time = 1140
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=1140.05n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 1140
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=1140.05n

* CHECK dout0_29 Vdout0_29ck113 = 1.8 time = 1140
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=1140.05n

* CHECK dout0_30 Vdout0_30ck113 = 0 time = 1140
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=1140.05n

* CHECK dout0_31 Vdout0_31ck113 = 1.8 time = 1140
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=1140.05n

* CHECK dout0_32 Vdout0_32ck113 = 0 time = 1140
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=1140.05n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 1170
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=1170.05n

* CHECK dout0_1 Vdout0_1ck116 = 1.8 time = 1170
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=1170.05n

* CHECK dout0_2 Vdout0_2ck116 = 0 time = 1170
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=1170.05n

* CHECK dout0_3 Vdout0_3ck116 = 0 time = 1170
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=1170.05n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 1170
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=1170.05n

* CHECK dout0_5 Vdout0_5ck116 = 1.8 time = 1170
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=1170.05n

* CHECK dout0_6 Vdout0_6ck116 = 1.8 time = 1170
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=1170.05n

* CHECK dout0_7 Vdout0_7ck116 = 0 time = 1170
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=1170.05n

* CHECK dout0_8 Vdout0_8ck116 = 1.8 time = 1170
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=1170.05n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 1170
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=1170.05n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 1170
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=1170.05n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 1170
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=1170.05n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 1170
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=1170.05n

* CHECK dout0_13 Vdout0_13ck116 = 1.8 time = 1170
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=1170.05n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 1170
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=1170.05n

* CHECK dout0_15 Vdout0_15ck116 = 1.8 time = 1170
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=1170.05n

* CHECK dout0_16 Vdout0_16ck116 = 1.8 time = 1170
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=1170.05n

* CHECK dout0_17 Vdout0_17ck116 = 1.8 time = 1170
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=1170.05n

* CHECK dout0_18 Vdout0_18ck116 = 0 time = 1170
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=1170.05n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 1170
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=1170.05n

* CHECK dout0_20 Vdout0_20ck116 = 0 time = 1170
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=1170.05n

* CHECK dout0_21 Vdout0_21ck116 = 0 time = 1170
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=1170.05n

* CHECK dout0_22 Vdout0_22ck116 = 0 time = 1170
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=1170.05n

* CHECK dout0_23 Vdout0_23ck116 = 1.8 time = 1170
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=1170.05n

* CHECK dout0_24 Vdout0_24ck116 = 0 time = 1170
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=1170.05n

* CHECK dout0_25 Vdout0_25ck116 = 0 time = 1170
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=1170.05n

* CHECK dout0_26 Vdout0_26ck116 = 0 time = 1170
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=1170.05n

* CHECK dout0_27 Vdout0_27ck116 = 1.8 time = 1170
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=1170.05n

* CHECK dout0_28 Vdout0_28ck116 = 0 time = 1170
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=1170.05n

* CHECK dout0_29 Vdout0_29ck116 = 1.8 time = 1170
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=1170.05n

* CHECK dout0_30 Vdout0_30ck116 = 0 time = 1170
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=1170.05n

* CHECK dout0_31 Vdout0_31ck116 = 1.8 time = 1170
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=1170.05n

* CHECK dout0_32 Vdout0_32ck116 = 0 time = 1170
.meas tran vdout0_32ck116 FIND v(dout0_32) AT=1170.05n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 1180
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=1180.05n

* CHECK dout0_1 Vdout0_1ck117 = 1.8 time = 1180
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=1180.05n

* CHECK dout0_2 Vdout0_2ck117 = 1.8 time = 1180
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=1180.05n

* CHECK dout0_3 Vdout0_3ck117 = 0 time = 1180
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=1180.05n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 1180
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=1180.05n

* CHECK dout0_5 Vdout0_5ck117 = 1.8 time = 1180
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=1180.05n

* CHECK dout0_6 Vdout0_6ck117 = 1.8 time = 1180
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=1180.05n

* CHECK dout0_7 Vdout0_7ck117 = 0 time = 1180
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=1180.05n

* CHECK dout0_8 Vdout0_8ck117 = 1.8 time = 1180
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=1180.05n

* CHECK dout0_9 Vdout0_9ck117 = 1.8 time = 1180
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=1180.05n

* CHECK dout0_10 Vdout0_10ck117 = 0 time = 1180
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=1180.05n

* CHECK dout0_11 Vdout0_11ck117 = 1.8 time = 1180
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=1180.05n

* CHECK dout0_12 Vdout0_12ck117 = 1.8 time = 1180
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=1180.05n

* CHECK dout0_13 Vdout0_13ck117 = 0 time = 1180
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=1180.05n

* CHECK dout0_14 Vdout0_14ck117 = 1.8 time = 1180
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=1180.05n

* CHECK dout0_15 Vdout0_15ck117 = 0 time = 1180
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=1180.05n

* CHECK dout0_16 Vdout0_16ck117 = 0 time = 1180
.meas tran vdout0_16ck117 FIND v(dout0_16) AT=1180.05n

* CHECK dout0_17 Vdout0_17ck117 = 1.8 time = 1180
.meas tran vdout0_17ck117 FIND v(dout0_17) AT=1180.05n

* CHECK dout0_18 Vdout0_18ck117 = 1.8 time = 1180
.meas tran vdout0_18ck117 FIND v(dout0_18) AT=1180.05n

* CHECK dout0_19 Vdout0_19ck117 = 0 time = 1180
.meas tran vdout0_19ck117 FIND v(dout0_19) AT=1180.05n

* CHECK dout0_20 Vdout0_20ck117 = 1.8 time = 1180
.meas tran vdout0_20ck117 FIND v(dout0_20) AT=1180.05n

* CHECK dout0_21 Vdout0_21ck117 = 1.8 time = 1180
.meas tran vdout0_21ck117 FIND v(dout0_21) AT=1180.05n

* CHECK dout0_22 Vdout0_22ck117 = 1.8 time = 1180
.meas tran vdout0_22ck117 FIND v(dout0_22) AT=1180.05n

* CHECK dout0_23 Vdout0_23ck117 = 0 time = 1180
.meas tran vdout0_23ck117 FIND v(dout0_23) AT=1180.05n

* CHECK dout0_24 Vdout0_24ck117 = 0 time = 1180
.meas tran vdout0_24ck117 FIND v(dout0_24) AT=1180.05n

* CHECK dout0_25 Vdout0_25ck117 = 0 time = 1180
.meas tran vdout0_25ck117 FIND v(dout0_25) AT=1180.05n

* CHECK dout0_26 Vdout0_26ck117 = 1.8 time = 1180
.meas tran vdout0_26ck117 FIND v(dout0_26) AT=1180.05n

* CHECK dout0_27 Vdout0_27ck117 = 0 time = 1180
.meas tran vdout0_27ck117 FIND v(dout0_27) AT=1180.05n

* CHECK dout0_28 Vdout0_28ck117 = 1.8 time = 1180
.meas tran vdout0_28ck117 FIND v(dout0_28) AT=1180.05n

* CHECK dout0_29 Vdout0_29ck117 = 1.8 time = 1180
.meas tran vdout0_29ck117 FIND v(dout0_29) AT=1180.05n

* CHECK dout0_30 Vdout0_30ck117 = 1.8 time = 1180
.meas tran vdout0_30ck117 FIND v(dout0_30) AT=1180.05n

* CHECK dout0_31 Vdout0_31ck117 = 1.8 time = 1180
.meas tran vdout0_31ck117 FIND v(dout0_31) AT=1180.05n

* CHECK dout0_32 Vdout0_32ck117 = 0 time = 1180
.meas tran vdout0_32ck117 FIND v(dout0_32) AT=1180.05n

* CHECK dout0_0 Vdout0_0ck119 = 1.8 time = 1200
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=1200.05n

* CHECK dout0_1 Vdout0_1ck119 = 1.8 time = 1200
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=1200.05n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 1200
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=1200.05n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 1200
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=1200.05n

* CHECK dout0_4 Vdout0_4ck119 = 1.8 time = 1200
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=1200.05n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 1200
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=1200.05n

* CHECK dout0_6 Vdout0_6ck119 = 1.8 time = 1200
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=1200.05n

* CHECK dout0_7 Vdout0_7ck119 = 1.8 time = 1200
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=1200.05n

* CHECK dout0_8 Vdout0_8ck119 = 1.8 time = 1200
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=1200.05n

* CHECK dout0_9 Vdout0_9ck119 = 0 time = 1200
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=1200.05n

* CHECK dout0_10 Vdout0_10ck119 = 1.8 time = 1200
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=1200.05n

* CHECK dout0_11 Vdout0_11ck119 = 1.8 time = 1200
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=1200.05n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 1200
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=1200.05n

* CHECK dout0_13 Vdout0_13ck119 = 1.8 time = 1200
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=1200.05n

* CHECK dout0_14 Vdout0_14ck119 = 0 time = 1200
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=1200.05n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 1200
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=1200.05n

* CHECK dout0_16 Vdout0_16ck119 = 1.8 time = 1200
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=1200.05n

* CHECK dout0_17 Vdout0_17ck119 = 1.8 time = 1200
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=1200.05n

* CHECK dout0_18 Vdout0_18ck119 = 0 time = 1200
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=1200.05n

* CHECK dout0_19 Vdout0_19ck119 = 1.8 time = 1200
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=1200.05n

* CHECK dout0_20 Vdout0_20ck119 = 1.8 time = 1200
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=1200.05n

* CHECK dout0_21 Vdout0_21ck119 = 1.8 time = 1200
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=1200.05n

* CHECK dout0_22 Vdout0_22ck119 = 1.8 time = 1200
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=1200.05n

* CHECK dout0_23 Vdout0_23ck119 = 1.8 time = 1200
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=1200.05n

* CHECK dout0_24 Vdout0_24ck119 = 1.8 time = 1200
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=1200.05n

* CHECK dout0_25 Vdout0_25ck119 = 0 time = 1200
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=1200.05n

* CHECK dout0_26 Vdout0_26ck119 = 0 time = 1200
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=1200.05n

* CHECK dout0_27 Vdout0_27ck119 = 0 time = 1200
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=1200.05n

* CHECK dout0_28 Vdout0_28ck119 = 1.8 time = 1200
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=1200.05n

* CHECK dout0_29 Vdout0_29ck119 = 1.8 time = 1200
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=1200.05n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 1200
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=1200.05n

* CHECK dout0_31 Vdout0_31ck119 = 1.8 time = 1200
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=1200.05n

* CHECK dout0_32 Vdout0_32ck119 = 0 time = 1200
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=1200.05n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 1210
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=1210.05n

* CHECK dout0_1 Vdout0_1ck120 = 1.8 time = 1210
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=1210.05n

* CHECK dout0_2 Vdout0_2ck120 = 1.8 time = 1210
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=1210.05n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 1210
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=1210.05n

* CHECK dout0_4 Vdout0_4ck120 = 0 time = 1210
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=1210.05n

* CHECK dout0_5 Vdout0_5ck120 = 1.8 time = 1210
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=1210.05n

* CHECK dout0_6 Vdout0_6ck120 = 1.8 time = 1210
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=1210.05n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 1210
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=1210.05n

* CHECK dout0_8 Vdout0_8ck120 = 1.8 time = 1210
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=1210.05n

* CHECK dout0_9 Vdout0_9ck120 = 1.8 time = 1210
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=1210.05n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 1210
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=1210.05n

* CHECK dout0_11 Vdout0_11ck120 = 1.8 time = 1210
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=1210.05n

* CHECK dout0_12 Vdout0_12ck120 = 1.8 time = 1210
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=1210.05n

* CHECK dout0_13 Vdout0_13ck120 = 0 time = 1210
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=1210.05n

* CHECK dout0_14 Vdout0_14ck120 = 1.8 time = 1210
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=1210.05n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 1210
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=1210.05n

* CHECK dout0_16 Vdout0_16ck120 = 1.8 time = 1210
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=1210.05n

* CHECK dout0_17 Vdout0_17ck120 = 1.8 time = 1210
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=1210.05n

* CHECK dout0_18 Vdout0_18ck120 = 1.8 time = 1210
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=1210.05n

* CHECK dout0_19 Vdout0_19ck120 = 1.8 time = 1210
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=1210.05n

* CHECK dout0_20 Vdout0_20ck120 = 1.8 time = 1210
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=1210.05n

* CHECK dout0_21 Vdout0_21ck120 = 0 time = 1210
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=1210.05n

* CHECK dout0_22 Vdout0_22ck120 = 0 time = 1210
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=1210.05n

* CHECK dout0_23 Vdout0_23ck120 = 1.8 time = 1210
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=1210.05n

* CHECK dout0_24 Vdout0_24ck120 = 0 time = 1210
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=1210.05n

* CHECK dout0_25 Vdout0_25ck120 = 1.8 time = 1210
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=1210.05n

* CHECK dout0_26 Vdout0_26ck120 = 1.8 time = 1210
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=1210.05n

* CHECK dout0_27 Vdout0_27ck120 = 0 time = 1210
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=1210.05n

* CHECK dout0_28 Vdout0_28ck120 = 1.8 time = 1210
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=1210.05n

* CHECK dout0_29 Vdout0_29ck120 = 1.8 time = 1210
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=1210.05n

* CHECK dout0_30 Vdout0_30ck120 = 1.8 time = 1210
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=1210.05n

* CHECK dout0_31 Vdout0_31ck120 = 1.8 time = 1210
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=1210.05n

* CHECK dout0_32 Vdout0_32ck120 = 0 time = 1210
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=1210.05n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 1220
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=1220.05n

* CHECK dout0_1 Vdout0_1ck121 = 0 time = 1220
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=1220.05n

* CHECK dout0_2 Vdout0_2ck121 = 0 time = 1220
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=1220.05n

* CHECK dout0_3 Vdout0_3ck121 = 1.8 time = 1220
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=1220.05n

* CHECK dout0_4 Vdout0_4ck121 = 1.8 time = 1220
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=1220.05n

* CHECK dout0_5 Vdout0_5ck121 = 1.8 time = 1220
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=1220.05n

* CHECK dout0_6 Vdout0_6ck121 = 1.8 time = 1220
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=1220.05n

* CHECK dout0_7 Vdout0_7ck121 = 1.8 time = 1220
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=1220.05n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 1220
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=1220.05n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 1220
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=1220.05n

* CHECK dout0_10 Vdout0_10ck121 = 1.8 time = 1220
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=1220.05n

* CHECK dout0_11 Vdout0_11ck121 = 1.8 time = 1220
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=1220.05n

* CHECK dout0_12 Vdout0_12ck121 = 1.8 time = 1220
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=1220.05n

* CHECK dout0_13 Vdout0_13ck121 = 0 time = 1220
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=1220.05n

* CHECK dout0_14 Vdout0_14ck121 = 1.8 time = 1220
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=1220.05n

* CHECK dout0_15 Vdout0_15ck121 = 0 time = 1220
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=1220.05n

* CHECK dout0_16 Vdout0_16ck121 = 1.8 time = 1220
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=1220.05n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 1220
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=1220.05n

* CHECK dout0_18 Vdout0_18ck121 = 1.8 time = 1220
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=1220.05n

* CHECK dout0_19 Vdout0_19ck121 = 0 time = 1220
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=1220.05n

* CHECK dout0_20 Vdout0_20ck121 = 0 time = 1220
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=1220.05n

* CHECK dout0_21 Vdout0_21ck121 = 0 time = 1220
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=1220.05n

* CHECK dout0_22 Vdout0_22ck121 = 0 time = 1220
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=1220.05n

* CHECK dout0_23 Vdout0_23ck121 = 1.8 time = 1220
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=1220.05n

* CHECK dout0_24 Vdout0_24ck121 = 0 time = 1220
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=1220.05n

* CHECK dout0_25 Vdout0_25ck121 = 0 time = 1220
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=1220.05n

* CHECK dout0_26 Vdout0_26ck121 = 0 time = 1220
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=1220.05n

* CHECK dout0_27 Vdout0_27ck121 = 1.8 time = 1220
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=1220.05n

* CHECK dout0_28 Vdout0_28ck121 = 0 time = 1220
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=1220.05n

* CHECK dout0_29 Vdout0_29ck121 = 1.8 time = 1220
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=1220.05n

* CHECK dout0_30 Vdout0_30ck121 = 0 time = 1220
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=1220.05n

* CHECK dout0_31 Vdout0_31ck121 = 0 time = 1220
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=1220.05n

* CHECK dout0_32 Vdout0_32ck121 = 0 time = 1220
.meas tran vdout0_32ck121 FIND v(dout0_32) AT=1220.05n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 1240
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=1240.05n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 1240
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=1240.05n

* CHECK dout0_2 Vdout0_2ck123 = 1.8 time = 1240
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=1240.05n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 1240
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=1240.05n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 1240
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=1240.05n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 1240
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=1240.05n

* CHECK dout0_6 Vdout0_6ck123 = 0 time = 1240
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=1240.05n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 1240
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=1240.05n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 1240
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=1240.05n

* CHECK dout0_9 Vdout0_9ck123 = 1.8 time = 1240
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=1240.05n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 1240
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=1240.05n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 1240
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=1240.05n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 1240
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=1240.05n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 1240
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=1240.05n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 1240
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=1240.05n

* CHECK dout0_15 Vdout0_15ck123 = 1.8 time = 1240
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=1240.05n

* CHECK dout0_16 Vdout0_16ck123 = 1.8 time = 1240
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=1240.05n

* CHECK dout0_17 Vdout0_17ck123 = 1.8 time = 1240
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=1240.05n

* CHECK dout0_18 Vdout0_18ck123 = 0 time = 1240
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=1240.05n

* CHECK dout0_19 Vdout0_19ck123 = 1.8 time = 1240
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=1240.05n

* CHECK dout0_20 Vdout0_20ck123 = 0 time = 1240
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=1240.05n

* CHECK dout0_21 Vdout0_21ck123 = 1.8 time = 1240
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=1240.05n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 1240
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=1240.05n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 1240
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=1240.05n

* CHECK dout0_24 Vdout0_24ck123 = 1.8 time = 1240
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=1240.05n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 1240
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=1240.05n

* CHECK dout0_26 Vdout0_26ck123 = 0 time = 1240
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=1240.05n

* CHECK dout0_27 Vdout0_27ck123 = 1.8 time = 1240
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=1240.05n

* CHECK dout0_28 Vdout0_28ck123 = 0 time = 1240
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=1240.05n

* CHECK dout0_29 Vdout0_29ck123 = 0 time = 1240
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=1240.05n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 1240
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=1240.05n

* CHECK dout0_31 Vdout0_31ck123 = 1.8 time = 1240
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=1240.05n

* CHECK dout0_32 Vdout0_32ck123 = 0 time = 1240
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=1240.05n

* CHECK dout0_0 Vdout0_0ck125 = 0 time = 1260
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=1260.05n

* CHECK dout0_1 Vdout0_1ck125 = 1.8 time = 1260
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=1260.05n

* CHECK dout0_2 Vdout0_2ck125 = 0 time = 1260
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=1260.05n

* CHECK dout0_3 Vdout0_3ck125 = 0 time = 1260
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=1260.05n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 1260
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=1260.05n

* CHECK dout0_5 Vdout0_5ck125 = 1.8 time = 1260
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=1260.05n

* CHECK dout0_6 Vdout0_6ck125 = 1.8 time = 1260
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=1260.05n

* CHECK dout0_7 Vdout0_7ck125 = 0 time = 1260
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=1260.05n

* CHECK dout0_8 Vdout0_8ck125 = 1.8 time = 1260
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=1260.05n

* CHECK dout0_9 Vdout0_9ck125 = 0 time = 1260
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=1260.05n

* CHECK dout0_10 Vdout0_10ck125 = 0 time = 1260
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=1260.05n

* CHECK dout0_11 Vdout0_11ck125 = 1.8 time = 1260
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=1260.05n

* CHECK dout0_12 Vdout0_12ck125 = 0 time = 1260
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=1260.05n

* CHECK dout0_13 Vdout0_13ck125 = 1.8 time = 1260
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=1260.05n

* CHECK dout0_14 Vdout0_14ck125 = 0 time = 1260
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=1260.05n

* CHECK dout0_15 Vdout0_15ck125 = 1.8 time = 1260
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=1260.05n

* CHECK dout0_16 Vdout0_16ck125 = 1.8 time = 1260
.meas tran vdout0_16ck125 FIND v(dout0_16) AT=1260.05n

* CHECK dout0_17 Vdout0_17ck125 = 1.8 time = 1260
.meas tran vdout0_17ck125 FIND v(dout0_17) AT=1260.05n

* CHECK dout0_18 Vdout0_18ck125 = 0 time = 1260
.meas tran vdout0_18ck125 FIND v(dout0_18) AT=1260.05n

* CHECK dout0_19 Vdout0_19ck125 = 0 time = 1260
.meas tran vdout0_19ck125 FIND v(dout0_19) AT=1260.05n

* CHECK dout0_20 Vdout0_20ck125 = 0 time = 1260
.meas tran vdout0_20ck125 FIND v(dout0_20) AT=1260.05n

* CHECK dout0_21 Vdout0_21ck125 = 0 time = 1260
.meas tran vdout0_21ck125 FIND v(dout0_21) AT=1260.05n

* CHECK dout0_22 Vdout0_22ck125 = 0 time = 1260
.meas tran vdout0_22ck125 FIND v(dout0_22) AT=1260.05n

* CHECK dout0_23 Vdout0_23ck125 = 1.8 time = 1260
.meas tran vdout0_23ck125 FIND v(dout0_23) AT=1260.05n

* CHECK dout0_24 Vdout0_24ck125 = 0 time = 1260
.meas tran vdout0_24ck125 FIND v(dout0_24) AT=1260.05n

* CHECK dout0_25 Vdout0_25ck125 = 0 time = 1260
.meas tran vdout0_25ck125 FIND v(dout0_25) AT=1260.05n

* CHECK dout0_26 Vdout0_26ck125 = 0 time = 1260
.meas tran vdout0_26ck125 FIND v(dout0_26) AT=1260.05n

* CHECK dout0_27 Vdout0_27ck125 = 1.8 time = 1260
.meas tran vdout0_27ck125 FIND v(dout0_27) AT=1260.05n

* CHECK dout0_28 Vdout0_28ck125 = 0 time = 1260
.meas tran vdout0_28ck125 FIND v(dout0_28) AT=1260.05n

* CHECK dout0_29 Vdout0_29ck125 = 1.8 time = 1260
.meas tran vdout0_29ck125 FIND v(dout0_29) AT=1260.05n

* CHECK dout0_30 Vdout0_30ck125 = 0 time = 1260
.meas tran vdout0_30ck125 FIND v(dout0_30) AT=1260.05n

* CHECK dout0_31 Vdout0_31ck125 = 1.8 time = 1260
.meas tran vdout0_31ck125 FIND v(dout0_31) AT=1260.05n

* CHECK dout0_32 Vdout0_32ck125 = 0 time = 1260
.meas tran vdout0_32ck125 FIND v(dout0_32) AT=1260.05n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 1270
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=1270.05n

* CHECK dout0_1 Vdout0_1ck126 = 0 time = 1270
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=1270.05n

* CHECK dout0_2 Vdout0_2ck126 = 1.8 time = 1270
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=1270.05n

* CHECK dout0_3 Vdout0_3ck126 = 0 time = 1270
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=1270.05n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 1270
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=1270.05n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 1270
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=1270.05n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 1270
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=1270.05n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 1270
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=1270.05n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 1270
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=1270.05n

* CHECK dout0_9 Vdout0_9ck126 = 1.8 time = 1270
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=1270.05n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 1270
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=1270.05n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 1270
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=1270.05n

* CHECK dout0_12 Vdout0_12ck126 = 0 time = 1270
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=1270.05n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 1270
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=1270.05n

* CHECK dout0_14 Vdout0_14ck126 = 0 time = 1270
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=1270.05n

* CHECK dout0_15 Vdout0_15ck126 = 1.8 time = 1270
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=1270.05n

* CHECK dout0_16 Vdout0_16ck126 = 1.8 time = 1270
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=1270.05n

* CHECK dout0_17 Vdout0_17ck126 = 1.8 time = 1270
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=1270.05n

* CHECK dout0_18 Vdout0_18ck126 = 0 time = 1270
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=1270.05n

* CHECK dout0_19 Vdout0_19ck126 = 1.8 time = 1270
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=1270.05n

* CHECK dout0_20 Vdout0_20ck126 = 0 time = 1270
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=1270.05n

* CHECK dout0_21 Vdout0_21ck126 = 1.8 time = 1270
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=1270.05n

* CHECK dout0_22 Vdout0_22ck126 = 0 time = 1270
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=1270.05n

* CHECK dout0_23 Vdout0_23ck126 = 0 time = 1270
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=1270.05n

* CHECK dout0_24 Vdout0_24ck126 = 1.8 time = 1270
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=1270.05n

* CHECK dout0_25 Vdout0_25ck126 = 0 time = 1270
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=1270.05n

* CHECK dout0_26 Vdout0_26ck126 = 0 time = 1270
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=1270.05n

* CHECK dout0_27 Vdout0_27ck126 = 1.8 time = 1270
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=1270.05n

* CHECK dout0_28 Vdout0_28ck126 = 0 time = 1270
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=1270.05n

* CHECK dout0_29 Vdout0_29ck126 = 0 time = 1270
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=1270.05n

* CHECK dout0_30 Vdout0_30ck126 = 0 time = 1270
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=1270.05n

* CHECK dout0_31 Vdout0_31ck126 = 1.8 time = 1270
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=1270.05n

* CHECK dout0_32 Vdout0_32ck126 = 0 time = 1270
.meas tran vdout0_32ck126 FIND v(dout0_32) AT=1270.05n

* CHECK dout0_0 Vdout0_0ck131 = 1.8 time = 1320
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=1320.05n

* CHECK dout0_1 Vdout0_1ck131 = 1.8 time = 1320
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=1320.05n

* CHECK dout0_2 Vdout0_2ck131 = 0 time = 1320
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=1320.05n

* CHECK dout0_3 Vdout0_3ck131 = 1.8 time = 1320
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=1320.05n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 1320
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=1320.05n

* CHECK dout0_5 Vdout0_5ck131 = 1.8 time = 1320
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=1320.05n

* CHECK dout0_6 Vdout0_6ck131 = 1.8 time = 1320
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=1320.05n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 1320
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=1320.05n

* CHECK dout0_8 Vdout0_8ck131 = 0 time = 1320
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=1320.05n

* CHECK dout0_9 Vdout0_9ck131 = 1.8 time = 1320
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=1320.05n

* CHECK dout0_10 Vdout0_10ck131 = 1.8 time = 1320
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=1320.05n

* CHECK dout0_11 Vdout0_11ck131 = 0 time = 1320
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=1320.05n

* CHECK dout0_12 Vdout0_12ck131 = 1.8 time = 1320
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=1320.05n

* CHECK dout0_13 Vdout0_13ck131 = 1.8 time = 1320
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=1320.05n

* CHECK dout0_14 Vdout0_14ck131 = 0 time = 1320
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=1320.05n

* CHECK dout0_15 Vdout0_15ck131 = 1.8 time = 1320
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=1320.05n

* CHECK dout0_16 Vdout0_16ck131 = 1.8 time = 1320
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=1320.05n

* CHECK dout0_17 Vdout0_17ck131 = 1.8 time = 1320
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=1320.05n

* CHECK dout0_18 Vdout0_18ck131 = 1.8 time = 1320
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=1320.05n

* CHECK dout0_19 Vdout0_19ck131 = 0 time = 1320
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=1320.05n

* CHECK dout0_20 Vdout0_20ck131 = 0 time = 1320
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=1320.05n

* CHECK dout0_21 Vdout0_21ck131 = 1.8 time = 1320
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=1320.05n

* CHECK dout0_22 Vdout0_22ck131 = 1.8 time = 1320
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=1320.05n

* CHECK dout0_23 Vdout0_23ck131 = 0 time = 1320
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=1320.05n

* CHECK dout0_24 Vdout0_24ck131 = 0 time = 1320
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=1320.05n

* CHECK dout0_25 Vdout0_25ck131 = 0 time = 1320
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=1320.05n

* CHECK dout0_26 Vdout0_26ck131 = 1.8 time = 1320
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=1320.05n

* CHECK dout0_27 Vdout0_27ck131 = 1.8 time = 1320
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=1320.05n

* CHECK dout0_28 Vdout0_28ck131 = 0 time = 1320
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=1320.05n

* CHECK dout0_29 Vdout0_29ck131 = 0 time = 1320
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=1320.05n

* CHECK dout0_30 Vdout0_30ck131 = 0 time = 1320
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=1320.05n

* CHECK dout0_31 Vdout0_31ck131 = 0 time = 1320
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=1320.05n

* CHECK dout0_32 Vdout0_32ck131 = 0 time = 1320
.meas tran vdout0_32ck131 FIND v(dout0_32) AT=1320.05n

* CHECK dout0_0 Vdout0_0ck132 = 1.8 time = 1330
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=1330.05n

* CHECK dout0_1 Vdout0_1ck132 = 0 time = 1330
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=1330.05n

* CHECK dout0_2 Vdout0_2ck132 = 1.8 time = 1330
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=1330.05n

* CHECK dout0_3 Vdout0_3ck132 = 0 time = 1330
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=1330.05n

* CHECK dout0_4 Vdout0_4ck132 = 0 time = 1330
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=1330.05n

* CHECK dout0_5 Vdout0_5ck132 = 1.8 time = 1330
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=1330.05n

* CHECK dout0_6 Vdout0_6ck132 = 0 time = 1330
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=1330.05n

* CHECK dout0_7 Vdout0_7ck132 = 1.8 time = 1330
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=1330.05n

* CHECK dout0_8 Vdout0_8ck132 = 0 time = 1330
.meas tran vdout0_8ck132 FIND v(dout0_8) AT=1330.05n

* CHECK dout0_9 Vdout0_9ck132 = 1.8 time = 1330
.meas tran vdout0_9ck132 FIND v(dout0_9) AT=1330.05n

* CHECK dout0_10 Vdout0_10ck132 = 1.8 time = 1330
.meas tran vdout0_10ck132 FIND v(dout0_10) AT=1330.05n

* CHECK dout0_11 Vdout0_11ck132 = 1.8 time = 1330
.meas tran vdout0_11ck132 FIND v(dout0_11) AT=1330.05n

* CHECK dout0_12 Vdout0_12ck132 = 1.8 time = 1330
.meas tran vdout0_12ck132 FIND v(dout0_12) AT=1330.05n

* CHECK dout0_13 Vdout0_13ck132 = 1.8 time = 1330
.meas tran vdout0_13ck132 FIND v(dout0_13) AT=1330.05n

* CHECK dout0_14 Vdout0_14ck132 = 1.8 time = 1330
.meas tran vdout0_14ck132 FIND v(dout0_14) AT=1330.05n

* CHECK dout0_15 Vdout0_15ck132 = 0 time = 1330
.meas tran vdout0_15ck132 FIND v(dout0_15) AT=1330.05n

* CHECK dout0_16 Vdout0_16ck132 = 1.8 time = 1330
.meas tran vdout0_16ck132 FIND v(dout0_16) AT=1330.05n

* CHECK dout0_17 Vdout0_17ck132 = 0 time = 1330
.meas tran vdout0_17ck132 FIND v(dout0_17) AT=1330.05n

* CHECK dout0_18 Vdout0_18ck132 = 0 time = 1330
.meas tran vdout0_18ck132 FIND v(dout0_18) AT=1330.05n

* CHECK dout0_19 Vdout0_19ck132 = 1.8 time = 1330
.meas tran vdout0_19ck132 FIND v(dout0_19) AT=1330.05n

* CHECK dout0_20 Vdout0_20ck132 = 0 time = 1330
.meas tran vdout0_20ck132 FIND v(dout0_20) AT=1330.05n

* CHECK dout0_21 Vdout0_21ck132 = 0 time = 1330
.meas tran vdout0_21ck132 FIND v(dout0_21) AT=1330.05n

* CHECK dout0_22 Vdout0_22ck132 = 1.8 time = 1330
.meas tran vdout0_22ck132 FIND v(dout0_22) AT=1330.05n

* CHECK dout0_23 Vdout0_23ck132 = 1.8 time = 1330
.meas tran vdout0_23ck132 FIND v(dout0_23) AT=1330.05n

* CHECK dout0_24 Vdout0_24ck132 = 1.8 time = 1330
.meas tran vdout0_24ck132 FIND v(dout0_24) AT=1330.05n

* CHECK dout0_25 Vdout0_25ck132 = 1.8 time = 1330
.meas tran vdout0_25ck132 FIND v(dout0_25) AT=1330.05n

* CHECK dout0_26 Vdout0_26ck132 = 1.8 time = 1330
.meas tran vdout0_26ck132 FIND v(dout0_26) AT=1330.05n

* CHECK dout0_27 Vdout0_27ck132 = 1.8 time = 1330
.meas tran vdout0_27ck132 FIND v(dout0_27) AT=1330.05n

* CHECK dout0_28 Vdout0_28ck132 = 0 time = 1330
.meas tran vdout0_28ck132 FIND v(dout0_28) AT=1330.05n

* CHECK dout0_29 Vdout0_29ck132 = 0 time = 1330
.meas tran vdout0_29ck132 FIND v(dout0_29) AT=1330.05n

* CHECK dout0_30 Vdout0_30ck132 = 0 time = 1330
.meas tran vdout0_30ck132 FIND v(dout0_30) AT=1330.05n

* CHECK dout0_31 Vdout0_31ck132 = 1.8 time = 1330
.meas tran vdout0_31ck132 FIND v(dout0_31) AT=1330.05n

* CHECK dout0_32 Vdout0_32ck132 = 0 time = 1330
.meas tran vdout0_32ck132 FIND v(dout0_32) AT=1330.05n

* CHECK dout0_0 Vdout0_0ck135 = 0 time = 1360
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=1360.05n

* CHECK dout0_1 Vdout0_1ck135 = 0 time = 1360
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=1360.05n

* CHECK dout0_2 Vdout0_2ck135 = 1.8 time = 1360
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=1360.05n

* CHECK dout0_3 Vdout0_3ck135 = 1.8 time = 1360
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=1360.05n

* CHECK dout0_4 Vdout0_4ck135 = 1.8 time = 1360
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=1360.05n

* CHECK dout0_5 Vdout0_5ck135 = 1.8 time = 1360
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=1360.05n

* CHECK dout0_6 Vdout0_6ck135 = 1.8 time = 1360
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=1360.05n

* CHECK dout0_7 Vdout0_7ck135 = 1.8 time = 1360
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=1360.05n

* CHECK dout0_8 Vdout0_8ck135 = 0 time = 1360
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=1360.05n

* CHECK dout0_9 Vdout0_9ck135 = 1.8 time = 1360
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=1360.05n

* CHECK dout0_10 Vdout0_10ck135 = 0 time = 1360
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=1360.05n

* CHECK dout0_11 Vdout0_11ck135 = 0 time = 1360
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=1360.05n

* CHECK dout0_12 Vdout0_12ck135 = 0 time = 1360
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=1360.05n

* CHECK dout0_13 Vdout0_13ck135 = 0 time = 1360
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=1360.05n

* CHECK dout0_14 Vdout0_14ck135 = 0 time = 1360
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=1360.05n

* CHECK dout0_15 Vdout0_15ck135 = 1.8 time = 1360
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=1360.05n

* CHECK dout0_16 Vdout0_16ck135 = 1.8 time = 1360
.meas tran vdout0_16ck135 FIND v(dout0_16) AT=1360.05n

* CHECK dout0_17 Vdout0_17ck135 = 1.8 time = 1360
.meas tran vdout0_17ck135 FIND v(dout0_17) AT=1360.05n

* CHECK dout0_18 Vdout0_18ck135 = 0 time = 1360
.meas tran vdout0_18ck135 FIND v(dout0_18) AT=1360.05n

* CHECK dout0_19 Vdout0_19ck135 = 1.8 time = 1360
.meas tran vdout0_19ck135 FIND v(dout0_19) AT=1360.05n

* CHECK dout0_20 Vdout0_20ck135 = 0 time = 1360
.meas tran vdout0_20ck135 FIND v(dout0_20) AT=1360.05n

* CHECK dout0_21 Vdout0_21ck135 = 1.8 time = 1360
.meas tran vdout0_21ck135 FIND v(dout0_21) AT=1360.05n

* CHECK dout0_22 Vdout0_22ck135 = 0 time = 1360
.meas tran vdout0_22ck135 FIND v(dout0_22) AT=1360.05n

* CHECK dout0_23 Vdout0_23ck135 = 0 time = 1360
.meas tran vdout0_23ck135 FIND v(dout0_23) AT=1360.05n

* CHECK dout0_24 Vdout0_24ck135 = 1.8 time = 1360
.meas tran vdout0_24ck135 FIND v(dout0_24) AT=1360.05n

* CHECK dout0_25 Vdout0_25ck135 = 0 time = 1360
.meas tran vdout0_25ck135 FIND v(dout0_25) AT=1360.05n

* CHECK dout0_26 Vdout0_26ck135 = 0 time = 1360
.meas tran vdout0_26ck135 FIND v(dout0_26) AT=1360.05n

* CHECK dout0_27 Vdout0_27ck135 = 1.8 time = 1360
.meas tran vdout0_27ck135 FIND v(dout0_27) AT=1360.05n

* CHECK dout0_28 Vdout0_28ck135 = 0 time = 1360
.meas tran vdout0_28ck135 FIND v(dout0_28) AT=1360.05n

* CHECK dout0_29 Vdout0_29ck135 = 0 time = 1360
.meas tran vdout0_29ck135 FIND v(dout0_29) AT=1360.05n

* CHECK dout0_30 Vdout0_30ck135 = 0 time = 1360
.meas tran vdout0_30ck135 FIND v(dout0_30) AT=1360.05n

* CHECK dout0_31 Vdout0_31ck135 = 1.8 time = 1360
.meas tran vdout0_31ck135 FIND v(dout0_31) AT=1360.05n

* CHECK dout0_32 Vdout0_32ck135 = 0 time = 1360
.meas tran vdout0_32ck135 FIND v(dout0_32) AT=1360.05n

* CHECK dout0_0 Vdout0_0ck137 = 0 time = 1380
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=1380.05n

* CHECK dout0_1 Vdout0_1ck137 = 0 time = 1380
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=1380.05n

* CHECK dout0_2 Vdout0_2ck137 = 1.8 time = 1380
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=1380.05n

* CHECK dout0_3 Vdout0_3ck137 = 1.8 time = 1380
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=1380.05n

* CHECK dout0_4 Vdout0_4ck137 = 1.8 time = 1380
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=1380.05n

* CHECK dout0_5 Vdout0_5ck137 = 1.8 time = 1380
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=1380.05n

* CHECK dout0_6 Vdout0_6ck137 = 1.8 time = 1380
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=1380.05n

* CHECK dout0_7 Vdout0_7ck137 = 1.8 time = 1380
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=1380.05n

* CHECK dout0_8 Vdout0_8ck137 = 0 time = 1380
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=1380.05n

* CHECK dout0_9 Vdout0_9ck137 = 1.8 time = 1380
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=1380.05n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 1380
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=1380.05n

* CHECK dout0_11 Vdout0_11ck137 = 0 time = 1380
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=1380.05n

* CHECK dout0_12 Vdout0_12ck137 = 0 time = 1380
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=1380.05n

* CHECK dout0_13 Vdout0_13ck137 = 0 time = 1380
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=1380.05n

* CHECK dout0_14 Vdout0_14ck137 = 0 time = 1380
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=1380.05n

* CHECK dout0_15 Vdout0_15ck137 = 1.8 time = 1380
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=1380.05n

* CHECK dout0_16 Vdout0_16ck137 = 1.8 time = 1380
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=1380.05n

* CHECK dout0_17 Vdout0_17ck137 = 1.8 time = 1380
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=1380.05n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 1380
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=1380.05n

* CHECK dout0_19 Vdout0_19ck137 = 1.8 time = 1380
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=1380.05n

* CHECK dout0_20 Vdout0_20ck137 = 0 time = 1380
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=1380.05n

* CHECK dout0_21 Vdout0_21ck137 = 1.8 time = 1380
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=1380.05n

* CHECK dout0_22 Vdout0_22ck137 = 0 time = 1380
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=1380.05n

* CHECK dout0_23 Vdout0_23ck137 = 0 time = 1380
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=1380.05n

* CHECK dout0_24 Vdout0_24ck137 = 1.8 time = 1380
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=1380.05n

* CHECK dout0_25 Vdout0_25ck137 = 0 time = 1380
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=1380.05n

* CHECK dout0_26 Vdout0_26ck137 = 0 time = 1380
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=1380.05n

* CHECK dout0_27 Vdout0_27ck137 = 1.8 time = 1380
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=1380.05n

* CHECK dout0_28 Vdout0_28ck137 = 0 time = 1380
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=1380.05n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 1380
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=1380.05n

* CHECK dout0_30 Vdout0_30ck137 = 0 time = 1380
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=1380.05n

* CHECK dout0_31 Vdout0_31ck137 = 1.8 time = 1380
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=1380.05n

* CHECK dout0_32 Vdout0_32ck137 = 0 time = 1380
.meas tran vdout0_32ck137 FIND v(dout0_32) AT=1380.05n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 1400
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=1400.05n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 1400
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=1400.05n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 1400
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=1400.05n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 1400
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=1400.05n

* CHECK dout0_4 Vdout0_4ck139 = 1.8 time = 1400
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=1400.05n

* CHECK dout0_5 Vdout0_5ck139 = 1.8 time = 1400
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=1400.05n

* CHECK dout0_6 Vdout0_6ck139 = 1.8 time = 1400
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=1400.05n

* CHECK dout0_7 Vdout0_7ck139 = 1.8 time = 1400
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=1400.05n

* CHECK dout0_8 Vdout0_8ck139 = 1.8 time = 1400
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=1400.05n

* CHECK dout0_9 Vdout0_9ck139 = 0 time = 1400
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=1400.05n

* CHECK dout0_10 Vdout0_10ck139 = 1.8 time = 1400
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=1400.05n

* CHECK dout0_11 Vdout0_11ck139 = 1.8 time = 1400
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=1400.05n

* CHECK dout0_12 Vdout0_12ck139 = 0 time = 1400
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=1400.05n

* CHECK dout0_13 Vdout0_13ck139 = 1.8 time = 1400
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=1400.05n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 1400
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=1400.05n

* CHECK dout0_15 Vdout0_15ck139 = 0 time = 1400
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=1400.05n

* CHECK dout0_16 Vdout0_16ck139 = 1.8 time = 1400
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=1400.05n

* CHECK dout0_17 Vdout0_17ck139 = 1.8 time = 1400
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=1400.05n

* CHECK dout0_18 Vdout0_18ck139 = 1.8 time = 1400
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=1400.05n

* CHECK dout0_19 Vdout0_19ck139 = 1.8 time = 1400
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=1400.05n

* CHECK dout0_20 Vdout0_20ck139 = 1.8 time = 1400
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=1400.05n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 1400
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=1400.05n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 1400
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=1400.05n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 1400
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=1400.05n

* CHECK dout0_24 Vdout0_24ck139 = 1.8 time = 1400
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=1400.05n

* CHECK dout0_25 Vdout0_25ck139 = 0 time = 1400
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=1400.05n

* CHECK dout0_26 Vdout0_26ck139 = 0 time = 1400
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=1400.05n

* CHECK dout0_27 Vdout0_27ck139 = 0 time = 1400
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=1400.05n

* CHECK dout0_28 Vdout0_28ck139 = 1.8 time = 1400
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=1400.05n

* CHECK dout0_29 Vdout0_29ck139 = 1.8 time = 1400
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=1400.05n

* CHECK dout0_30 Vdout0_30ck139 = 0 time = 1400
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=1400.05n

* CHECK dout0_31 Vdout0_31ck139 = 1.8 time = 1400
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=1400.05n

* CHECK dout0_32 Vdout0_32ck139 = 0 time = 1400
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=1400.05n

* CHECK dout0_0 Vdout0_0ck146 = 1.8 time = 1470
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=1470.05n

* CHECK dout0_1 Vdout0_1ck146 = 1.8 time = 1470
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=1470.05n

* CHECK dout0_2 Vdout0_2ck146 = 0 time = 1470
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=1470.05n

* CHECK dout0_3 Vdout0_3ck146 = 1.8 time = 1470
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=1470.05n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 1470
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=1470.05n

* CHECK dout0_5 Vdout0_5ck146 = 1.8 time = 1470
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=1470.05n

* CHECK dout0_6 Vdout0_6ck146 = 1.8 time = 1470
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=1470.05n

* CHECK dout0_7 Vdout0_7ck146 = 0 time = 1470
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=1470.05n

* CHECK dout0_8 Vdout0_8ck146 = 0 time = 1470
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=1470.05n

* CHECK dout0_9 Vdout0_9ck146 = 1.8 time = 1470
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=1470.05n

* CHECK dout0_10 Vdout0_10ck146 = 1.8 time = 1470
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=1470.05n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 1470
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=1470.05n

* CHECK dout0_12 Vdout0_12ck146 = 1.8 time = 1470
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=1470.05n

* CHECK dout0_13 Vdout0_13ck146 = 1.8 time = 1470
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=1470.05n

* CHECK dout0_14 Vdout0_14ck146 = 0 time = 1470
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=1470.05n

* CHECK dout0_15 Vdout0_15ck146 = 1.8 time = 1470
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=1470.05n

* CHECK dout0_16 Vdout0_16ck146 = 1.8 time = 1470
.meas tran vdout0_16ck146 FIND v(dout0_16) AT=1470.05n

* CHECK dout0_17 Vdout0_17ck146 = 1.8 time = 1470
.meas tran vdout0_17ck146 FIND v(dout0_17) AT=1470.05n

* CHECK dout0_18 Vdout0_18ck146 = 1.8 time = 1470
.meas tran vdout0_18ck146 FIND v(dout0_18) AT=1470.05n

* CHECK dout0_19 Vdout0_19ck146 = 0 time = 1470
.meas tran vdout0_19ck146 FIND v(dout0_19) AT=1470.05n

* CHECK dout0_20 Vdout0_20ck146 = 0 time = 1470
.meas tran vdout0_20ck146 FIND v(dout0_20) AT=1470.05n

* CHECK dout0_21 Vdout0_21ck146 = 1.8 time = 1470
.meas tran vdout0_21ck146 FIND v(dout0_21) AT=1470.05n

* CHECK dout0_22 Vdout0_22ck146 = 1.8 time = 1470
.meas tran vdout0_22ck146 FIND v(dout0_22) AT=1470.05n

* CHECK dout0_23 Vdout0_23ck146 = 0 time = 1470
.meas tran vdout0_23ck146 FIND v(dout0_23) AT=1470.05n

* CHECK dout0_24 Vdout0_24ck146 = 0 time = 1470
.meas tran vdout0_24ck146 FIND v(dout0_24) AT=1470.05n

* CHECK dout0_25 Vdout0_25ck146 = 0 time = 1470
.meas tran vdout0_25ck146 FIND v(dout0_25) AT=1470.05n

* CHECK dout0_26 Vdout0_26ck146 = 1.8 time = 1470
.meas tran vdout0_26ck146 FIND v(dout0_26) AT=1470.05n

* CHECK dout0_27 Vdout0_27ck146 = 1.8 time = 1470
.meas tran vdout0_27ck146 FIND v(dout0_27) AT=1470.05n

* CHECK dout0_28 Vdout0_28ck146 = 0 time = 1470
.meas tran vdout0_28ck146 FIND v(dout0_28) AT=1470.05n

* CHECK dout0_29 Vdout0_29ck146 = 0 time = 1470
.meas tran vdout0_29ck146 FIND v(dout0_29) AT=1470.05n

* CHECK dout0_30 Vdout0_30ck146 = 0 time = 1470
.meas tran vdout0_30ck146 FIND v(dout0_30) AT=1470.05n

* CHECK dout0_31 Vdout0_31ck146 = 0 time = 1470
.meas tran vdout0_31ck146 FIND v(dout0_31) AT=1470.05n

* CHECK dout0_32 Vdout0_32ck146 = 0 time = 1470
.meas tran vdout0_32ck146 FIND v(dout0_32) AT=1470.05n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 1490
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=1490.05n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 1490
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=1490.05n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 1490
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=1490.05n

* CHECK dout0_3 Vdout0_3ck148 = 1.8 time = 1490
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=1490.05n

* CHECK dout0_4 Vdout0_4ck148 = 1.8 time = 1490
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=1490.05n

* CHECK dout0_5 Vdout0_5ck148 = 0 time = 1490
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=1490.05n

* CHECK dout0_6 Vdout0_6ck148 = 0 time = 1490
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=1490.05n

* CHECK dout0_7 Vdout0_7ck148 = 1.8 time = 1490
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=1490.05n

* CHECK dout0_8 Vdout0_8ck148 = 1.8 time = 1490
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=1490.05n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 1490
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=1490.05n

* CHECK dout0_10 Vdout0_10ck148 = 1.8 time = 1490
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=1490.05n

* CHECK dout0_11 Vdout0_11ck148 = 0 time = 1490
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=1490.05n

* CHECK dout0_12 Vdout0_12ck148 = 1.8 time = 1490
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=1490.05n

* CHECK dout0_13 Vdout0_13ck148 = 0 time = 1490
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=1490.05n

* CHECK dout0_14 Vdout0_14ck148 = 0 time = 1490
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=1490.05n

* CHECK dout0_15 Vdout0_15ck148 = 0 time = 1490
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=1490.05n

* CHECK dout0_16 Vdout0_16ck148 = 1.8 time = 1490
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=1490.05n

* CHECK dout0_17 Vdout0_17ck148 = 1.8 time = 1490
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=1490.05n

* CHECK dout0_18 Vdout0_18ck148 = 0 time = 1490
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=1490.05n

* CHECK dout0_19 Vdout0_19ck148 = 1.8 time = 1490
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=1490.05n

* CHECK dout0_20 Vdout0_20ck148 = 1.8 time = 1490
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=1490.05n

* CHECK dout0_21 Vdout0_21ck148 = 1.8 time = 1490
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=1490.05n

* CHECK dout0_22 Vdout0_22ck148 = 0 time = 1490
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=1490.05n

* CHECK dout0_23 Vdout0_23ck148 = 1.8 time = 1490
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=1490.05n

* CHECK dout0_24 Vdout0_24ck148 = 1.8 time = 1490
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=1490.05n

* CHECK dout0_25 Vdout0_25ck148 = 0 time = 1490
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=1490.05n

* CHECK dout0_26 Vdout0_26ck148 = 1.8 time = 1490
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=1490.05n

* CHECK dout0_27 Vdout0_27ck148 = 1.8 time = 1490
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=1490.05n

* CHECK dout0_28 Vdout0_28ck148 = 1.8 time = 1490
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=1490.05n

* CHECK dout0_29 Vdout0_29ck148 = 1.8 time = 1490
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=1490.05n

* CHECK dout0_30 Vdout0_30ck148 = 1.8 time = 1490
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=1490.05n

* CHECK dout0_31 Vdout0_31ck148 = 0 time = 1490
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=1490.05n

* CHECK dout0_32 Vdout0_32ck148 = 0 time = 1490
.meas tran vdout0_32ck148 FIND v(dout0_32) AT=1490.05n

* CHECK dout0_0 Vdout0_0ck156 = 1.8 time = 1570
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=1570.05n

* CHECK dout0_1 Vdout0_1ck156 = 0 time = 1570
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=1570.05n

* CHECK dout0_2 Vdout0_2ck156 = 1.8 time = 1570
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=1570.05n

* CHECK dout0_3 Vdout0_3ck156 = 0 time = 1570
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=1570.05n

* CHECK dout0_4 Vdout0_4ck156 = 1.8 time = 1570
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=1570.05n

* CHECK dout0_5 Vdout0_5ck156 = 0 time = 1570
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=1570.05n

* CHECK dout0_6 Vdout0_6ck156 = 0 time = 1570
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=1570.05n

* CHECK dout0_7 Vdout0_7ck156 = 1.8 time = 1570
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=1570.05n

* CHECK dout0_8 Vdout0_8ck156 = 0 time = 1570
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=1570.05n

* CHECK dout0_9 Vdout0_9ck156 = 0 time = 1570
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=1570.05n

* CHECK dout0_10 Vdout0_10ck156 = 1.8 time = 1570
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=1570.05n

* CHECK dout0_11 Vdout0_11ck156 = 0 time = 1570
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=1570.05n

* CHECK dout0_12 Vdout0_12ck156 = 0 time = 1570
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=1570.05n

* CHECK dout0_13 Vdout0_13ck156 = 1.8 time = 1570
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=1570.05n

* CHECK dout0_14 Vdout0_14ck156 = 0 time = 1570
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=1570.05n

* CHECK dout0_15 Vdout0_15ck156 = 1.8 time = 1570
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=1570.05n

* CHECK dout0_16 Vdout0_16ck156 = 0 time = 1570
.meas tran vdout0_16ck156 FIND v(dout0_16) AT=1570.05n

* CHECK dout0_17 Vdout0_17ck156 = 1.8 time = 1570
.meas tran vdout0_17ck156 FIND v(dout0_17) AT=1570.05n

* CHECK dout0_18 Vdout0_18ck156 = 0 time = 1570
.meas tran vdout0_18ck156 FIND v(dout0_18) AT=1570.05n

* CHECK dout0_19 Vdout0_19ck156 = 0 time = 1570
.meas tran vdout0_19ck156 FIND v(dout0_19) AT=1570.05n

* CHECK dout0_20 Vdout0_20ck156 = 0 time = 1570
.meas tran vdout0_20ck156 FIND v(dout0_20) AT=1570.05n

* CHECK dout0_21 Vdout0_21ck156 = 0 time = 1570
.meas tran vdout0_21ck156 FIND v(dout0_21) AT=1570.05n

* CHECK dout0_22 Vdout0_22ck156 = 0 time = 1570
.meas tran vdout0_22ck156 FIND v(dout0_22) AT=1570.05n

* CHECK dout0_23 Vdout0_23ck156 = 0 time = 1570
.meas tran vdout0_23ck156 FIND v(dout0_23) AT=1570.05n

* CHECK dout0_24 Vdout0_24ck156 = 0 time = 1570
.meas tran vdout0_24ck156 FIND v(dout0_24) AT=1570.05n

* CHECK dout0_25 Vdout0_25ck156 = 0 time = 1570
.meas tran vdout0_25ck156 FIND v(dout0_25) AT=1570.05n

* CHECK dout0_26 Vdout0_26ck156 = 1.8 time = 1570
.meas tran vdout0_26ck156 FIND v(dout0_26) AT=1570.05n

* CHECK dout0_27 Vdout0_27ck156 = 0 time = 1570
.meas tran vdout0_27ck156 FIND v(dout0_27) AT=1570.05n

* CHECK dout0_28 Vdout0_28ck156 = 0 time = 1570
.meas tran vdout0_28ck156 FIND v(dout0_28) AT=1570.05n

* CHECK dout0_29 Vdout0_29ck156 = 0 time = 1570
.meas tran vdout0_29ck156 FIND v(dout0_29) AT=1570.05n

* CHECK dout0_30 Vdout0_30ck156 = 1.8 time = 1570
.meas tran vdout0_30ck156 FIND v(dout0_30) AT=1570.05n

* CHECK dout0_31 Vdout0_31ck156 = 0 time = 1570
.meas tran vdout0_31ck156 FIND v(dout0_31) AT=1570.05n

* CHECK dout0_32 Vdout0_32ck156 = 0 time = 1570
.meas tran vdout0_32ck156 FIND v(dout0_32) AT=1570.05n

* CHECK dout0_0 Vdout0_0ck157 = 0 time = 1580
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=1580.05n

* CHECK dout0_1 Vdout0_1ck157 = 0 time = 1580
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=1580.05n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 1580
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=1580.05n

* CHECK dout0_3 Vdout0_3ck157 = 1.8 time = 1580
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=1580.05n

* CHECK dout0_4 Vdout0_4ck157 = 1.8 time = 1580
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=1580.05n

* CHECK dout0_5 Vdout0_5ck157 = 0 time = 1580
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=1580.05n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 1580
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=1580.05n

* CHECK dout0_7 Vdout0_7ck157 = 1.8 time = 1580
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=1580.05n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 1580
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=1580.05n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 1580
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=1580.05n

* CHECK dout0_10 Vdout0_10ck157 = 1.8 time = 1580
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=1580.05n

* CHECK dout0_11 Vdout0_11ck157 = 0 time = 1580
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=1580.05n

* CHECK dout0_12 Vdout0_12ck157 = 1.8 time = 1580
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=1580.05n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 1580
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=1580.05n

* CHECK dout0_14 Vdout0_14ck157 = 0 time = 1580
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=1580.05n

* CHECK dout0_15 Vdout0_15ck157 = 0 time = 1580
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=1580.05n

* CHECK dout0_16 Vdout0_16ck157 = 1.8 time = 1580
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=1580.05n

* CHECK dout0_17 Vdout0_17ck157 = 1.8 time = 1580
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=1580.05n

* CHECK dout0_18 Vdout0_18ck157 = 0 time = 1580
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=1580.05n

* CHECK dout0_19 Vdout0_19ck157 = 1.8 time = 1580
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=1580.05n

* CHECK dout0_20 Vdout0_20ck157 = 1.8 time = 1580
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=1580.05n

* CHECK dout0_21 Vdout0_21ck157 = 1.8 time = 1580
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=1580.05n

* CHECK dout0_22 Vdout0_22ck157 = 0 time = 1580
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=1580.05n

* CHECK dout0_23 Vdout0_23ck157 = 1.8 time = 1580
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=1580.05n

* CHECK dout0_24 Vdout0_24ck157 = 1.8 time = 1580
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=1580.05n

* CHECK dout0_25 Vdout0_25ck157 = 0 time = 1580
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=1580.05n

* CHECK dout0_26 Vdout0_26ck157 = 1.8 time = 1580
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=1580.05n

* CHECK dout0_27 Vdout0_27ck157 = 1.8 time = 1580
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=1580.05n

* CHECK dout0_28 Vdout0_28ck157 = 1.8 time = 1580
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=1580.05n

* CHECK dout0_29 Vdout0_29ck157 = 1.8 time = 1580
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=1580.05n

* CHECK dout0_30 Vdout0_30ck157 = 1.8 time = 1580
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=1580.05n

* CHECK dout0_31 Vdout0_31ck157 = 0 time = 1580
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=1580.05n

* CHECK dout0_32 Vdout0_32ck157 = 0 time = 1580
.meas tran vdout0_32ck157 FIND v(dout0_32) AT=1580.05n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 1590
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=1590.05n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 1590
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=1590.05n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 1590
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=1590.05n

* CHECK dout0_3 Vdout0_3ck158 = 1.8 time = 1590
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=1590.05n

* CHECK dout0_4 Vdout0_4ck158 = 1.8 time = 1590
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=1590.05n

* CHECK dout0_5 Vdout0_5ck158 = 0 time = 1590
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=1590.05n

* CHECK dout0_6 Vdout0_6ck158 = 0 time = 1590
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=1590.05n

* CHECK dout0_7 Vdout0_7ck158 = 1.8 time = 1590
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=1590.05n

* CHECK dout0_8 Vdout0_8ck158 = 1.8 time = 1590
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=1590.05n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 1590
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=1590.05n

* CHECK dout0_10 Vdout0_10ck158 = 1.8 time = 1590
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=1590.05n

* CHECK dout0_11 Vdout0_11ck158 = 0 time = 1590
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=1590.05n

* CHECK dout0_12 Vdout0_12ck158 = 1.8 time = 1590
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=1590.05n

* CHECK dout0_13 Vdout0_13ck158 = 0 time = 1590
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=1590.05n

* CHECK dout0_14 Vdout0_14ck158 = 0 time = 1590
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=1590.05n

* CHECK dout0_15 Vdout0_15ck158 = 0 time = 1590
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=1590.05n

* CHECK dout0_16 Vdout0_16ck158 = 1.8 time = 1590
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=1590.05n

* CHECK dout0_17 Vdout0_17ck158 = 1.8 time = 1590
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=1590.05n

* CHECK dout0_18 Vdout0_18ck158 = 0 time = 1590
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=1590.05n

* CHECK dout0_19 Vdout0_19ck158 = 1.8 time = 1590
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=1590.05n

* CHECK dout0_20 Vdout0_20ck158 = 1.8 time = 1590
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=1590.05n

* CHECK dout0_21 Vdout0_21ck158 = 1.8 time = 1590
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=1590.05n

* CHECK dout0_22 Vdout0_22ck158 = 0 time = 1590
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=1590.05n

* CHECK dout0_23 Vdout0_23ck158 = 1.8 time = 1590
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=1590.05n

* CHECK dout0_24 Vdout0_24ck158 = 1.8 time = 1590
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=1590.05n

* CHECK dout0_25 Vdout0_25ck158 = 0 time = 1590
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=1590.05n

* CHECK dout0_26 Vdout0_26ck158 = 1.8 time = 1590
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=1590.05n

* CHECK dout0_27 Vdout0_27ck158 = 1.8 time = 1590
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=1590.05n

* CHECK dout0_28 Vdout0_28ck158 = 1.8 time = 1590
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=1590.05n

* CHECK dout0_29 Vdout0_29ck158 = 1.8 time = 1590
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=1590.05n

* CHECK dout0_30 Vdout0_30ck158 = 1.8 time = 1590
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=1590.05n

* CHECK dout0_31 Vdout0_31ck158 = 0 time = 1590
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=1590.05n

* CHECK dout0_32 Vdout0_32ck158 = 0 time = 1590
.meas tran vdout0_32ck158 FIND v(dout0_32) AT=1590.05n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 1610
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=1610.05n

* CHECK dout0_1 Vdout0_1ck160 = 0 time = 1610
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=1610.05n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 1610
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=1610.05n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 1610
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=1610.05n

* CHECK dout0_4 Vdout0_4ck160 = 1.8 time = 1610
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=1610.05n

* CHECK dout0_5 Vdout0_5ck160 = 1.8 time = 1610
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=1610.05n

* CHECK dout0_6 Vdout0_6ck160 = 1.8 time = 1610
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=1610.05n

* CHECK dout0_7 Vdout0_7ck160 = 1.8 time = 1610
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=1610.05n

* CHECK dout0_8 Vdout0_8ck160 = 1.8 time = 1610
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=1610.05n

* CHECK dout0_9 Vdout0_9ck160 = 0 time = 1610
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=1610.05n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 1610
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=1610.05n

* CHECK dout0_11 Vdout0_11ck160 = 1.8 time = 1610
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=1610.05n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 1610
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=1610.05n

* CHECK dout0_13 Vdout0_13ck160 = 1.8 time = 1610
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=1610.05n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 1610
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=1610.05n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 1610
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=1610.05n

* CHECK dout0_16 Vdout0_16ck160 = 0 time = 1610
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=1610.05n

* CHECK dout0_17 Vdout0_17ck160 = 1.8 time = 1610
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=1610.05n

* CHECK dout0_18 Vdout0_18ck160 = 1.8 time = 1610
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=1610.05n

* CHECK dout0_19 Vdout0_19ck160 = 1.8 time = 1610
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=1610.05n

* CHECK dout0_20 Vdout0_20ck160 = 1.8 time = 1610
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=1610.05n

* CHECK dout0_21 Vdout0_21ck160 = 0 time = 1610
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=1610.05n

* CHECK dout0_22 Vdout0_22ck160 = 0 time = 1610
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=1610.05n

* CHECK dout0_23 Vdout0_23ck160 = 1.8 time = 1610
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=1610.05n

* CHECK dout0_24 Vdout0_24ck160 = 1.8 time = 1610
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=1610.05n

* CHECK dout0_25 Vdout0_25ck160 = 0 time = 1610
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=1610.05n

* CHECK dout0_26 Vdout0_26ck160 = 0 time = 1610
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=1610.05n

* CHECK dout0_27 Vdout0_27ck160 = 0 time = 1610
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=1610.05n

* CHECK dout0_28 Vdout0_28ck160 = 1.8 time = 1610
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=1610.05n

* CHECK dout0_29 Vdout0_29ck160 = 1.8 time = 1610
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=1610.05n

* CHECK dout0_30 Vdout0_30ck160 = 0 time = 1610
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=1610.05n

* CHECK dout0_31 Vdout0_31ck160 = 1.8 time = 1610
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=1610.05n

* CHECK dout0_32 Vdout0_32ck160 = 0 time = 1610
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=1610.05n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 1630
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=1630.05n

* CHECK dout0_1 Vdout0_1ck162 = 0 time = 1630
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=1630.05n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 1630
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=1630.05n

* CHECK dout0_3 Vdout0_3ck162 = 0 time = 1630
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=1630.05n

* CHECK dout0_4 Vdout0_4ck162 = 1.8 time = 1630
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=1630.05n

* CHECK dout0_5 Vdout0_5ck162 = 1.8 time = 1630
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=1630.05n

* CHECK dout0_6 Vdout0_6ck162 = 1.8 time = 1630
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=1630.05n

* CHECK dout0_7 Vdout0_7ck162 = 1.8 time = 1630
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=1630.05n

* CHECK dout0_8 Vdout0_8ck162 = 1.8 time = 1630
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=1630.05n

* CHECK dout0_9 Vdout0_9ck162 = 0 time = 1630
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=1630.05n

* CHECK dout0_10 Vdout0_10ck162 = 1.8 time = 1630
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=1630.05n

* CHECK dout0_11 Vdout0_11ck162 = 1.8 time = 1630
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=1630.05n

* CHECK dout0_12 Vdout0_12ck162 = 0 time = 1630
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=1630.05n

* CHECK dout0_13 Vdout0_13ck162 = 1.8 time = 1630
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=1630.05n

* CHECK dout0_14 Vdout0_14ck162 = 0 time = 1630
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=1630.05n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 1630
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=1630.05n

* CHECK dout0_16 Vdout0_16ck162 = 0 time = 1630
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=1630.05n

* CHECK dout0_17 Vdout0_17ck162 = 1.8 time = 1630
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=1630.05n

* CHECK dout0_18 Vdout0_18ck162 = 1.8 time = 1630
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=1630.05n

* CHECK dout0_19 Vdout0_19ck162 = 1.8 time = 1630
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=1630.05n

* CHECK dout0_20 Vdout0_20ck162 = 1.8 time = 1630
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=1630.05n

* CHECK dout0_21 Vdout0_21ck162 = 0 time = 1630
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=1630.05n

* CHECK dout0_22 Vdout0_22ck162 = 0 time = 1630
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=1630.05n

* CHECK dout0_23 Vdout0_23ck162 = 1.8 time = 1630
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=1630.05n

* CHECK dout0_24 Vdout0_24ck162 = 1.8 time = 1630
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=1630.05n

* CHECK dout0_25 Vdout0_25ck162 = 0 time = 1630
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=1630.05n

* CHECK dout0_26 Vdout0_26ck162 = 0 time = 1630
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=1630.05n

* CHECK dout0_27 Vdout0_27ck162 = 0 time = 1630
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=1630.05n

* CHECK dout0_28 Vdout0_28ck162 = 1.8 time = 1630
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=1630.05n

* CHECK dout0_29 Vdout0_29ck162 = 1.8 time = 1630
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=1630.05n

* CHECK dout0_30 Vdout0_30ck162 = 0 time = 1630
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=1630.05n

* CHECK dout0_31 Vdout0_31ck162 = 1.8 time = 1630
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=1630.05n

* CHECK dout0_32 Vdout0_32ck162 = 0 time = 1630
.meas tran vdout0_32ck162 FIND v(dout0_32) AT=1630.05n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 1700
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=1700.05n

* CHECK dout0_1 Vdout0_1ck169 = 0 time = 1700
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=1700.05n

* CHECK dout0_2 Vdout0_2ck169 = 0 time = 1700
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=1700.05n

* CHECK dout0_3 Vdout0_3ck169 = 0 time = 1700
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=1700.05n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 1700
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=1700.05n

* CHECK dout0_5 Vdout0_5ck169 = 1.8 time = 1700
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=1700.05n

* CHECK dout0_6 Vdout0_6ck169 = 0 time = 1700
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=1700.05n

* CHECK dout0_7 Vdout0_7ck169 = 1.8 time = 1700
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=1700.05n

* CHECK dout0_8 Vdout0_8ck169 = 0 time = 1700
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=1700.05n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 1700
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=1700.05n

* CHECK dout0_10 Vdout0_10ck169 = 1.8 time = 1700
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=1700.05n

* CHECK dout0_11 Vdout0_11ck169 = 0 time = 1700
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=1700.05n

* CHECK dout0_12 Vdout0_12ck169 = 1.8 time = 1700
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=1700.05n

* CHECK dout0_13 Vdout0_13ck169 = 1.8 time = 1700
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=1700.05n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 1700
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=1700.05n

* CHECK dout0_15 Vdout0_15ck169 = 1.8 time = 1700
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=1700.05n

* CHECK dout0_16 Vdout0_16ck169 = 1.8 time = 1700
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=1700.05n

* CHECK dout0_17 Vdout0_17ck169 = 0 time = 1700
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=1700.05n

* CHECK dout0_18 Vdout0_18ck169 = 1.8 time = 1700
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=1700.05n

* CHECK dout0_19 Vdout0_19ck169 = 1.8 time = 1700
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=1700.05n

* CHECK dout0_20 Vdout0_20ck169 = 0 time = 1700
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=1700.05n

* CHECK dout0_21 Vdout0_21ck169 = 1.8 time = 1700
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=1700.05n

* CHECK dout0_22 Vdout0_22ck169 = 1.8 time = 1700
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=1700.05n

* CHECK dout0_23 Vdout0_23ck169 = 0 time = 1700
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=1700.05n

* CHECK dout0_24 Vdout0_24ck169 = 0 time = 1700
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=1700.05n

* CHECK dout0_25 Vdout0_25ck169 = 0 time = 1700
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=1700.05n

* CHECK dout0_26 Vdout0_26ck169 = 1.8 time = 1700
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=1700.05n

* CHECK dout0_27 Vdout0_27ck169 = 1.8 time = 1700
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=1700.05n

* CHECK dout0_28 Vdout0_28ck169 = 0 time = 1700
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=1700.05n

* CHECK dout0_29 Vdout0_29ck169 = 0 time = 1700
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=1700.05n

* CHECK dout0_30 Vdout0_30ck169 = 0 time = 1700
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=1700.05n

* CHECK dout0_31 Vdout0_31ck169 = 0 time = 1700
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=1700.05n

* CHECK dout0_32 Vdout0_32ck169 = 0 time = 1700
.meas tran vdout0_32ck169 FIND v(dout0_32) AT=1700.05n

* CHECK dout0_0 Vdout0_0ck172 = 1.8 time = 1730
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=1730.05n

* CHECK dout0_1 Vdout0_1ck172 = 1.8 time = 1730
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=1730.05n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 1730
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=1730.05n

* CHECK dout0_3 Vdout0_3ck172 = 1.8 time = 1730
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=1730.05n

* CHECK dout0_4 Vdout0_4ck172 = 1.8 time = 1730
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=1730.05n

* CHECK dout0_5 Vdout0_5ck172 = 1.8 time = 1730
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=1730.05n

* CHECK dout0_6 Vdout0_6ck172 = 1.8 time = 1730
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=1730.05n

* CHECK dout0_7 Vdout0_7ck172 = 1.8 time = 1730
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=1730.05n

* CHECK dout0_8 Vdout0_8ck172 = 1.8 time = 1730
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=1730.05n

* CHECK dout0_9 Vdout0_9ck172 = 1.8 time = 1730
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=1730.05n

* CHECK dout0_10 Vdout0_10ck172 = 1.8 time = 1730
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=1730.05n

* CHECK dout0_11 Vdout0_11ck172 = 0 time = 1730
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=1730.05n

* CHECK dout0_12 Vdout0_12ck172 = 0 time = 1730
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=1730.05n

* CHECK dout0_13 Vdout0_13ck172 = 1.8 time = 1730
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=1730.05n

* CHECK dout0_14 Vdout0_14ck172 = 0 time = 1730
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=1730.05n

* CHECK dout0_15 Vdout0_15ck172 = 0 time = 1730
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=1730.05n

* CHECK dout0_16 Vdout0_16ck172 = 1.8 time = 1730
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=1730.05n

* CHECK dout0_17 Vdout0_17ck172 = 0 time = 1730
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=1730.05n

* CHECK dout0_18 Vdout0_18ck172 = 1.8 time = 1730
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=1730.05n

* CHECK dout0_19 Vdout0_19ck172 = 1.8 time = 1730
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=1730.05n

* CHECK dout0_20 Vdout0_20ck172 = 1.8 time = 1730
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=1730.05n

* CHECK dout0_21 Vdout0_21ck172 = 0 time = 1730
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=1730.05n

* CHECK dout0_22 Vdout0_22ck172 = 1.8 time = 1730
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=1730.05n

* CHECK dout0_23 Vdout0_23ck172 = 1.8 time = 1730
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=1730.05n

* CHECK dout0_24 Vdout0_24ck172 = 0 time = 1730
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=1730.05n

* CHECK dout0_25 Vdout0_25ck172 = 0 time = 1730
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=1730.05n

* CHECK dout0_26 Vdout0_26ck172 = 1.8 time = 1730
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=1730.05n

* CHECK dout0_27 Vdout0_27ck172 = 1.8 time = 1730
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=1730.05n

* CHECK dout0_28 Vdout0_28ck172 = 1.8 time = 1730
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=1730.05n

* CHECK dout0_29 Vdout0_29ck172 = 0 time = 1730
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=1730.05n

* CHECK dout0_30 Vdout0_30ck172 = 0 time = 1730
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=1730.05n

* CHECK dout0_31 Vdout0_31ck172 = 1.8 time = 1730
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=1730.05n

* CHECK dout0_32 Vdout0_32ck172 = 0 time = 1730
.meas tran vdout0_32ck172 FIND v(dout0_32) AT=1730.05n

* CHECK dout0_0 Vdout0_0ck173 = 1.8 time = 1740
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=1740.05n

* CHECK dout0_1 Vdout0_1ck173 = 1.8 time = 1740
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=1740.05n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 1740
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=1740.05n

* CHECK dout0_3 Vdout0_3ck173 = 1.8 time = 1740
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=1740.05n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 1740
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=1740.05n

* CHECK dout0_5 Vdout0_5ck173 = 1.8 time = 1740
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=1740.05n

* CHECK dout0_6 Vdout0_6ck173 = 1.8 time = 1740
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=1740.05n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 1740
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=1740.05n

* CHECK dout0_8 Vdout0_8ck173 = 0 time = 1740
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=1740.05n

* CHECK dout0_9 Vdout0_9ck173 = 1.8 time = 1740
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=1740.05n

* CHECK dout0_10 Vdout0_10ck173 = 1.8 time = 1740
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=1740.05n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 1740
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=1740.05n

* CHECK dout0_12 Vdout0_12ck173 = 1.8 time = 1740
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=1740.05n

* CHECK dout0_13 Vdout0_13ck173 = 1.8 time = 1740
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=1740.05n

* CHECK dout0_14 Vdout0_14ck173 = 0 time = 1740
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=1740.05n

* CHECK dout0_15 Vdout0_15ck173 = 1.8 time = 1740
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=1740.05n

* CHECK dout0_16 Vdout0_16ck173 = 1.8 time = 1740
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=1740.05n

* CHECK dout0_17 Vdout0_17ck173 = 1.8 time = 1740
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=1740.05n

* CHECK dout0_18 Vdout0_18ck173 = 1.8 time = 1740
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=1740.05n

* CHECK dout0_19 Vdout0_19ck173 = 0 time = 1740
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=1740.05n

* CHECK dout0_20 Vdout0_20ck173 = 0 time = 1740
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=1740.05n

* CHECK dout0_21 Vdout0_21ck173 = 1.8 time = 1740
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=1740.05n

* CHECK dout0_22 Vdout0_22ck173 = 1.8 time = 1740
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=1740.05n

* CHECK dout0_23 Vdout0_23ck173 = 0 time = 1740
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=1740.05n

* CHECK dout0_24 Vdout0_24ck173 = 0 time = 1740
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=1740.05n

* CHECK dout0_25 Vdout0_25ck173 = 0 time = 1740
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=1740.05n

* CHECK dout0_26 Vdout0_26ck173 = 1.8 time = 1740
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=1740.05n

* CHECK dout0_27 Vdout0_27ck173 = 1.8 time = 1740
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=1740.05n

* CHECK dout0_28 Vdout0_28ck173 = 0 time = 1740
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=1740.05n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 1740
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=1740.05n

* CHECK dout0_30 Vdout0_30ck173 = 0 time = 1740
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=1740.05n

* CHECK dout0_31 Vdout0_31ck173 = 0 time = 1740
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=1740.05n

* CHECK dout0_32 Vdout0_32ck173 = 0 time = 1740
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=1740.05n

* CHECK dout0_0 Vdout0_0ck175 = 1.8 time = 1760
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=1760.05n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 1760
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=1760.05n

* CHECK dout0_2 Vdout0_2ck175 = 1.8 time = 1760
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=1760.05n

* CHECK dout0_3 Vdout0_3ck175 = 0 time = 1760
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=1760.05n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 1760
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=1760.05n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 1760
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=1760.05n

* CHECK dout0_6 Vdout0_6ck175 = 1.8 time = 1760
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=1760.05n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 1760
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=1760.05n

* CHECK dout0_8 Vdout0_8ck175 = 1.8 time = 1760
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=1760.05n

* CHECK dout0_9 Vdout0_9ck175 = 1.8 time = 1760
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=1760.05n

* CHECK dout0_10 Vdout0_10ck175 = 0 time = 1760
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=1760.05n

* CHECK dout0_11 Vdout0_11ck175 = 0 time = 1760
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=1760.05n

* CHECK dout0_12 Vdout0_12ck175 = 0 time = 1760
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=1760.05n

* CHECK dout0_13 Vdout0_13ck175 = 0 time = 1760
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=1760.05n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 1760
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=1760.05n

* CHECK dout0_15 Vdout0_15ck175 = 1.8 time = 1760
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=1760.05n

* CHECK dout0_16 Vdout0_16ck175 = 0 time = 1760
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=1760.05n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 1760
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=1760.05n

* CHECK dout0_18 Vdout0_18ck175 = 1.8 time = 1760
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=1760.05n

* CHECK dout0_19 Vdout0_19ck175 = 1.8 time = 1760
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=1760.05n

* CHECK dout0_20 Vdout0_20ck175 = 1.8 time = 1760
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=1760.05n

* CHECK dout0_21 Vdout0_21ck175 = 0 time = 1760
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=1760.05n

* CHECK dout0_22 Vdout0_22ck175 = 0 time = 1760
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=1760.05n

* CHECK dout0_23 Vdout0_23ck175 = 1.8 time = 1760
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=1760.05n

* CHECK dout0_24 Vdout0_24ck175 = 1.8 time = 1760
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=1760.05n

* CHECK dout0_25 Vdout0_25ck175 = 1.8 time = 1760
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=1760.05n

* CHECK dout0_26 Vdout0_26ck175 = 1.8 time = 1760
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=1760.05n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 1760
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=1760.05n

* CHECK dout0_28 Vdout0_28ck175 = 0 time = 1760
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=1760.05n

* CHECK dout0_29 Vdout0_29ck175 = 1.8 time = 1760
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=1760.05n

* CHECK dout0_30 Vdout0_30ck175 = 0 time = 1760
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=1760.05n

* CHECK dout0_31 Vdout0_31ck175 = 1.8 time = 1760
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=1760.05n

* CHECK dout0_32 Vdout0_32ck175 = 0 time = 1760
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=1760.05n

* CHECK dout0_0 Vdout0_0ck179 = 1.8 time = 1800
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=1800.05n

* CHECK dout0_1 Vdout0_1ck179 = 1.8 time = 1800
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=1800.05n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 1800
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=1800.05n

* CHECK dout0_3 Vdout0_3ck179 = 1.8 time = 1800
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=1800.05n

* CHECK dout0_4 Vdout0_4ck179 = 1.8 time = 1800
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=1800.05n

* CHECK dout0_5 Vdout0_5ck179 = 1.8 time = 1800
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=1800.05n

* CHECK dout0_6 Vdout0_6ck179 = 1.8 time = 1800
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=1800.05n

* CHECK dout0_7 Vdout0_7ck179 = 1.8 time = 1800
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=1800.05n

* CHECK dout0_8 Vdout0_8ck179 = 1.8 time = 1800
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=1800.05n

* CHECK dout0_9 Vdout0_9ck179 = 1.8 time = 1800
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=1800.05n

* CHECK dout0_10 Vdout0_10ck179 = 1.8 time = 1800
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=1800.05n

* CHECK dout0_11 Vdout0_11ck179 = 0 time = 1800
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=1800.05n

* CHECK dout0_12 Vdout0_12ck179 = 0 time = 1800
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=1800.05n

* CHECK dout0_13 Vdout0_13ck179 = 1.8 time = 1800
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=1800.05n

* CHECK dout0_14 Vdout0_14ck179 = 0 time = 1800
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=1800.05n

* CHECK dout0_15 Vdout0_15ck179 = 0 time = 1800
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=1800.05n

* CHECK dout0_16 Vdout0_16ck179 = 1.8 time = 1800
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=1800.05n

* CHECK dout0_17 Vdout0_17ck179 = 0 time = 1800
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=1800.05n

* CHECK dout0_18 Vdout0_18ck179 = 1.8 time = 1800
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=1800.05n

* CHECK dout0_19 Vdout0_19ck179 = 1.8 time = 1800
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=1800.05n

* CHECK dout0_20 Vdout0_20ck179 = 1.8 time = 1800
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=1800.05n

* CHECK dout0_21 Vdout0_21ck179 = 0 time = 1800
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=1800.05n

* CHECK dout0_22 Vdout0_22ck179 = 1.8 time = 1800
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=1800.05n

* CHECK dout0_23 Vdout0_23ck179 = 1.8 time = 1800
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=1800.05n

* CHECK dout0_24 Vdout0_24ck179 = 0 time = 1800
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=1800.05n

* CHECK dout0_25 Vdout0_25ck179 = 0 time = 1800
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=1800.05n

* CHECK dout0_26 Vdout0_26ck179 = 1.8 time = 1800
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=1800.05n

* CHECK dout0_27 Vdout0_27ck179 = 1.8 time = 1800
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=1800.05n

* CHECK dout0_28 Vdout0_28ck179 = 1.8 time = 1800
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=1800.05n

* CHECK dout0_29 Vdout0_29ck179 = 0 time = 1800
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=1800.05n

* CHECK dout0_30 Vdout0_30ck179 = 0 time = 1800
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=1800.05n

* CHECK dout0_31 Vdout0_31ck179 = 1.8 time = 1800
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=1800.05n

* CHECK dout0_32 Vdout0_32ck179 = 0 time = 1800
.meas tran vdout0_32ck179 FIND v(dout0_32) AT=1800.05n

* CHECK dout0_0 Vdout0_0ck189 = 0 time = 1900
.meas tran vdout0_0ck189 FIND v(dout0_0) AT=1900.05n

* CHECK dout0_1 Vdout0_1ck189 = 0 time = 1900
.meas tran vdout0_1ck189 FIND v(dout0_1) AT=1900.05n

* CHECK dout0_2 Vdout0_2ck189 = 0 time = 1900
.meas tran vdout0_2ck189 FIND v(dout0_2) AT=1900.05n

* CHECK dout0_3 Vdout0_3ck189 = 1.8 time = 1900
.meas tran vdout0_3ck189 FIND v(dout0_3) AT=1900.05n

* CHECK dout0_4 Vdout0_4ck189 = 0 time = 1900
.meas tran vdout0_4ck189 FIND v(dout0_4) AT=1900.05n

* CHECK dout0_5 Vdout0_5ck189 = 1.8 time = 1900
.meas tran vdout0_5ck189 FIND v(dout0_5) AT=1900.05n

* CHECK dout0_6 Vdout0_6ck189 = 1.8 time = 1900
.meas tran vdout0_6ck189 FIND v(dout0_6) AT=1900.05n

* CHECK dout0_7 Vdout0_7ck189 = 1.8 time = 1900
.meas tran vdout0_7ck189 FIND v(dout0_7) AT=1900.05n

* CHECK dout0_8 Vdout0_8ck189 = 0 time = 1900
.meas tran vdout0_8ck189 FIND v(dout0_8) AT=1900.05n

* CHECK dout0_9 Vdout0_9ck189 = 0 time = 1900
.meas tran vdout0_9ck189 FIND v(dout0_9) AT=1900.05n

* CHECK dout0_10 Vdout0_10ck189 = 0 time = 1900
.meas tran vdout0_10ck189 FIND v(dout0_10) AT=1900.05n

* CHECK dout0_11 Vdout0_11ck189 = 1.8 time = 1900
.meas tran vdout0_11ck189 FIND v(dout0_11) AT=1900.05n

* CHECK dout0_12 Vdout0_12ck189 = 0 time = 1900
.meas tran vdout0_12ck189 FIND v(dout0_12) AT=1900.05n

* CHECK dout0_13 Vdout0_13ck189 = 1.8 time = 1900
.meas tran vdout0_13ck189 FIND v(dout0_13) AT=1900.05n

* CHECK dout0_14 Vdout0_14ck189 = 1.8 time = 1900
.meas tran vdout0_14ck189 FIND v(dout0_14) AT=1900.05n

* CHECK dout0_15 Vdout0_15ck189 = 0 time = 1900
.meas tran vdout0_15ck189 FIND v(dout0_15) AT=1900.05n

* CHECK dout0_16 Vdout0_16ck189 = 0 time = 1900
.meas tran vdout0_16ck189 FIND v(dout0_16) AT=1900.05n

* CHECK dout0_17 Vdout0_17ck189 = 1.8 time = 1900
.meas tran vdout0_17ck189 FIND v(dout0_17) AT=1900.05n

* CHECK dout0_18 Vdout0_18ck189 = 0 time = 1900
.meas tran vdout0_18ck189 FIND v(dout0_18) AT=1900.05n

* CHECK dout0_19 Vdout0_19ck189 = 0 time = 1900
.meas tran vdout0_19ck189 FIND v(dout0_19) AT=1900.05n

* CHECK dout0_20 Vdout0_20ck189 = 1.8 time = 1900
.meas tran vdout0_20ck189 FIND v(dout0_20) AT=1900.05n

* CHECK dout0_21 Vdout0_21ck189 = 1.8 time = 1900
.meas tran vdout0_21ck189 FIND v(dout0_21) AT=1900.05n

* CHECK dout0_22 Vdout0_22ck189 = 0 time = 1900
.meas tran vdout0_22ck189 FIND v(dout0_22) AT=1900.05n

* CHECK dout0_23 Vdout0_23ck189 = 0 time = 1900
.meas tran vdout0_23ck189 FIND v(dout0_23) AT=1900.05n

* CHECK dout0_24 Vdout0_24ck189 = 0 time = 1900
.meas tran vdout0_24ck189 FIND v(dout0_24) AT=1900.05n

* CHECK dout0_25 Vdout0_25ck189 = 1.8 time = 1900
.meas tran vdout0_25ck189 FIND v(dout0_25) AT=1900.05n

* CHECK dout0_26 Vdout0_26ck189 = 1.8 time = 1900
.meas tran vdout0_26ck189 FIND v(dout0_26) AT=1900.05n

* CHECK dout0_27 Vdout0_27ck189 = 0 time = 1900
.meas tran vdout0_27ck189 FIND v(dout0_27) AT=1900.05n

* CHECK dout0_28 Vdout0_28ck189 = 0 time = 1900
.meas tran vdout0_28ck189 FIND v(dout0_28) AT=1900.05n

* CHECK dout0_29 Vdout0_29ck189 = 1.8 time = 1900
.meas tran vdout0_29ck189 FIND v(dout0_29) AT=1900.05n

* CHECK dout0_30 Vdout0_30ck189 = 1.8 time = 1900
.meas tran vdout0_30ck189 FIND v(dout0_30) AT=1900.05n

* CHECK dout0_31 Vdout0_31ck189 = 0 time = 1900
.meas tran vdout0_31ck189 FIND v(dout0_31) AT=1900.05n

* CHECK dout0_32 Vdout0_32ck189 = 0 time = 1900
.meas tran vdout0_32ck189 FIND v(dout0_32) AT=1900.05n

* CHECK dout0_0 Vdout0_0ck191 = 0 time = 1920
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=1920.05n

* CHECK dout0_1 Vdout0_1ck191 = 1.8 time = 1920
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=1920.05n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 1920
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=1920.05n

* CHECK dout0_3 Vdout0_3ck191 = 0 time = 1920
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=1920.05n

* CHECK dout0_4 Vdout0_4ck191 = 1.8 time = 1920
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=1920.05n

* CHECK dout0_5 Vdout0_5ck191 = 1.8 time = 1920
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=1920.05n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 1920
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=1920.05n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 1920
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=1920.05n

* CHECK dout0_8 Vdout0_8ck191 = 0 time = 1920
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=1920.05n

* CHECK dout0_9 Vdout0_9ck191 = 0 time = 1920
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=1920.05n

* CHECK dout0_10 Vdout0_10ck191 = 0 time = 1920
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=1920.05n

* CHECK dout0_11 Vdout0_11ck191 = 1.8 time = 1920
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=1920.05n

* CHECK dout0_12 Vdout0_12ck191 = 0 time = 1920
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=1920.05n

* CHECK dout0_13 Vdout0_13ck191 = 1.8 time = 1920
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=1920.05n

* CHECK dout0_14 Vdout0_14ck191 = 0 time = 1920
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=1920.05n

* CHECK dout0_15 Vdout0_15ck191 = 0 time = 1920
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=1920.05n

* CHECK dout0_16 Vdout0_16ck191 = 0 time = 1920
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=1920.05n

* CHECK dout0_17 Vdout0_17ck191 = 1.8 time = 1920
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=1920.05n

* CHECK dout0_18 Vdout0_18ck191 = 1.8 time = 1920
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=1920.05n

* CHECK dout0_19 Vdout0_19ck191 = 1.8 time = 1920
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=1920.05n

* CHECK dout0_20 Vdout0_20ck191 = 1.8 time = 1920
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=1920.05n

* CHECK dout0_21 Vdout0_21ck191 = 1.8 time = 1920
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=1920.05n

* CHECK dout0_22 Vdout0_22ck191 = 0 time = 1920
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=1920.05n

* CHECK dout0_23 Vdout0_23ck191 = 1.8 time = 1920
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=1920.05n

* CHECK dout0_24 Vdout0_24ck191 = 0 time = 1920
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=1920.05n

* CHECK dout0_25 Vdout0_25ck191 = 0 time = 1920
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=1920.05n

* CHECK dout0_26 Vdout0_26ck191 = 1.8 time = 1920
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=1920.05n

* CHECK dout0_27 Vdout0_27ck191 = 0 time = 1920
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=1920.05n

* CHECK dout0_28 Vdout0_28ck191 = 1.8 time = 1920
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=1920.05n

* CHECK dout0_29 Vdout0_29ck191 = 1.8 time = 1920
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=1920.05n

* CHECK dout0_30 Vdout0_30ck191 = 1.8 time = 1920
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=1920.05n

* CHECK dout0_31 Vdout0_31ck191 = 0 time = 1920
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=1920.05n

* CHECK dout0_32 Vdout0_32ck191 = 0 time = 1920
.meas tran vdout0_32ck191 FIND v(dout0_32) AT=1920.05n

* CHECK dout0_0 Vdout0_0ck193 = 1.8 time = 1940
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=1940.05n

* CHECK dout0_1 Vdout0_1ck193 = 1.8 time = 1940
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=1940.05n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 1940
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=1940.05n

* CHECK dout0_3 Vdout0_3ck193 = 1.8 time = 1940
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=1940.05n

* CHECK dout0_4 Vdout0_4ck193 = 0 time = 1940
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=1940.05n

* CHECK dout0_5 Vdout0_5ck193 = 1.8 time = 1940
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=1940.05n

* CHECK dout0_6 Vdout0_6ck193 = 1.8 time = 1940
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=1940.05n

* CHECK dout0_7 Vdout0_7ck193 = 1.8 time = 1940
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=1940.05n

* CHECK dout0_8 Vdout0_8ck193 = 0 time = 1940
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=1940.05n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 1940
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=1940.05n

* CHECK dout0_10 Vdout0_10ck193 = 1.8 time = 1940
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=1940.05n

* CHECK dout0_11 Vdout0_11ck193 = 0 time = 1940
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=1940.05n

* CHECK dout0_12 Vdout0_12ck193 = 1.8 time = 1940
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=1940.05n

* CHECK dout0_13 Vdout0_13ck193 = 1.8 time = 1940
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=1940.05n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 1940
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=1940.05n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 1940
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=1940.05n

* CHECK dout0_16 Vdout0_16ck193 = 1.8 time = 1940
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=1940.05n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 1940
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=1940.05n

* CHECK dout0_18 Vdout0_18ck193 = 1.8 time = 1940
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=1940.05n

* CHECK dout0_19 Vdout0_19ck193 = 0 time = 1940
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=1940.05n

* CHECK dout0_20 Vdout0_20ck193 = 1.8 time = 1940
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=1940.05n

* CHECK dout0_21 Vdout0_21ck193 = 1.8 time = 1940
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=1940.05n

* CHECK dout0_22 Vdout0_22ck193 = 0 time = 1940
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=1940.05n

* CHECK dout0_23 Vdout0_23ck193 = 1.8 time = 1940
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=1940.05n

* CHECK dout0_24 Vdout0_24ck193 = 1.8 time = 1940
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=1940.05n

* CHECK dout0_25 Vdout0_25ck193 = 1.8 time = 1940
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=1940.05n

* CHECK dout0_26 Vdout0_26ck193 = 1.8 time = 1940
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=1940.05n

* CHECK dout0_27 Vdout0_27ck193 = 0 time = 1940
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=1940.05n

* CHECK dout0_28 Vdout0_28ck193 = 0 time = 1940
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=1940.05n

* CHECK dout0_29 Vdout0_29ck193 = 0 time = 1940
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=1940.05n

* CHECK dout0_30 Vdout0_30ck193 = 0 time = 1940
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=1940.05n

* CHECK dout0_31 Vdout0_31ck193 = 1.8 time = 1940
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=1940.05n

* CHECK dout0_32 Vdout0_32ck193 = 0 time = 1940
.meas tran vdout0_32ck193 FIND v(dout0_32) AT=1940.05n

* CHECK dout0_0 Vdout0_0ck194 = 0 time = 1950
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=1950.05n

* CHECK dout0_1 Vdout0_1ck194 = 1.8 time = 1950
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=1950.05n

* CHECK dout0_2 Vdout0_2ck194 = 0 time = 1950
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=1950.05n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 1950
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=1950.05n

* CHECK dout0_4 Vdout0_4ck194 = 1.8 time = 1950
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=1950.05n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 1950
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=1950.05n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 1950
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=1950.05n

* CHECK dout0_7 Vdout0_7ck194 = 1.8 time = 1950
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=1950.05n

* CHECK dout0_8 Vdout0_8ck194 = 0 time = 1950
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=1950.05n

* CHECK dout0_9 Vdout0_9ck194 = 0 time = 1950
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=1950.05n

* CHECK dout0_10 Vdout0_10ck194 = 0 time = 1950
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=1950.05n

* CHECK dout0_11 Vdout0_11ck194 = 1.8 time = 1950
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=1950.05n

* CHECK dout0_12 Vdout0_12ck194 = 0 time = 1950
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=1950.05n

* CHECK dout0_13 Vdout0_13ck194 = 1.8 time = 1950
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=1950.05n

* CHECK dout0_14 Vdout0_14ck194 = 0 time = 1950
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=1950.05n

* CHECK dout0_15 Vdout0_15ck194 = 0 time = 1950
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=1950.05n

* CHECK dout0_16 Vdout0_16ck194 = 0 time = 1950
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=1950.05n

* CHECK dout0_17 Vdout0_17ck194 = 1.8 time = 1950
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=1950.05n

* CHECK dout0_18 Vdout0_18ck194 = 1.8 time = 1950
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=1950.05n

* CHECK dout0_19 Vdout0_19ck194 = 1.8 time = 1950
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=1950.05n

* CHECK dout0_20 Vdout0_20ck194 = 1.8 time = 1950
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=1950.05n

* CHECK dout0_21 Vdout0_21ck194 = 1.8 time = 1950
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=1950.05n

* CHECK dout0_22 Vdout0_22ck194 = 0 time = 1950
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=1950.05n

* CHECK dout0_23 Vdout0_23ck194 = 1.8 time = 1950
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=1950.05n

* CHECK dout0_24 Vdout0_24ck194 = 0 time = 1950
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=1950.05n

* CHECK dout0_25 Vdout0_25ck194 = 0 time = 1950
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=1950.05n

* CHECK dout0_26 Vdout0_26ck194 = 1.8 time = 1950
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=1950.05n

* CHECK dout0_27 Vdout0_27ck194 = 0 time = 1950
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=1950.05n

* CHECK dout0_28 Vdout0_28ck194 = 1.8 time = 1950
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=1950.05n

* CHECK dout0_29 Vdout0_29ck194 = 1.8 time = 1950
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=1950.05n

* CHECK dout0_30 Vdout0_30ck194 = 1.8 time = 1950
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=1950.05n

* CHECK dout0_31 Vdout0_31ck194 = 0 time = 1950
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=1950.05n

* CHECK dout0_32 Vdout0_32ck194 = 0 time = 1950
.meas tran vdout0_32ck194 FIND v(dout0_32) AT=1950.05n

* CHECK dout0_0 Vdout0_0ck195 = 1.8 time = 1960
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=1960.05n

* CHECK dout0_1 Vdout0_1ck195 = 1.8 time = 1960
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=1960.05n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 1960
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=1960.05n

* CHECK dout0_3 Vdout0_3ck195 = 0 time = 1960
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=1960.05n

* CHECK dout0_4 Vdout0_4ck195 = 0 time = 1960
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=1960.05n

* CHECK dout0_5 Vdout0_5ck195 = 1.8 time = 1960
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=1960.05n

* CHECK dout0_6 Vdout0_6ck195 = 0 time = 1960
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=1960.05n

* CHECK dout0_7 Vdout0_7ck195 = 0 time = 1960
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=1960.05n

* CHECK dout0_8 Vdout0_8ck195 = 1.8 time = 1960
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=1960.05n

* CHECK dout0_9 Vdout0_9ck195 = 0 time = 1960
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=1960.05n

* CHECK dout0_10 Vdout0_10ck195 = 0 time = 1960
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=1960.05n

* CHECK dout0_11 Vdout0_11ck195 = 0 time = 1960
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=1960.05n

* CHECK dout0_12 Vdout0_12ck195 = 1.8 time = 1960
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=1960.05n

* CHECK dout0_13 Vdout0_13ck195 = 0 time = 1960
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=1960.05n

* CHECK dout0_14 Vdout0_14ck195 = 0 time = 1960
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=1960.05n

* CHECK dout0_15 Vdout0_15ck195 = 0 time = 1960
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=1960.05n

* CHECK dout0_16 Vdout0_16ck195 = 1.8 time = 1960
.meas tran vdout0_16ck195 FIND v(dout0_16) AT=1960.05n

* CHECK dout0_17 Vdout0_17ck195 = 1.8 time = 1960
.meas tran vdout0_17ck195 FIND v(dout0_17) AT=1960.05n

* CHECK dout0_18 Vdout0_18ck195 = 1.8 time = 1960
.meas tran vdout0_18ck195 FIND v(dout0_18) AT=1960.05n

* CHECK dout0_19 Vdout0_19ck195 = 1.8 time = 1960
.meas tran vdout0_19ck195 FIND v(dout0_19) AT=1960.05n

* CHECK dout0_20 Vdout0_20ck195 = 0 time = 1960
.meas tran vdout0_20ck195 FIND v(dout0_20) AT=1960.05n

* CHECK dout0_21 Vdout0_21ck195 = 1.8 time = 1960
.meas tran vdout0_21ck195 FIND v(dout0_21) AT=1960.05n

* CHECK dout0_22 Vdout0_22ck195 = 0 time = 1960
.meas tran vdout0_22ck195 FIND v(dout0_22) AT=1960.05n

* CHECK dout0_23 Vdout0_23ck195 = 0 time = 1960
.meas tran vdout0_23ck195 FIND v(dout0_23) AT=1960.05n

* CHECK dout0_24 Vdout0_24ck195 = 1.8 time = 1960
.meas tran vdout0_24ck195 FIND v(dout0_24) AT=1960.05n

* CHECK dout0_25 Vdout0_25ck195 = 0 time = 1960
.meas tran vdout0_25ck195 FIND v(dout0_25) AT=1960.05n

* CHECK dout0_26 Vdout0_26ck195 = 1.8 time = 1960
.meas tran vdout0_26ck195 FIND v(dout0_26) AT=1960.05n

* CHECK dout0_27 Vdout0_27ck195 = 0 time = 1960
.meas tran vdout0_27ck195 FIND v(dout0_27) AT=1960.05n

* CHECK dout0_28 Vdout0_28ck195 = 1.8 time = 1960
.meas tran vdout0_28ck195 FIND v(dout0_28) AT=1960.05n

* CHECK dout0_29 Vdout0_29ck195 = 0 time = 1960
.meas tran vdout0_29ck195 FIND v(dout0_29) AT=1960.05n

* CHECK dout0_30 Vdout0_30ck195 = 1.8 time = 1960
.meas tran vdout0_30ck195 FIND v(dout0_30) AT=1960.05n

* CHECK dout0_31 Vdout0_31ck195 = 0 time = 1960
.meas tran vdout0_31ck195 FIND v(dout0_31) AT=1960.05n

* CHECK dout0_32 Vdout0_32ck195 = 0 time = 1960
.meas tran vdout0_32ck195 FIND v(dout0_32) AT=1960.05n

* CHECK dout0_0 Vdout0_0ck203 = 0 time = 2040
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=2040.05n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 2040
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=2040.05n

* CHECK dout0_2 Vdout0_2ck203 = 1.8 time = 2040
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=2040.05n

* CHECK dout0_3 Vdout0_3ck203 = 0 time = 2040
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=2040.05n

* CHECK dout0_4 Vdout0_4ck203 = 1.8 time = 2040
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=2040.05n

* CHECK dout0_5 Vdout0_5ck203 = 0 time = 2040
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=2040.05n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 2040
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=2040.05n

* CHECK dout0_7 Vdout0_7ck203 = 1.8 time = 2040
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=2040.05n

* CHECK dout0_8 Vdout0_8ck203 = 0 time = 2040
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=2040.05n

* CHECK dout0_9 Vdout0_9ck203 = 1.8 time = 2040
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=2040.05n

* CHECK dout0_10 Vdout0_10ck203 = 0 time = 2040
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=2040.05n

* CHECK dout0_11 Vdout0_11ck203 = 1.8 time = 2040
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=2040.05n

* CHECK dout0_12 Vdout0_12ck203 = 1.8 time = 2040
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=2040.05n

* CHECK dout0_13 Vdout0_13ck203 = 1.8 time = 2040
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=2040.05n

* CHECK dout0_14 Vdout0_14ck203 = 0 time = 2040
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=2040.05n

* CHECK dout0_15 Vdout0_15ck203 = 0 time = 2040
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=2040.05n

* CHECK dout0_16 Vdout0_16ck203 = 1.8 time = 2040
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=2040.05n

* CHECK dout0_17 Vdout0_17ck203 = 1.8 time = 2040
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=2040.05n

* CHECK dout0_18 Vdout0_18ck203 = 1.8 time = 2040
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=2040.05n

* CHECK dout0_19 Vdout0_19ck203 = 1.8 time = 2040
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=2040.05n

* CHECK dout0_20 Vdout0_20ck203 = 1.8 time = 2040
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=2040.05n

* CHECK dout0_21 Vdout0_21ck203 = 1.8 time = 2040
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=2040.05n

* CHECK dout0_22 Vdout0_22ck203 = 0 time = 2040
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=2040.05n

* CHECK dout0_23 Vdout0_23ck203 = 1.8 time = 2040
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=2040.05n

* CHECK dout0_24 Vdout0_24ck203 = 1.8 time = 2040
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=2040.05n

* CHECK dout0_25 Vdout0_25ck203 = 1.8 time = 2040
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=2040.05n

* CHECK dout0_26 Vdout0_26ck203 = 1.8 time = 2040
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=2040.05n

* CHECK dout0_27 Vdout0_27ck203 = 0 time = 2040
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=2040.05n

* CHECK dout0_28 Vdout0_28ck203 = 0 time = 2040
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=2040.05n

* CHECK dout0_29 Vdout0_29ck203 = 1.8 time = 2040
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=2040.05n

* CHECK dout0_30 Vdout0_30ck203 = 1.8 time = 2040
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=2040.05n

* CHECK dout0_31 Vdout0_31ck203 = 1.8 time = 2040
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=2040.05n

* CHECK dout0_32 Vdout0_32ck203 = 0 time = 2040
.meas tran vdout0_32ck203 FIND v(dout0_32) AT=2040.05n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
