* Functional test stimulus file for 10ns period

* TT process corner
.lib "/home/software/PDKs/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "sky130_sram_4kbyte_1rw_64x512_8.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsky130_sram_4kbyte_1rw_64x512_8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 a0_9 CSB0 WEB0 clk0 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 WMASK0_4 WMASK0_5 WMASK0_6 WMASK0_7 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 dout0_33 dout0_34 dout0_35 dout0_36 dout0_37 dout0_38 dout0_39 dout0_40 dout0_41 dout0_42 dout0_43 dout0_44 dout0_45 dout0_46 dout0_47 dout0_48 dout0_49 dout0_50 dout0_51 dout0_52 dout0_53 dout0_54 dout0_55 dout0_56 dout0_57 dout0_58 dout0_59 dout0_60 dout0_61 dout0_62 dout0_63 dout0_64 vdd gnd sky130_sram_4kbyte_1rw_64x512_8

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f
CD033 dout0_33  0 27.56f
CD034 dout0_34  0 27.56f
CD035 dout0_35  0 27.56f
CD036 dout0_36  0 27.56f
CD037 dout0_37  0 27.56f
CD038 dout0_38  0 27.56f
CD039 dout0_39  0 27.56f
CD040 dout0_40  0 27.56f
CD041 dout0_41  0 27.56f
CD042 dout0_42  0 27.56f
CD043 dout0_43  0 27.56f
CD044 dout0_44  0 27.56f
CD045 dout0_45  0 27.56f
CD046 dout0_46  0 27.56f
CD047 dout0_47  0 27.56f
CD048 dout0_48  0 27.56f
CD049 dout0_49  0 27.56f
CD050 dout0_50  0 27.56f
CD051 dout0_51  0 27.56f
CD052 dout0_52  0 27.56f
CD053 dout0_53  0 27.56f
CD054 dout0_54  0 27.56f
CD055 dout0_55  0 27.56f
CD056 dout0_56  0 27.56f
CD057 dout0_57  0 27.56f
CD058 dout0_58  0 27.56f
CD059 dout0_59  0 27.56f
CD060 dout0_60  0 27.56f
CD061 dout0_61  0 27.56f
CD062 dout0_62  0 27.56f
CD063 dout0_63  0 27.56f
CD064 dout0_64  0 27.56f

* Important signals for debug
* bl:	xsky130_sram_4kbyte_1rw_64x512_8.xbank0.bl_0_0
* br:	xsky130_sram_4kbyte_1rw_64x512_8.xbank0.br_0_0
* s_en:	xsky130_sram_4kbyte_1rw_64x512_8.s_en
* q:	xsky130_sram_4kbyte_1rw_64x512_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q
* qbar:	xsky130_sram_4kbyte_1rw_64x512_8.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+1110010101010111111010110011101111100100010100101101000010100001  to  address 1000000010 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+1100101110001001100111010110111000100110001110001110100010101100  to  address 0000000001 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+1010111110110000110110111001001110011001100000000001111100111100  to  address 0000000011 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+1110010101010111111010110011101111100100010100101101000010100001 from address 1000000010 (from port 0) during cycle 4 (40ns - 50ns)
*	Writing 0+1001100110101011100001110100010110001000011011110101011101101111  to  address 0000000001 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 0+1110010101010111111010110011101111100100010100101101000010100001 from address 1000000010 (from port 0) during cycle 6 (60ns - 70ns)
*	Writing (partial) 0+0101111101110101101111000111100100010110111001110010011010101011  to  address 0000000001 with mask bit 00000111 (from port 0) during cycle 7 (70ns - 80ns)
*	Reading 0+1001100110101011100001110100010110001000111001110010011010101011 from address 0000000001 (from port 0) during cycle 8 (80ns - 90ns)
*	Writing 0+0011110100000010100010101010010000001111100100011101011101101011  to  address 0000000001 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 0+0011110100000010100010101010010000001111100100011101011101101011 from address 0000000001 (from port 0) during cycle 11 (110ns - 120ns)
*	Reading 0+1110010101010111111010110011101111100100010100101101000010100001 from address 1000000010 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 0+0101010011101100101111000111111111110101110011100100111001110001  to  address 0000000010 (from port 0) during cycle 13 (130ns - 140ns)
*	Writing (partial) 0+1111001011110001111110010000110011010100001011001001001101101101  to  address 0000000001 with mask bit 10001001 (from port 0) during cycle 15 (150ns - 160ns)
*	Writing 0+1101001010000000000100011111011001100111101110111000110001101110  to  address 1000000001 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 0+1010111110110000110110111001001110011001100000000001111100111100 from address 0000000011 (from port 0) during cycle 17 (170ns - 180ns)
*	Writing 0+0001000111110100010110000100001100011000000001100010001001110101  to  address 0000000010 (from port 0) during cycle 18 (180ns - 190ns)
*	Reading 0+1010111110110000110110111001001110011001100000000001111100111100 from address 0000000011 (from port 0) during cycle 19 (190ns - 200ns)
*	Reading 0+1110010101010111111010110011101111100100010100101101000010100001 from address 1000000010 (from port 0) during cycle 20 (200ns - 210ns)
*	Writing 0+0011010110110100010011110000000100010100000011000010011111110101  to  address 0000000000 (from port 0) during cycle 22 (220ns - 230ns)
*	Reading 0+1111001000000010100010101010010011010100100100011101011101101101 from address 0000000001 (from port 0) during cycle 23 (230ns - 240ns)
*	Writing (partial) 0+1001001011010001100011000000101010110101111010111000001110000100  to  address 0000000001 with mask bit 11000011 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 0+1010111110110000110110111001001110011001100000000001111100111100 from address 0000000011 (from port 0) during cycle 25 (250ns - 260ns)
*	Reading 0+0001000111110100010110000100001100011000000001100010001001110101 from address 0000000010 (from port 0) during cycle 26 (260ns - 270ns)
*	Reading 0+1001001011010001100010101010010011010100100100011000001110000100 from address 0000000001 (from port 0) during cycle 27 (270ns - 280ns)
*	Writing 0+0110000000110010100000001101100110100001110111110001110001010101  to  address 1000000001 (from port 0) during cycle 30 (300ns - 310ns)
*	Reading 0+1110010101010111111010110011101111100100010100101101000010100001 from address 1000000010 (from port 0) during cycle 32 (320ns - 330ns)
*	Writing 0+1101111001011110111101000110011001010011010101111010001001100100  to  address 0111111111 (from port 0) during cycle 33 (330ns - 340ns)
*	Writing 0+1101011001010100000101000110110100101101101110100001111111110010  to  address 1000000000 (from port 0) during cycle 37 (370ns - 380ns)
*	Reading 0+0110000000110010100000001101100110100001110111110001110001010101 from address 1000000001 (from port 0) during cycle 38 (380ns - 390ns)
*	Writing (partial) 0+0110100010010101000011000011100000000101110101110011001110111101  to  address 0111111111 with mask bit 10000000 (from port 0) during cycle 39 (390ns - 400ns)
*	Writing (partial) 0+1010000010000110110010101011111010011000011111010110010110111000  to  address 1000000010 with mask bit 01000101 (from port 0) during cycle 40 (400ns - 410ns)
*	Writing 0+0100011001111011001111010011000110010111010100100001101111010010  to  address 0000000001 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 0+1101011001010100000101000110110100101101101110100001111111110010 from address 1000000000 (from port 0) during cycle 42 (420ns - 430ns)
*	Writing (partial) 0+0011100000100011100111000010011111100011010100011110000011000101  to  address 1000000010 with mask bit 10111110 (from port 0) during cycle 43 (430ns - 440ns)
*	Writing (partial) 0+0001000010101011111100110000010111000101001001001101000000100001  to  address 0000000000 with mask bit 11010101 (from port 0) during cycle 45 (450ns - 460ns)
*	Writing 0+1110110111101010110000100100010101100010110011011000100100000101  to  address 0000000011 (from port 0) during cycle 46 (460ns - 470ns)
*	Reading 0+0100011001111011001111010011000110010111010100100001101111010010 from address 0000000001 (from port 0) during cycle 47 (470ns - 480ns)
*	Reading 0+0001000010101011010011110000010100010100001001000010011100100001 from address 0000000000 (from port 0) during cycle 48 (480ns - 490ns)
*	Reading 0+0100011001111011001111010011000110010111010100100001101111010010 from address 0000000001 (from port 0) during cycle 49 (490ns - 500ns)
*	Reading 0+1110110111101010110000100100010101100010110011011000100100000101 from address 0000000011 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 0+1110110111101010110000100100010101100010110011011000100100000101 from address 0000000011 (from port 0) during cycle 52 (520ns - 530ns)
*	Writing (partial) 0+1111110010111101000011011101001001111001010000110111011110110100  to  address 0000000010 with mask bit 00110011 (from port 0) during cycle 54 (540ns - 550ns)
*	Writing 0+1010100101000110110010010110010010111011111101111100011101001010  to  address 0000000000 (from port 0) during cycle 55 (550ns - 560ns)
*	Writing 0+0010001101100100010011100000100010011001110001010101100011000101  to  address 0111111111 (from port 0) during cycle 56 (560ns - 570ns)
*	Reading 0+1101011001010100000101000110110100101101101110100001111111110010 from address 1000000000 (from port 0) during cycle 57 (570ns - 580ns)
*	Writing (partial) 0+1111000001111001011101000101101011110111100000001110010110110111  to  address 0000000011 with mask bit 00101000 (from port 0) during cycle 58 (580ns - 590ns)
*	Writing 0+1111011111001111100011110000111110101101101101010001001111011111  to  address 1000000001 (from port 0) during cycle 59 (590ns - 600ns)
*	Reading 0+0010001101100100010011100000100010011001110001010101100011000101 from address 0111111111 (from port 0) during cycle 60 (600ns - 610ns)
*	Writing 0+1111111100101000101001111100111110101010101000110001101111100010  to  address 0000000011 (from port 0) during cycle 61 (610ns - 620ns)
*	Writing (partial) 0+0100101101100001110000111111001001001100010011011100101101011011  to  address 0000000000 with mask bit 11010001 (from port 0) during cycle 64 (640ns - 650ns)
*	Writing (partial) 0+1000011101111001101101001010111100100101101011010110011101001100  to  address 1000000010 with mask bit 00101001 (from port 0) during cycle 66 (660ns - 670ns)
*	Writing 0+1111011111010000101001100100111001010110001011001001100101000100  to  address 0000000010 (from port 0) during cycle 69 (690ns - 700ns)
*	Reading 0+0010001101100100010011100000100010011001110001010101100011000101 from address 0111111111 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 0+1111011111001111100011110000111110101101101101010001001111011111 from address 1000000001 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 0+1111011111001111100011110000111110101101101101010001001111011111 from address 1000000001 (from port 0) during cycle 73 (730ns - 740ns)
*	Reading 0+1101011001010100000101000110110100101101101110100001111111110010 from address 1000000000 (from port 0) during cycle 74 (740ns - 750ns)
*	Writing (partial) 0+1001011011101101101001110110011010001010011111001100101010111001  to  address 1000000010 with mask bit 10010110 (from port 0) during cycle 75 (750ns - 760ns)
*	Writing (partial) 0+1000101010000101111001000110111110000111010001101110000001110100  to  address 0000000011 with mask bit 11000101 (from port 0) during cycle 76 (760ns - 770ns)
*	Reading 0+1001011010000110101101000110011000100101011111001100101001001100 from address 1000000010 (from port 0) during cycle 77 (770ns - 780ns)
*	Writing 0+0011010010011010110110001110001011000100100111100101011110001000  to  address 1000000010 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing 0+0111001100100011100011010110001010000010010101111010101110110011  to  address 0000000000 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 0+0010001101100100010011100000100010011001110001010101100011000101 from address 0111111111 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 0+0010001101100100010011100000100010011001110001010101100011000101 from address 0111111111 (from port 0) during cycle 82 (820ns - 830ns)
*	Writing (partial) 0+1011011111110001010010101000010111101011011011111011011001111101  to  address 0000000010 with mask bit 11011000 (from port 0) during cycle 85 (850ns - 860ns)
*	Writing (partial) 0+0101010000101111100100101011110000001101010101110001000110010100  to  address 0000000010 with mask bit 01110011 (from port 0) during cycle 86 (860ns - 870ns)
*	Reading 0+1111011111001111100011110000111110101101101101010001001111011111 from address 1000000001 (from port 0) during cycle 87 (870ns - 880ns)
*	Reading 0+1011011100101111100100101011110011101011001011000001000110010100 from address 0000000010 (from port 0) during cycle 89 (890ns - 900ns)
*	Reading 0+1000101010000101101001111100111110101010010001100001101101110100 from address 0000000011 (from port 0) during cycle 90 (900ns - 910ns)
*	Writing 0+1111111001001011000010110011011101101110000110101011101101001011  to  address 0000000011 (from port 0) during cycle 92 (920ns - 930ns)
*	Writing 0+0011110101001101101010001001011111000010111000000101111011100110  to  address 0000000001 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 0+0011110101001101101010001001011111000010111000000101111011100110 from address 0000000001 (from port 0) during cycle 94 (940ns - 950ns)
*	Reading 0+1111111001001011000010110011011101101110000110101011101101001011 from address 0000000011 (from port 0) during cycle 95 (950ns - 960ns)
*	Writing 0+0110001000100000011001001011011110111101000110111111100110000111  to  address 0000000010 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 0+0011110101001101101010001001011111000010111000000101111011100110 from address 0000000001 (from port 0) during cycle 97 (970ns - 980ns)
*	Writing (partial) 0+0010011110010010010101000000101110111011100011000010011111101111  to  address 1000000010 with mask bit 01011101 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 0+0110001000100000011001001011011110111101000110111111100110000111 from address 0000000010 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 0+0011010010010010110110000000101110111011100011000101011111101111 from address 1000000010 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+1111011111001111100011110000111110101101101101010001001111011111 from address 1000000001 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Writing (partial) 0+1101110011101010100110110011100011111000110000001101101010000111  to  address 1000000000 with mask bit 10010011 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Reading 0+0110001000100000011001001011011110111101000110111111100110000111 from address 0000000010 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 0+0111001100100011100011010110001010000010010101111010101110110011 from address 0000000000 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 0+1111111001001011000010110011011101101110000110101011101101001011 from address 0000000011 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Writing 0+1010000111110011001011010101000110100110101000000111010001000101  to  address 1000000001 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 0+0011110101001101101010001001011111000010111000000101111011100110 from address 0000000001 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Reading 0+0110001000100000011001001011011110111101000110111111100110000111 from address 0000000010 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Writing 0+1101101111001111111011000010011110010100010011001100110111111011  to  address 0000000010 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 0+1111111001001011000010110011011101101110000110101011101101001011 from address 0000000011 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 0+1101110001010100000101000011100000101101101110101101101010000111 from address 1000000000 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Writing (partial) 0+0100100011100111011000100011111010010100000011110111110011011001  to  address 1000000000 with mask bit 01101001 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Reading 0+0111001100100011100011010110001010000010010101111010101110110011 from address 0000000000 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Reading 0+1111111001001011000010110011011101101110000110101011101101001011 from address 0000000011 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Writing 0+0100001111001100001111101011101111010101100110011111101001000101  to  address 0000000001 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 0+0111001100100011100011010110001010000010010101111010101110110011 from address 0000000000 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 0+0100001111001100001111101011101111010101100110011111101001000101 from address 0000000001 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Writing 0+0110010101100111100111101111011100111001111011101100100000111110  to  address 0111111111 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Writing 0+0100000000110101100010001010011100111000011000001010001101100101  to  address 0000000001 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 0+1101110011100111011000100011100010010100101110101101101011011001 from address 1000000000 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Reading 0+0111001100100011100011010110001010000010010101111010101110110011 from address 0000000000 (from port 0) during cycle 124 (1240ns - 1250ns)
*	Reading 0+1101101111001111111011000010011110010100010011001100110111111011 from address 0000000010 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Writing (partial) 0+1110010011100101100000011010011000110011101110010100111011110000  to  address 0000000001 with mask bit 01110011 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Writing 0+1011101111100010100001011001101110011101000001101000111010101110  to  address 0000000000 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Reading 0+0100000011100101100000011010011000111000011000000100111011110000 from address 0000000001 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Reading 0+1010000111110011001011010101000110100110101000000111010001000101 from address 1000000001 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 0+1111111001001011000010110011011101101110000110101011101101001011 from address 0000000011 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Writing (partial) 0+1011110011110101111100000000010110111100010100101011111101100110  to  address 0000000010 with mask bit 11001001 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Reading 0+1010000111110011001011010101000110100110101000000111010001000101 from address 1000000001 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Writing (partial) 0+0011010001100111100110010001000001100110001001111011111000111010  to  address 1000000000 with mask bit 11111101 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 0+0110010101100111100111101111011100111001111011101100100000111110 from address 0111111111 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 0+1011101111100010100001011001101110011101000001101000111010101110 from address 0000000000 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Writing 0+1001000101100110010101110011100110010101001111101101000100001111  to  address 1000000000 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Writing 0+1111010101100100110010000100110110100001011010000101010011001101  to  address 0000000000 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Writing 0+1101010110011110000110011010100100100101001110101011000010000011  to  address 0000000000 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Reading 0+1111111001001011000010110011011101101110000110101011101101001011 from address 0000000011 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Writing (partial) 0+0111010010111010101011101010111001000100000110110101001011110011  to  address 0000000001 with mask bit 00000001 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Writing (partial) 0+0111011001011001010100100100011110010001100101111011110001111000  to  address 0111111111 with mask bit 00011001 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Writing (partial) 0+1000001100100100100011000100011001111011100010011010000101001100  to  address 0000000001 with mask bit 01100010 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Writing (partial) 0+0011111110000100010000110100111000011001000001111010001110110111  to  address 0000000001 with mask bit 00000110 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Writing 0+1110000111110011001110101100101010100110011101111111100000000100  to  address 0111111111 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 0+1101010110011110000110011010100100100101001110101011000010000011 from address 0000000000 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Reading 0+1110000111110011001110101100101010100110011101111111100000000100 from address 0111111111 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Reading 0+1110000111110011001110101100101010100110011101111111100000000100 from address 0111111111 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Reading 0+1011110011110101111011000010011110111100010011001100110101100110 from address 0000000010 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Writing (partial) 0+1111000000100001001010100111111111100110110110101101010011111011  to  address 0000000000 with mask bit 11101101 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Writing 0+1011111010000000110110111100100000000101101010100100111110100101  to  address 1000000001 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Writing 0+0010101011111000000100111110000000101111010011001111100111111011  to  address 1000000010 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Writing (partial) 0+1011011100000001101100110111011000010010001010000011000000000110  to  address 0000000001 with mask bit 00010000 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Reading 0+0010101011111000000100111110000000101111010011001111100111111011 from address 1000000010 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Writing (partial) 0+1000010101110011100000001010001010110001111101100101000011101100  to  address 1000000010 with mask bit 00110100 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Writing (partial) 0+0001110001100101100000011000101001010001101110101110101010101111  to  address 0000000010 with mask bit 00001101 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Writing (partial) 0+1100100011111000100001101101001111110110110001011010111100101111  to  address 1000000010 with mask bit 11101110 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Writing 0+1010100011111110011110011111110111100000111100001100011101110000  to  address 0000000001 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Writing 0+1010101001010000011100001011111100000010001000011101111111110000  to  address 0000000010 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Writing 0+1011100000001110101011111010000001101101101001001011100110101100  to  address 0000000011 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 0+1011111010000000110110111100100000000101101010100100111110100101 from address 1000000001 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Reading 0+1011111010000000110110111100100000000101101010100100111110100101 from address 1000000001 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Reading 0+1110000111110011001110101100101010100110011101111111100000000100 from address 0111111111 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 0+1100100011111000100001101010001011110110110001011010111111111011 from address 1000000010 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Writing 0+0100010011100001011011010111001110011110110011101110101011010000  to  address 0000000000 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Writing (partial) 0+1110100101100000011110101001100100101000110110100111010110101011  to  address 0000000011 with mask bit 11100000 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 0+1110000111110011001110101100101010100110011101111111100000000100 from address 0111111111 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 0+1010101001010000011100001011111100000010001000011101111111110000 from address 0000000010 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Reading 0+1011111010000000110110111100100000000101101010100100111110100101 from address 1000000001 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 0+0100010011100001011011010111001110011110110011101110101011010000 from address 0000000000 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Writing (partial) 0+1000101001111110100001110001001100110000100000010111101110110100  to  address 0000000001 with mask bit 11110100 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Writing (partial) 0+0101111011001110010011101011010011111101100010010011000110001001  to  address 0000000000 with mask bit 00110011 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Writing 0+1011011110101010110110001010111100000011111110100110100001101000  to  address 0000000011 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Writing 0+0101010110011111000101100010111110110000110001001111011100110011  to  address 1000000000 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Writing 0+0010000010010000111010111000100110001111001101001000000110111011  to  address 0000000001 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 0+0101010110011111000101100010111110110000110001001111011100110011 from address 1000000000 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Writing 0+0100010010010101010110110101001101001011101111110110011101100101  to  address 0000000011 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Writing 0+1001101001111110011101101000010000000000010011110011100110011111  to  address 0000000011 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Reading 0+1010101001010000011100001011111100000010001000011101111111110000 from address 0000000010 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing 0+1110100101111101110101111111001111011101110101101011001001110111  to  address 0000000010 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 0+1011111010000000110110111100100000000101101010100100111110100101 from address 1000000001 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Writing (partial) 0+1011001101010010010101110101001100100011000110111110010011001011  to  address 1000000000 with mask bit 10000110 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 0+1100100011111000100001101010001011110110110001011010111111111011 from address 1000000010 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 0+1011111010000000110110111100100000000101101010100100111110100101 from address 1000000001 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Writing (partial) 0+0001101010110100011101101100100100110001100110101110010000001000  to  address 0000000010 with mask bit 10011111 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 0+1011111010000000110110111100100000000101101010100100111110100101 from address 1000000001 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Reading 0+0001101001111101110101111100100100110001100110101110010000001000 from address 0000000010 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Writing 0+1010100111100011111100100100100100000011001100110101100011100001  to  address 0000000001 (from port 0) during cycle 196 (1960ns - 1970ns)
*	Writing (partial) 0+0101011111011111000100011100001001101111110111000011101001110000  to  address 1000000000 with mask bit 00011100 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Writing 0+1011111110001010111011001001001101100111101010101100011010000110  to  address 1000000001 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing (partial) 0+1000010110011100011000111100101101101000101000000001010010010110  to  address 0000000001 with mask bit 10100011 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Writing 0+1001000110110111000010110111110010110100010011101110001000000001  to  address 0000000010 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Reading 0+1001101001111110011101101000010000000000010011110011100110011111 from address 0000000011 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Reading 0+0100010011100001010011101011010010011110110011100011000110001001 from address 0000000000 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 0), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 1), (390, 1), (400, 0), (410, 1), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 0), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 1), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 0), (460, 1), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 0), (560, 1), (570, 0), (580, 1), (590, 0), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 0), (950, 1), (960, 1), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 0), (1890, 0), (1900, 1), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 1), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 1), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_9  a0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 0), (650, 1), (660, 0), (670, 1), (680, 1), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 0), (110, 1), (120, 1), (130, 0), (140, 1), (150, 0), (160, 0), (170, 1), (180, 0), (190, 1), (200, 1), (210, 1), (220, 0), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 1), (330, 0), (340, 1), (350, 1), (360, 1), (370, 0), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 0), (440, 1), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 0), (620, 1), (630, 1), (640, 0), (650, 1), (660, 0), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 1), (950, 1), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of wmask signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_4  WMASK0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_5  WMASK0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 0.0v 459.495n 0.0v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_6  WMASK0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_7  WMASK0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 1.8 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 50
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=50.05n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 50
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=50.05n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 50
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=50.05n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 50
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=50.05n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 50
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=50.05n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 50
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=50.05n

* CHECK dout0_14 Vdout0_14ck4 = 1.8 time = 50
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=50.05n

* CHECK dout0_15 Vdout0_15ck4 = 1.8 time = 50
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=50.05n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 50
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=50.05n

* CHECK dout0_17 Vdout0_17ck4 = 1.8 time = 50
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=50.05n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 50
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=50.05n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 50
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=50.05n

* CHECK dout0_20 Vdout0_20ck4 = 1.8 time = 50
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=50.05n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 50
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=50.05n

* CHECK dout0_22 Vdout0_22ck4 = 1.8 time = 50
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=50.05n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 50
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=50.05n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 50
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=50.05n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 50
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=50.05n

* CHECK dout0_26 Vdout0_26ck4 = 1.8 time = 50
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=50.05n

* CHECK dout0_27 Vdout0_27ck4 = 0 time = 50
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=50.05n

* CHECK dout0_28 Vdout0_28ck4 = 0 time = 50
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=50.05n

* CHECK dout0_29 Vdout0_29ck4 = 1.8 time = 50
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=50.05n

* CHECK dout0_30 Vdout0_30ck4 = 1.8 time = 50
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=50.05n

* CHECK dout0_31 Vdout0_31ck4 = 1.8 time = 50
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=50.05n

* CHECK dout0_32 Vdout0_32ck4 = 1.8 time = 50
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=50.05n

* CHECK dout0_33 Vdout0_33ck4 = 1.8 time = 50
.meas tran vdout0_33ck4 FIND v(dout0_33) AT=50.05n

* CHECK dout0_34 Vdout0_34ck4 = 0 time = 50
.meas tran vdout0_34ck4 FIND v(dout0_34) AT=50.05n

* CHECK dout0_35 Vdout0_35ck4 = 1.8 time = 50
.meas tran vdout0_35ck4 FIND v(dout0_35) AT=50.05n

* CHECK dout0_36 Vdout0_36ck4 = 1.8 time = 50
.meas tran vdout0_36ck4 FIND v(dout0_36) AT=50.05n

* CHECK dout0_37 Vdout0_37ck4 = 1.8 time = 50
.meas tran vdout0_37ck4 FIND v(dout0_37) AT=50.05n

* CHECK dout0_38 Vdout0_38ck4 = 0 time = 50
.meas tran vdout0_38ck4 FIND v(dout0_38) AT=50.05n

* CHECK dout0_39 Vdout0_39ck4 = 0 time = 50
.meas tran vdout0_39ck4 FIND v(dout0_39) AT=50.05n

* CHECK dout0_40 Vdout0_40ck4 = 1.8 time = 50
.meas tran vdout0_40ck4 FIND v(dout0_40) AT=50.05n

* CHECK dout0_41 Vdout0_41ck4 = 1.8 time = 50
.meas tran vdout0_41ck4 FIND v(dout0_41) AT=50.05n

* CHECK dout0_42 Vdout0_42ck4 = 0 time = 50
.meas tran vdout0_42ck4 FIND v(dout0_42) AT=50.05n

* CHECK dout0_43 Vdout0_43ck4 = 1.8 time = 50
.meas tran vdout0_43ck4 FIND v(dout0_43) AT=50.05n

* CHECK dout0_44 Vdout0_44ck4 = 0 time = 50
.meas tran vdout0_44ck4 FIND v(dout0_44) AT=50.05n

* CHECK dout0_45 Vdout0_45ck4 = 1.8 time = 50
.meas tran vdout0_45ck4 FIND v(dout0_45) AT=50.05n

* CHECK dout0_46 Vdout0_46ck4 = 1.8 time = 50
.meas tran vdout0_46ck4 FIND v(dout0_46) AT=50.05n

* CHECK dout0_47 Vdout0_47ck4 = 1.8 time = 50
.meas tran vdout0_47ck4 FIND v(dout0_47) AT=50.05n

* CHECK dout0_48 Vdout0_48ck4 = 1.8 time = 50
.meas tran vdout0_48ck4 FIND v(dout0_48) AT=50.05n

* CHECK dout0_49 Vdout0_49ck4 = 1.8 time = 50
.meas tran vdout0_49ck4 FIND v(dout0_49) AT=50.05n

* CHECK dout0_50 Vdout0_50ck4 = 1.8 time = 50
.meas tran vdout0_50ck4 FIND v(dout0_50) AT=50.05n

* CHECK dout0_51 Vdout0_51ck4 = 0 time = 50
.meas tran vdout0_51ck4 FIND v(dout0_51) AT=50.05n

* CHECK dout0_52 Vdout0_52ck4 = 1.8 time = 50
.meas tran vdout0_52ck4 FIND v(dout0_52) AT=50.05n

* CHECK dout0_53 Vdout0_53ck4 = 0 time = 50
.meas tran vdout0_53ck4 FIND v(dout0_53) AT=50.05n

* CHECK dout0_54 Vdout0_54ck4 = 1.8 time = 50
.meas tran vdout0_54ck4 FIND v(dout0_54) AT=50.05n

* CHECK dout0_55 Vdout0_55ck4 = 0 time = 50
.meas tran vdout0_55ck4 FIND v(dout0_55) AT=50.05n

* CHECK dout0_56 Vdout0_56ck4 = 1.8 time = 50
.meas tran vdout0_56ck4 FIND v(dout0_56) AT=50.05n

* CHECK dout0_57 Vdout0_57ck4 = 0 time = 50
.meas tran vdout0_57ck4 FIND v(dout0_57) AT=50.05n

* CHECK dout0_58 Vdout0_58ck4 = 1.8 time = 50
.meas tran vdout0_58ck4 FIND v(dout0_58) AT=50.05n

* CHECK dout0_59 Vdout0_59ck4 = 0 time = 50
.meas tran vdout0_59ck4 FIND v(dout0_59) AT=50.05n

* CHECK dout0_60 Vdout0_60ck4 = 0 time = 50
.meas tran vdout0_60ck4 FIND v(dout0_60) AT=50.05n

* CHECK dout0_61 Vdout0_61ck4 = 1.8 time = 50
.meas tran vdout0_61ck4 FIND v(dout0_61) AT=50.05n

* CHECK dout0_62 Vdout0_62ck4 = 1.8 time = 50
.meas tran vdout0_62ck4 FIND v(dout0_62) AT=50.05n

* CHECK dout0_63 Vdout0_63ck4 = 1.8 time = 50
.meas tran vdout0_63ck4 FIND v(dout0_63) AT=50.05n

* CHECK dout0_64 Vdout0_64ck4 = 0 time = 50
.meas tran vdout0_64ck4 FIND v(dout0_64) AT=50.05n

* CHECK dout0_0 Vdout0_0ck6 = 1.8 time = 70
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=70.05n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 70
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=70.05n

* CHECK dout0_2 Vdout0_2ck6 = 0 time = 70
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=70.05n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 70
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=70.05n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 70
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=70.05n

* CHECK dout0_5 Vdout0_5ck6 = 1.8 time = 70
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=70.05n

* CHECK dout0_6 Vdout0_6ck6 = 0 time = 70
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=70.05n

* CHECK dout0_7 Vdout0_7ck6 = 1.8 time = 70
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=70.05n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 70
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=70.05n

* CHECK dout0_9 Vdout0_9ck6 = 0 time = 70
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=70.05n

* CHECK dout0_10 Vdout0_10ck6 = 0 time = 70
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=70.05n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 70
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=70.05n

* CHECK dout0_12 Vdout0_12ck6 = 1.8 time = 70
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=70.05n

* CHECK dout0_13 Vdout0_13ck6 = 0 time = 70
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=70.05n

* CHECK dout0_14 Vdout0_14ck6 = 1.8 time = 70
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=70.05n

* CHECK dout0_15 Vdout0_15ck6 = 1.8 time = 70
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=70.05n

* CHECK dout0_16 Vdout0_16ck6 = 0 time = 70
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=70.05n

* CHECK dout0_17 Vdout0_17ck6 = 1.8 time = 70
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=70.05n

* CHECK dout0_18 Vdout0_18ck6 = 0 time = 70
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=70.05n

* CHECK dout0_19 Vdout0_19ck6 = 0 time = 70
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=70.05n

* CHECK dout0_20 Vdout0_20ck6 = 1.8 time = 70
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=70.05n

* CHECK dout0_21 Vdout0_21ck6 = 0 time = 70
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=70.05n

* CHECK dout0_22 Vdout0_22ck6 = 1.8 time = 70
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=70.05n

* CHECK dout0_23 Vdout0_23ck6 = 0 time = 70
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=70.05n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 70
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=70.05n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 70
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=70.05n

* CHECK dout0_26 Vdout0_26ck6 = 1.8 time = 70
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=70.05n

* CHECK dout0_27 Vdout0_27ck6 = 0 time = 70
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=70.05n

* CHECK dout0_28 Vdout0_28ck6 = 0 time = 70
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=70.05n

* CHECK dout0_29 Vdout0_29ck6 = 1.8 time = 70
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=70.05n

* CHECK dout0_30 Vdout0_30ck6 = 1.8 time = 70
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=70.05n

* CHECK dout0_31 Vdout0_31ck6 = 1.8 time = 70
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=70.05n

* CHECK dout0_32 Vdout0_32ck6 = 1.8 time = 70
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=70.05n

* CHECK dout0_33 Vdout0_33ck6 = 1.8 time = 70
.meas tran vdout0_33ck6 FIND v(dout0_33) AT=70.05n

* CHECK dout0_34 Vdout0_34ck6 = 0 time = 70
.meas tran vdout0_34ck6 FIND v(dout0_34) AT=70.05n

* CHECK dout0_35 Vdout0_35ck6 = 1.8 time = 70
.meas tran vdout0_35ck6 FIND v(dout0_35) AT=70.05n

* CHECK dout0_36 Vdout0_36ck6 = 1.8 time = 70
.meas tran vdout0_36ck6 FIND v(dout0_36) AT=70.05n

* CHECK dout0_37 Vdout0_37ck6 = 1.8 time = 70
.meas tran vdout0_37ck6 FIND v(dout0_37) AT=70.05n

* CHECK dout0_38 Vdout0_38ck6 = 0 time = 70
.meas tran vdout0_38ck6 FIND v(dout0_38) AT=70.05n

* CHECK dout0_39 Vdout0_39ck6 = 0 time = 70
.meas tran vdout0_39ck6 FIND v(dout0_39) AT=70.05n

* CHECK dout0_40 Vdout0_40ck6 = 1.8 time = 70
.meas tran vdout0_40ck6 FIND v(dout0_40) AT=70.05n

* CHECK dout0_41 Vdout0_41ck6 = 1.8 time = 70
.meas tran vdout0_41ck6 FIND v(dout0_41) AT=70.05n

* CHECK dout0_42 Vdout0_42ck6 = 0 time = 70
.meas tran vdout0_42ck6 FIND v(dout0_42) AT=70.05n

* CHECK dout0_43 Vdout0_43ck6 = 1.8 time = 70
.meas tran vdout0_43ck6 FIND v(dout0_43) AT=70.05n

* CHECK dout0_44 Vdout0_44ck6 = 0 time = 70
.meas tran vdout0_44ck6 FIND v(dout0_44) AT=70.05n

* CHECK dout0_45 Vdout0_45ck6 = 1.8 time = 70
.meas tran vdout0_45ck6 FIND v(dout0_45) AT=70.05n

* CHECK dout0_46 Vdout0_46ck6 = 1.8 time = 70
.meas tran vdout0_46ck6 FIND v(dout0_46) AT=70.05n

* CHECK dout0_47 Vdout0_47ck6 = 1.8 time = 70
.meas tran vdout0_47ck6 FIND v(dout0_47) AT=70.05n

* CHECK dout0_48 Vdout0_48ck6 = 1.8 time = 70
.meas tran vdout0_48ck6 FIND v(dout0_48) AT=70.05n

* CHECK dout0_49 Vdout0_49ck6 = 1.8 time = 70
.meas tran vdout0_49ck6 FIND v(dout0_49) AT=70.05n

* CHECK dout0_50 Vdout0_50ck6 = 1.8 time = 70
.meas tran vdout0_50ck6 FIND v(dout0_50) AT=70.05n

* CHECK dout0_51 Vdout0_51ck6 = 0 time = 70
.meas tran vdout0_51ck6 FIND v(dout0_51) AT=70.05n

* CHECK dout0_52 Vdout0_52ck6 = 1.8 time = 70
.meas tran vdout0_52ck6 FIND v(dout0_52) AT=70.05n

* CHECK dout0_53 Vdout0_53ck6 = 0 time = 70
.meas tran vdout0_53ck6 FIND v(dout0_53) AT=70.05n

* CHECK dout0_54 Vdout0_54ck6 = 1.8 time = 70
.meas tran vdout0_54ck6 FIND v(dout0_54) AT=70.05n

* CHECK dout0_55 Vdout0_55ck6 = 0 time = 70
.meas tran vdout0_55ck6 FIND v(dout0_55) AT=70.05n

* CHECK dout0_56 Vdout0_56ck6 = 1.8 time = 70
.meas tran vdout0_56ck6 FIND v(dout0_56) AT=70.05n

* CHECK dout0_57 Vdout0_57ck6 = 0 time = 70
.meas tran vdout0_57ck6 FIND v(dout0_57) AT=70.05n

* CHECK dout0_58 Vdout0_58ck6 = 1.8 time = 70
.meas tran vdout0_58ck6 FIND v(dout0_58) AT=70.05n

* CHECK dout0_59 Vdout0_59ck6 = 0 time = 70
.meas tran vdout0_59ck6 FIND v(dout0_59) AT=70.05n

* CHECK dout0_60 Vdout0_60ck6 = 0 time = 70
.meas tran vdout0_60ck6 FIND v(dout0_60) AT=70.05n

* CHECK dout0_61 Vdout0_61ck6 = 1.8 time = 70
.meas tran vdout0_61ck6 FIND v(dout0_61) AT=70.05n

* CHECK dout0_62 Vdout0_62ck6 = 1.8 time = 70
.meas tran vdout0_62ck6 FIND v(dout0_62) AT=70.05n

* CHECK dout0_63 Vdout0_63ck6 = 1.8 time = 70
.meas tran vdout0_63ck6 FIND v(dout0_63) AT=70.05n

* CHECK dout0_64 Vdout0_64ck6 = 0 time = 70
.meas tran vdout0_64ck6 FIND v(dout0_64) AT=70.05n

* CHECK dout0_0 Vdout0_0ck8 = 1.8 time = 90
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=90.05n

* CHECK dout0_1 Vdout0_1ck8 = 1.8 time = 90
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=90.05n

* CHECK dout0_2 Vdout0_2ck8 = 0 time = 90
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=90.05n

* CHECK dout0_3 Vdout0_3ck8 = 1.8 time = 90
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=90.05n

* CHECK dout0_4 Vdout0_4ck8 = 0 time = 90
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=90.05n

* CHECK dout0_5 Vdout0_5ck8 = 1.8 time = 90
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=90.05n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 90
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=90.05n

* CHECK dout0_7 Vdout0_7ck8 = 1.8 time = 90
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=90.05n

* CHECK dout0_8 Vdout0_8ck8 = 0 time = 90
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=90.05n

* CHECK dout0_9 Vdout0_9ck8 = 1.8 time = 90
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=90.05n

* CHECK dout0_10 Vdout0_10ck8 = 1.8 time = 90
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=90.05n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 90
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=90.05n

* CHECK dout0_12 Vdout0_12ck8 = 0 time = 90
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=90.05n

* CHECK dout0_13 Vdout0_13ck8 = 1.8 time = 90
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=90.05n

* CHECK dout0_14 Vdout0_14ck8 = 0 time = 90
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=90.05n

* CHECK dout0_15 Vdout0_15ck8 = 0 time = 90
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=90.05n

* CHECK dout0_16 Vdout0_16ck8 = 1.8 time = 90
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=90.05n

* CHECK dout0_17 Vdout0_17ck8 = 1.8 time = 90
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=90.05n

* CHECK dout0_18 Vdout0_18ck8 = 1.8 time = 90
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=90.05n

* CHECK dout0_19 Vdout0_19ck8 = 0 time = 90
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=90.05n

* CHECK dout0_20 Vdout0_20ck8 = 0 time = 90
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=90.05n

* CHECK dout0_21 Vdout0_21ck8 = 1.8 time = 90
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=90.05n

* CHECK dout0_22 Vdout0_22ck8 = 1.8 time = 90
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=90.05n

* CHECK dout0_23 Vdout0_23ck8 = 1.8 time = 90
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=90.05n

* CHECK dout0_24 Vdout0_24ck8 = 0 time = 90
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=90.05n

* CHECK dout0_25 Vdout0_25ck8 = 0 time = 90
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=90.05n

* CHECK dout0_26 Vdout0_26ck8 = 0 time = 90
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=90.05n

* CHECK dout0_27 Vdout0_27ck8 = 1.8 time = 90
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=90.05n

* CHECK dout0_28 Vdout0_28ck8 = 0 time = 90
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=90.05n

* CHECK dout0_29 Vdout0_29ck8 = 0 time = 90
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=90.05n

* CHECK dout0_30 Vdout0_30ck8 = 0 time = 90
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=90.05n

* CHECK dout0_31 Vdout0_31ck8 = 1.8 time = 90
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=90.05n

* CHECK dout0_32 Vdout0_32ck8 = 1.8 time = 90
.meas tran vdout0_32ck8 FIND v(dout0_32) AT=90.05n

* CHECK dout0_33 Vdout0_33ck8 = 0 time = 90
.meas tran vdout0_33ck8 FIND v(dout0_33) AT=90.05n

* CHECK dout0_34 Vdout0_34ck8 = 1.8 time = 90
.meas tran vdout0_34ck8 FIND v(dout0_34) AT=90.05n

* CHECK dout0_35 Vdout0_35ck8 = 0 time = 90
.meas tran vdout0_35ck8 FIND v(dout0_35) AT=90.05n

* CHECK dout0_36 Vdout0_36ck8 = 0 time = 90
.meas tran vdout0_36ck8 FIND v(dout0_36) AT=90.05n

* CHECK dout0_37 Vdout0_37ck8 = 0 time = 90
.meas tran vdout0_37ck8 FIND v(dout0_37) AT=90.05n

* CHECK dout0_38 Vdout0_38ck8 = 1.8 time = 90
.meas tran vdout0_38ck8 FIND v(dout0_38) AT=90.05n

* CHECK dout0_39 Vdout0_39ck8 = 0 time = 90
.meas tran vdout0_39ck8 FIND v(dout0_39) AT=90.05n

* CHECK dout0_40 Vdout0_40ck8 = 1.8 time = 90
.meas tran vdout0_40ck8 FIND v(dout0_40) AT=90.05n

* CHECK dout0_41 Vdout0_41ck8 = 1.8 time = 90
.meas tran vdout0_41ck8 FIND v(dout0_41) AT=90.05n

* CHECK dout0_42 Vdout0_42ck8 = 1.8 time = 90
.meas tran vdout0_42ck8 FIND v(dout0_42) AT=90.05n

* CHECK dout0_43 Vdout0_43ck8 = 0 time = 90
.meas tran vdout0_43ck8 FIND v(dout0_43) AT=90.05n

* CHECK dout0_44 Vdout0_44ck8 = 0 time = 90
.meas tran vdout0_44ck8 FIND v(dout0_44) AT=90.05n

* CHECK dout0_45 Vdout0_45ck8 = 0 time = 90
.meas tran vdout0_45ck8 FIND v(dout0_45) AT=90.05n

* CHECK dout0_46 Vdout0_46ck8 = 0 time = 90
.meas tran vdout0_46ck8 FIND v(dout0_46) AT=90.05n

* CHECK dout0_47 Vdout0_47ck8 = 1.8 time = 90
.meas tran vdout0_47ck8 FIND v(dout0_47) AT=90.05n

* CHECK dout0_48 Vdout0_48ck8 = 1.8 time = 90
.meas tran vdout0_48ck8 FIND v(dout0_48) AT=90.05n

* CHECK dout0_49 Vdout0_49ck8 = 1.8 time = 90
.meas tran vdout0_49ck8 FIND v(dout0_49) AT=90.05n

* CHECK dout0_50 Vdout0_50ck8 = 0 time = 90
.meas tran vdout0_50ck8 FIND v(dout0_50) AT=90.05n

* CHECK dout0_51 Vdout0_51ck8 = 1.8 time = 90
.meas tran vdout0_51ck8 FIND v(dout0_51) AT=90.05n

* CHECK dout0_52 Vdout0_52ck8 = 0 time = 90
.meas tran vdout0_52ck8 FIND v(dout0_52) AT=90.05n

* CHECK dout0_53 Vdout0_53ck8 = 1.8 time = 90
.meas tran vdout0_53ck8 FIND v(dout0_53) AT=90.05n

* CHECK dout0_54 Vdout0_54ck8 = 0 time = 90
.meas tran vdout0_54ck8 FIND v(dout0_54) AT=90.05n

* CHECK dout0_55 Vdout0_55ck8 = 1.8 time = 90
.meas tran vdout0_55ck8 FIND v(dout0_55) AT=90.05n

* CHECK dout0_56 Vdout0_56ck8 = 1.8 time = 90
.meas tran vdout0_56ck8 FIND v(dout0_56) AT=90.05n

* CHECK dout0_57 Vdout0_57ck8 = 0 time = 90
.meas tran vdout0_57ck8 FIND v(dout0_57) AT=90.05n

* CHECK dout0_58 Vdout0_58ck8 = 0 time = 90
.meas tran vdout0_58ck8 FIND v(dout0_58) AT=90.05n

* CHECK dout0_59 Vdout0_59ck8 = 1.8 time = 90
.meas tran vdout0_59ck8 FIND v(dout0_59) AT=90.05n

* CHECK dout0_60 Vdout0_60ck8 = 1.8 time = 90
.meas tran vdout0_60ck8 FIND v(dout0_60) AT=90.05n

* CHECK dout0_61 Vdout0_61ck8 = 0 time = 90
.meas tran vdout0_61ck8 FIND v(dout0_61) AT=90.05n

* CHECK dout0_62 Vdout0_62ck8 = 0 time = 90
.meas tran vdout0_62ck8 FIND v(dout0_62) AT=90.05n

* CHECK dout0_63 Vdout0_63ck8 = 1.8 time = 90
.meas tran vdout0_63ck8 FIND v(dout0_63) AT=90.05n

* CHECK dout0_64 Vdout0_64ck8 = 0 time = 90
.meas tran vdout0_64ck8 FIND v(dout0_64) AT=90.05n

* CHECK dout0_0 Vdout0_0ck11 = 1.8 time = 120
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=120.05n

* CHECK dout0_1 Vdout0_1ck11 = 1.8 time = 120
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=120.05n

* CHECK dout0_2 Vdout0_2ck11 = 0 time = 120
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=120.05n

* CHECK dout0_3 Vdout0_3ck11 = 1.8 time = 120
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=120.05n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 120
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=120.05n

* CHECK dout0_5 Vdout0_5ck11 = 1.8 time = 120
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=120.05n

* CHECK dout0_6 Vdout0_6ck11 = 1.8 time = 120
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=120.05n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 120
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=120.05n

* CHECK dout0_8 Vdout0_8ck11 = 1.8 time = 120
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=120.05n

* CHECK dout0_9 Vdout0_9ck11 = 1.8 time = 120
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=120.05n

* CHECK dout0_10 Vdout0_10ck11 = 1.8 time = 120
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=120.05n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 120
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=120.05n

* CHECK dout0_12 Vdout0_12ck11 = 1.8 time = 120
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=120.05n

* CHECK dout0_13 Vdout0_13ck11 = 0 time = 120
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=120.05n

* CHECK dout0_14 Vdout0_14ck11 = 1.8 time = 120
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=120.05n

* CHECK dout0_15 Vdout0_15ck11 = 1.8 time = 120
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=120.05n

* CHECK dout0_16 Vdout0_16ck11 = 1.8 time = 120
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=120.05n

* CHECK dout0_17 Vdout0_17ck11 = 0 time = 120
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=120.05n

* CHECK dout0_18 Vdout0_18ck11 = 0 time = 120
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=120.05n

* CHECK dout0_19 Vdout0_19ck11 = 0 time = 120
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=120.05n

* CHECK dout0_20 Vdout0_20ck11 = 1.8 time = 120
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=120.05n

* CHECK dout0_21 Vdout0_21ck11 = 0 time = 120
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=120.05n

* CHECK dout0_22 Vdout0_22ck11 = 0 time = 120
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=120.05n

* CHECK dout0_23 Vdout0_23ck11 = 1.8 time = 120
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=120.05n

* CHECK dout0_24 Vdout0_24ck11 = 1.8 time = 120
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=120.05n

* CHECK dout0_25 Vdout0_25ck11 = 1.8 time = 120
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=120.05n

* CHECK dout0_26 Vdout0_26ck11 = 1.8 time = 120
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=120.05n

* CHECK dout0_27 Vdout0_27ck11 = 1.8 time = 120
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=120.05n

* CHECK dout0_28 Vdout0_28ck11 = 0 time = 120
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=120.05n

* CHECK dout0_29 Vdout0_29ck11 = 0 time = 120
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=120.05n

* CHECK dout0_30 Vdout0_30ck11 = 0 time = 120
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=120.05n

* CHECK dout0_31 Vdout0_31ck11 = 0 time = 120
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=120.05n

* CHECK dout0_32 Vdout0_32ck11 = 0 time = 120
.meas tran vdout0_32ck11 FIND v(dout0_32) AT=120.05n

* CHECK dout0_33 Vdout0_33ck11 = 0 time = 120
.meas tran vdout0_33ck11 FIND v(dout0_33) AT=120.05n

* CHECK dout0_34 Vdout0_34ck11 = 1.8 time = 120
.meas tran vdout0_34ck11 FIND v(dout0_34) AT=120.05n

* CHECK dout0_35 Vdout0_35ck11 = 0 time = 120
.meas tran vdout0_35ck11 FIND v(dout0_35) AT=120.05n

* CHECK dout0_36 Vdout0_36ck11 = 0 time = 120
.meas tran vdout0_36ck11 FIND v(dout0_36) AT=120.05n

* CHECK dout0_37 Vdout0_37ck11 = 1.8 time = 120
.meas tran vdout0_37ck11 FIND v(dout0_37) AT=120.05n

* CHECK dout0_38 Vdout0_38ck11 = 0 time = 120
.meas tran vdout0_38ck11 FIND v(dout0_38) AT=120.05n

* CHECK dout0_39 Vdout0_39ck11 = 1.8 time = 120
.meas tran vdout0_39ck11 FIND v(dout0_39) AT=120.05n

* CHECK dout0_40 Vdout0_40ck11 = 0 time = 120
.meas tran vdout0_40ck11 FIND v(dout0_40) AT=120.05n

* CHECK dout0_41 Vdout0_41ck11 = 1.8 time = 120
.meas tran vdout0_41ck11 FIND v(dout0_41) AT=120.05n

* CHECK dout0_42 Vdout0_42ck11 = 0 time = 120
.meas tran vdout0_42ck11 FIND v(dout0_42) AT=120.05n

* CHECK dout0_43 Vdout0_43ck11 = 1.8 time = 120
.meas tran vdout0_43ck11 FIND v(dout0_43) AT=120.05n

* CHECK dout0_44 Vdout0_44ck11 = 0 time = 120
.meas tran vdout0_44ck11 FIND v(dout0_44) AT=120.05n

* CHECK dout0_45 Vdout0_45ck11 = 0 time = 120
.meas tran vdout0_45ck11 FIND v(dout0_45) AT=120.05n

* CHECK dout0_46 Vdout0_46ck11 = 0 time = 120
.meas tran vdout0_46ck11 FIND v(dout0_46) AT=120.05n

* CHECK dout0_47 Vdout0_47ck11 = 1.8 time = 120
.meas tran vdout0_47ck11 FIND v(dout0_47) AT=120.05n

* CHECK dout0_48 Vdout0_48ck11 = 0 time = 120
.meas tran vdout0_48ck11 FIND v(dout0_48) AT=120.05n

* CHECK dout0_49 Vdout0_49ck11 = 1.8 time = 120
.meas tran vdout0_49ck11 FIND v(dout0_49) AT=120.05n

* CHECK dout0_50 Vdout0_50ck11 = 0 time = 120
.meas tran vdout0_50ck11 FIND v(dout0_50) AT=120.05n

* CHECK dout0_51 Vdout0_51ck11 = 0 time = 120
.meas tran vdout0_51ck11 FIND v(dout0_51) AT=120.05n

* CHECK dout0_52 Vdout0_52ck11 = 0 time = 120
.meas tran vdout0_52ck11 FIND v(dout0_52) AT=120.05n

* CHECK dout0_53 Vdout0_53ck11 = 0 time = 120
.meas tran vdout0_53ck11 FIND v(dout0_53) AT=120.05n

* CHECK dout0_54 Vdout0_54ck11 = 0 time = 120
.meas tran vdout0_54ck11 FIND v(dout0_54) AT=120.05n

* CHECK dout0_55 Vdout0_55ck11 = 0 time = 120
.meas tran vdout0_55ck11 FIND v(dout0_55) AT=120.05n

* CHECK dout0_56 Vdout0_56ck11 = 1.8 time = 120
.meas tran vdout0_56ck11 FIND v(dout0_56) AT=120.05n

* CHECK dout0_57 Vdout0_57ck11 = 0 time = 120
.meas tran vdout0_57ck11 FIND v(dout0_57) AT=120.05n

* CHECK dout0_58 Vdout0_58ck11 = 1.8 time = 120
.meas tran vdout0_58ck11 FIND v(dout0_58) AT=120.05n

* CHECK dout0_59 Vdout0_59ck11 = 1.8 time = 120
.meas tran vdout0_59ck11 FIND v(dout0_59) AT=120.05n

* CHECK dout0_60 Vdout0_60ck11 = 1.8 time = 120
.meas tran vdout0_60ck11 FIND v(dout0_60) AT=120.05n

* CHECK dout0_61 Vdout0_61ck11 = 1.8 time = 120
.meas tran vdout0_61ck11 FIND v(dout0_61) AT=120.05n

* CHECK dout0_62 Vdout0_62ck11 = 0 time = 120
.meas tran vdout0_62ck11 FIND v(dout0_62) AT=120.05n

* CHECK dout0_63 Vdout0_63ck11 = 0 time = 120
.meas tran vdout0_63ck11 FIND v(dout0_63) AT=120.05n

* CHECK dout0_64 Vdout0_64ck11 = 0 time = 120
.meas tran vdout0_64ck11 FIND v(dout0_64) AT=120.05n

* CHECK dout0_0 Vdout0_0ck12 = 1.8 time = 130
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=130.05n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 130
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=130.05n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 130
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=130.05n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 130
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=130.05n

* CHECK dout0_4 Vdout0_4ck12 = 0 time = 130
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=130.05n

* CHECK dout0_5 Vdout0_5ck12 = 1.8 time = 130
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=130.05n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 130
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=130.05n

* CHECK dout0_7 Vdout0_7ck12 = 1.8 time = 130
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=130.05n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 130
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=130.05n

* CHECK dout0_9 Vdout0_9ck12 = 0 time = 130
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=130.05n

* CHECK dout0_10 Vdout0_10ck12 = 0 time = 130
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=130.05n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 130
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=130.05n

* CHECK dout0_12 Vdout0_12ck12 = 1.8 time = 130
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=130.05n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 130
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=130.05n

* CHECK dout0_14 Vdout0_14ck12 = 1.8 time = 130
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=130.05n

* CHECK dout0_15 Vdout0_15ck12 = 1.8 time = 130
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=130.05n

* CHECK dout0_16 Vdout0_16ck12 = 0 time = 130
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=130.05n

* CHECK dout0_17 Vdout0_17ck12 = 1.8 time = 130
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=130.05n

* CHECK dout0_18 Vdout0_18ck12 = 0 time = 130
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=130.05n

* CHECK dout0_19 Vdout0_19ck12 = 0 time = 130
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=130.05n

* CHECK dout0_20 Vdout0_20ck12 = 1.8 time = 130
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=130.05n

* CHECK dout0_21 Vdout0_21ck12 = 0 time = 130
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=130.05n

* CHECK dout0_22 Vdout0_22ck12 = 1.8 time = 130
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=130.05n

* CHECK dout0_23 Vdout0_23ck12 = 0 time = 130
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=130.05n

* CHECK dout0_24 Vdout0_24ck12 = 0 time = 130
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=130.05n

* CHECK dout0_25 Vdout0_25ck12 = 0 time = 130
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=130.05n

* CHECK dout0_26 Vdout0_26ck12 = 1.8 time = 130
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=130.05n

* CHECK dout0_27 Vdout0_27ck12 = 0 time = 130
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=130.05n

* CHECK dout0_28 Vdout0_28ck12 = 0 time = 130
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=130.05n

* CHECK dout0_29 Vdout0_29ck12 = 1.8 time = 130
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=130.05n

* CHECK dout0_30 Vdout0_30ck12 = 1.8 time = 130
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=130.05n

* CHECK dout0_31 Vdout0_31ck12 = 1.8 time = 130
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=130.05n

* CHECK dout0_32 Vdout0_32ck12 = 1.8 time = 130
.meas tran vdout0_32ck12 FIND v(dout0_32) AT=130.05n

* CHECK dout0_33 Vdout0_33ck12 = 1.8 time = 130
.meas tran vdout0_33ck12 FIND v(dout0_33) AT=130.05n

* CHECK dout0_34 Vdout0_34ck12 = 0 time = 130
.meas tran vdout0_34ck12 FIND v(dout0_34) AT=130.05n

* CHECK dout0_35 Vdout0_35ck12 = 1.8 time = 130
.meas tran vdout0_35ck12 FIND v(dout0_35) AT=130.05n

* CHECK dout0_36 Vdout0_36ck12 = 1.8 time = 130
.meas tran vdout0_36ck12 FIND v(dout0_36) AT=130.05n

* CHECK dout0_37 Vdout0_37ck12 = 1.8 time = 130
.meas tran vdout0_37ck12 FIND v(dout0_37) AT=130.05n

* CHECK dout0_38 Vdout0_38ck12 = 0 time = 130
.meas tran vdout0_38ck12 FIND v(dout0_38) AT=130.05n

* CHECK dout0_39 Vdout0_39ck12 = 0 time = 130
.meas tran vdout0_39ck12 FIND v(dout0_39) AT=130.05n

* CHECK dout0_40 Vdout0_40ck12 = 1.8 time = 130
.meas tran vdout0_40ck12 FIND v(dout0_40) AT=130.05n

* CHECK dout0_41 Vdout0_41ck12 = 1.8 time = 130
.meas tran vdout0_41ck12 FIND v(dout0_41) AT=130.05n

* CHECK dout0_42 Vdout0_42ck12 = 0 time = 130
.meas tran vdout0_42ck12 FIND v(dout0_42) AT=130.05n

* CHECK dout0_43 Vdout0_43ck12 = 1.8 time = 130
.meas tran vdout0_43ck12 FIND v(dout0_43) AT=130.05n

* CHECK dout0_44 Vdout0_44ck12 = 0 time = 130
.meas tran vdout0_44ck12 FIND v(dout0_44) AT=130.05n

* CHECK dout0_45 Vdout0_45ck12 = 1.8 time = 130
.meas tran vdout0_45ck12 FIND v(dout0_45) AT=130.05n

* CHECK dout0_46 Vdout0_46ck12 = 1.8 time = 130
.meas tran vdout0_46ck12 FIND v(dout0_46) AT=130.05n

* CHECK dout0_47 Vdout0_47ck12 = 1.8 time = 130
.meas tran vdout0_47ck12 FIND v(dout0_47) AT=130.05n

* CHECK dout0_48 Vdout0_48ck12 = 1.8 time = 130
.meas tran vdout0_48ck12 FIND v(dout0_48) AT=130.05n

* CHECK dout0_49 Vdout0_49ck12 = 1.8 time = 130
.meas tran vdout0_49ck12 FIND v(dout0_49) AT=130.05n

* CHECK dout0_50 Vdout0_50ck12 = 1.8 time = 130
.meas tran vdout0_50ck12 FIND v(dout0_50) AT=130.05n

* CHECK dout0_51 Vdout0_51ck12 = 0 time = 130
.meas tran vdout0_51ck12 FIND v(dout0_51) AT=130.05n

* CHECK dout0_52 Vdout0_52ck12 = 1.8 time = 130
.meas tran vdout0_52ck12 FIND v(dout0_52) AT=130.05n

* CHECK dout0_53 Vdout0_53ck12 = 0 time = 130
.meas tran vdout0_53ck12 FIND v(dout0_53) AT=130.05n

* CHECK dout0_54 Vdout0_54ck12 = 1.8 time = 130
.meas tran vdout0_54ck12 FIND v(dout0_54) AT=130.05n

* CHECK dout0_55 Vdout0_55ck12 = 0 time = 130
.meas tran vdout0_55ck12 FIND v(dout0_55) AT=130.05n

* CHECK dout0_56 Vdout0_56ck12 = 1.8 time = 130
.meas tran vdout0_56ck12 FIND v(dout0_56) AT=130.05n

* CHECK dout0_57 Vdout0_57ck12 = 0 time = 130
.meas tran vdout0_57ck12 FIND v(dout0_57) AT=130.05n

* CHECK dout0_58 Vdout0_58ck12 = 1.8 time = 130
.meas tran vdout0_58ck12 FIND v(dout0_58) AT=130.05n

* CHECK dout0_59 Vdout0_59ck12 = 0 time = 130
.meas tran vdout0_59ck12 FIND v(dout0_59) AT=130.05n

* CHECK dout0_60 Vdout0_60ck12 = 0 time = 130
.meas tran vdout0_60ck12 FIND v(dout0_60) AT=130.05n

* CHECK dout0_61 Vdout0_61ck12 = 1.8 time = 130
.meas tran vdout0_61ck12 FIND v(dout0_61) AT=130.05n

* CHECK dout0_62 Vdout0_62ck12 = 1.8 time = 130
.meas tran vdout0_62ck12 FIND v(dout0_62) AT=130.05n

* CHECK dout0_63 Vdout0_63ck12 = 1.8 time = 130
.meas tran vdout0_63ck12 FIND v(dout0_63) AT=130.05n

* CHECK dout0_64 Vdout0_64ck12 = 0 time = 130
.meas tran vdout0_64ck12 FIND v(dout0_64) AT=130.05n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 180
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=180.05n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 180
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=180.05n

* CHECK dout0_2 Vdout0_2ck17 = 1.8 time = 180
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=180.05n

* CHECK dout0_3 Vdout0_3ck17 = 1.8 time = 180
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=180.05n

* CHECK dout0_4 Vdout0_4ck17 = 1.8 time = 180
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=180.05n

* CHECK dout0_5 Vdout0_5ck17 = 1.8 time = 180
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=180.05n

* CHECK dout0_6 Vdout0_6ck17 = 0 time = 180
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=180.05n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 180
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=180.05n

* CHECK dout0_8 Vdout0_8ck17 = 1.8 time = 180
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=180.05n

* CHECK dout0_9 Vdout0_9ck17 = 1.8 time = 180
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=180.05n

* CHECK dout0_10 Vdout0_10ck17 = 1.8 time = 180
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=180.05n

* CHECK dout0_11 Vdout0_11ck17 = 1.8 time = 180
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=180.05n

* CHECK dout0_12 Vdout0_12ck17 = 1.8 time = 180
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=180.05n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 180
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=180.05n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 180
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=180.05n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 180
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=180.05n

* CHECK dout0_16 Vdout0_16ck17 = 0 time = 180
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=180.05n

* CHECK dout0_17 Vdout0_17ck17 = 0 time = 180
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=180.05n

* CHECK dout0_18 Vdout0_18ck17 = 0 time = 180
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=180.05n

* CHECK dout0_19 Vdout0_19ck17 = 0 time = 180
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=180.05n

* CHECK dout0_20 Vdout0_20ck17 = 0 time = 180
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=180.05n

* CHECK dout0_21 Vdout0_21ck17 = 0 time = 180
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=180.05n

* CHECK dout0_22 Vdout0_22ck17 = 0 time = 180
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=180.05n

* CHECK dout0_23 Vdout0_23ck17 = 1.8 time = 180
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=180.05n

* CHECK dout0_24 Vdout0_24ck17 = 1.8 time = 180
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=180.05n

* CHECK dout0_25 Vdout0_25ck17 = 0 time = 180
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=180.05n

* CHECK dout0_26 Vdout0_26ck17 = 0 time = 180
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=180.05n

* CHECK dout0_27 Vdout0_27ck17 = 1.8 time = 180
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=180.05n

* CHECK dout0_28 Vdout0_28ck17 = 1.8 time = 180
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=180.05n

* CHECK dout0_29 Vdout0_29ck17 = 0 time = 180
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=180.05n

* CHECK dout0_30 Vdout0_30ck17 = 0 time = 180
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=180.05n

* CHECK dout0_31 Vdout0_31ck17 = 1.8 time = 180
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=180.05n

* CHECK dout0_32 Vdout0_32ck17 = 1.8 time = 180
.meas tran vdout0_32ck17 FIND v(dout0_32) AT=180.05n

* CHECK dout0_33 Vdout0_33ck17 = 1.8 time = 180
.meas tran vdout0_33ck17 FIND v(dout0_33) AT=180.05n

* CHECK dout0_34 Vdout0_34ck17 = 0 time = 180
.meas tran vdout0_34ck17 FIND v(dout0_34) AT=180.05n

* CHECK dout0_35 Vdout0_35ck17 = 0 time = 180
.meas tran vdout0_35ck17 FIND v(dout0_35) AT=180.05n

* CHECK dout0_36 Vdout0_36ck17 = 1.8 time = 180
.meas tran vdout0_36ck17 FIND v(dout0_36) AT=180.05n

* CHECK dout0_37 Vdout0_37ck17 = 0 time = 180
.meas tran vdout0_37ck17 FIND v(dout0_37) AT=180.05n

* CHECK dout0_38 Vdout0_38ck17 = 0 time = 180
.meas tran vdout0_38ck17 FIND v(dout0_38) AT=180.05n

* CHECK dout0_39 Vdout0_39ck17 = 1.8 time = 180
.meas tran vdout0_39ck17 FIND v(dout0_39) AT=180.05n

* CHECK dout0_40 Vdout0_40ck17 = 1.8 time = 180
.meas tran vdout0_40ck17 FIND v(dout0_40) AT=180.05n

* CHECK dout0_41 Vdout0_41ck17 = 1.8 time = 180
.meas tran vdout0_41ck17 FIND v(dout0_41) AT=180.05n

* CHECK dout0_42 Vdout0_42ck17 = 0 time = 180
.meas tran vdout0_42ck17 FIND v(dout0_42) AT=180.05n

* CHECK dout0_43 Vdout0_43ck17 = 1.8 time = 180
.meas tran vdout0_43ck17 FIND v(dout0_43) AT=180.05n

* CHECK dout0_44 Vdout0_44ck17 = 1.8 time = 180
.meas tran vdout0_44ck17 FIND v(dout0_44) AT=180.05n

* CHECK dout0_45 Vdout0_45ck17 = 0 time = 180
.meas tran vdout0_45ck17 FIND v(dout0_45) AT=180.05n

* CHECK dout0_46 Vdout0_46ck17 = 1.8 time = 180
.meas tran vdout0_46ck17 FIND v(dout0_46) AT=180.05n

* CHECK dout0_47 Vdout0_47ck17 = 1.8 time = 180
.meas tran vdout0_47ck17 FIND v(dout0_47) AT=180.05n

* CHECK dout0_48 Vdout0_48ck17 = 0 time = 180
.meas tran vdout0_48ck17 FIND v(dout0_48) AT=180.05n

* CHECK dout0_49 Vdout0_49ck17 = 0 time = 180
.meas tran vdout0_49ck17 FIND v(dout0_49) AT=180.05n

* CHECK dout0_50 Vdout0_50ck17 = 0 time = 180
.meas tran vdout0_50ck17 FIND v(dout0_50) AT=180.05n

* CHECK dout0_51 Vdout0_51ck17 = 0 time = 180
.meas tran vdout0_51ck17 FIND v(dout0_51) AT=180.05n

* CHECK dout0_52 Vdout0_52ck17 = 1.8 time = 180
.meas tran vdout0_52ck17 FIND v(dout0_52) AT=180.05n

* CHECK dout0_53 Vdout0_53ck17 = 1.8 time = 180
.meas tran vdout0_53ck17 FIND v(dout0_53) AT=180.05n

* CHECK dout0_54 Vdout0_54ck17 = 0 time = 180
.meas tran vdout0_54ck17 FIND v(dout0_54) AT=180.05n

* CHECK dout0_55 Vdout0_55ck17 = 1.8 time = 180
.meas tran vdout0_55ck17 FIND v(dout0_55) AT=180.05n

* CHECK dout0_56 Vdout0_56ck17 = 1.8 time = 180
.meas tran vdout0_56ck17 FIND v(dout0_56) AT=180.05n

* CHECK dout0_57 Vdout0_57ck17 = 1.8 time = 180
.meas tran vdout0_57ck17 FIND v(dout0_57) AT=180.05n

* CHECK dout0_58 Vdout0_58ck17 = 1.8 time = 180
.meas tran vdout0_58ck17 FIND v(dout0_58) AT=180.05n

* CHECK dout0_59 Vdout0_59ck17 = 1.8 time = 180
.meas tran vdout0_59ck17 FIND v(dout0_59) AT=180.05n

* CHECK dout0_60 Vdout0_60ck17 = 0 time = 180
.meas tran vdout0_60ck17 FIND v(dout0_60) AT=180.05n

* CHECK dout0_61 Vdout0_61ck17 = 1.8 time = 180
.meas tran vdout0_61ck17 FIND v(dout0_61) AT=180.05n

* CHECK dout0_62 Vdout0_62ck17 = 0 time = 180
.meas tran vdout0_62ck17 FIND v(dout0_62) AT=180.05n

* CHECK dout0_63 Vdout0_63ck17 = 1.8 time = 180
.meas tran vdout0_63ck17 FIND v(dout0_63) AT=180.05n

* CHECK dout0_64 Vdout0_64ck17 = 0 time = 180
.meas tran vdout0_64ck17 FIND v(dout0_64) AT=180.05n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 200
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=200.05n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 200
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=200.05n

* CHECK dout0_2 Vdout0_2ck19 = 1.8 time = 200
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=200.05n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 200
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=200.05n

* CHECK dout0_4 Vdout0_4ck19 = 1.8 time = 200
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=200.05n

* CHECK dout0_5 Vdout0_5ck19 = 1.8 time = 200
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=200.05n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 200
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=200.05n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 200
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=200.05n

* CHECK dout0_8 Vdout0_8ck19 = 1.8 time = 200
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=200.05n

* CHECK dout0_9 Vdout0_9ck19 = 1.8 time = 200
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=200.05n

* CHECK dout0_10 Vdout0_10ck19 = 1.8 time = 200
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=200.05n

* CHECK dout0_11 Vdout0_11ck19 = 1.8 time = 200
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=200.05n

* CHECK dout0_12 Vdout0_12ck19 = 1.8 time = 200
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=200.05n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 200
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=200.05n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 200
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=200.05n

* CHECK dout0_15 Vdout0_15ck19 = 0 time = 200
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=200.05n

* CHECK dout0_16 Vdout0_16ck19 = 0 time = 200
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=200.05n

* CHECK dout0_17 Vdout0_17ck19 = 0 time = 200
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=200.05n

* CHECK dout0_18 Vdout0_18ck19 = 0 time = 200
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=200.05n

* CHECK dout0_19 Vdout0_19ck19 = 0 time = 200
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=200.05n

* CHECK dout0_20 Vdout0_20ck19 = 0 time = 200
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=200.05n

* CHECK dout0_21 Vdout0_21ck19 = 0 time = 200
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=200.05n

* CHECK dout0_22 Vdout0_22ck19 = 0 time = 200
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=200.05n

* CHECK dout0_23 Vdout0_23ck19 = 1.8 time = 200
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=200.05n

* CHECK dout0_24 Vdout0_24ck19 = 1.8 time = 200
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=200.05n

* CHECK dout0_25 Vdout0_25ck19 = 0 time = 200
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=200.05n

* CHECK dout0_26 Vdout0_26ck19 = 0 time = 200
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=200.05n

* CHECK dout0_27 Vdout0_27ck19 = 1.8 time = 200
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=200.05n

* CHECK dout0_28 Vdout0_28ck19 = 1.8 time = 200
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=200.05n

* CHECK dout0_29 Vdout0_29ck19 = 0 time = 200
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=200.05n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 200
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=200.05n

* CHECK dout0_31 Vdout0_31ck19 = 1.8 time = 200
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=200.05n

* CHECK dout0_32 Vdout0_32ck19 = 1.8 time = 200
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=200.05n

* CHECK dout0_33 Vdout0_33ck19 = 1.8 time = 200
.meas tran vdout0_33ck19 FIND v(dout0_33) AT=200.05n

* CHECK dout0_34 Vdout0_34ck19 = 0 time = 200
.meas tran vdout0_34ck19 FIND v(dout0_34) AT=200.05n

* CHECK dout0_35 Vdout0_35ck19 = 0 time = 200
.meas tran vdout0_35ck19 FIND v(dout0_35) AT=200.05n

* CHECK dout0_36 Vdout0_36ck19 = 1.8 time = 200
.meas tran vdout0_36ck19 FIND v(dout0_36) AT=200.05n

* CHECK dout0_37 Vdout0_37ck19 = 0 time = 200
.meas tran vdout0_37ck19 FIND v(dout0_37) AT=200.05n

* CHECK dout0_38 Vdout0_38ck19 = 0 time = 200
.meas tran vdout0_38ck19 FIND v(dout0_38) AT=200.05n

* CHECK dout0_39 Vdout0_39ck19 = 1.8 time = 200
.meas tran vdout0_39ck19 FIND v(dout0_39) AT=200.05n

* CHECK dout0_40 Vdout0_40ck19 = 1.8 time = 200
.meas tran vdout0_40ck19 FIND v(dout0_40) AT=200.05n

* CHECK dout0_41 Vdout0_41ck19 = 1.8 time = 200
.meas tran vdout0_41ck19 FIND v(dout0_41) AT=200.05n

* CHECK dout0_42 Vdout0_42ck19 = 0 time = 200
.meas tran vdout0_42ck19 FIND v(dout0_42) AT=200.05n

* CHECK dout0_43 Vdout0_43ck19 = 1.8 time = 200
.meas tran vdout0_43ck19 FIND v(dout0_43) AT=200.05n

* CHECK dout0_44 Vdout0_44ck19 = 1.8 time = 200
.meas tran vdout0_44ck19 FIND v(dout0_44) AT=200.05n

* CHECK dout0_45 Vdout0_45ck19 = 0 time = 200
.meas tran vdout0_45ck19 FIND v(dout0_45) AT=200.05n

* CHECK dout0_46 Vdout0_46ck19 = 1.8 time = 200
.meas tran vdout0_46ck19 FIND v(dout0_46) AT=200.05n

* CHECK dout0_47 Vdout0_47ck19 = 1.8 time = 200
.meas tran vdout0_47ck19 FIND v(dout0_47) AT=200.05n

* CHECK dout0_48 Vdout0_48ck19 = 0 time = 200
.meas tran vdout0_48ck19 FIND v(dout0_48) AT=200.05n

* CHECK dout0_49 Vdout0_49ck19 = 0 time = 200
.meas tran vdout0_49ck19 FIND v(dout0_49) AT=200.05n

* CHECK dout0_50 Vdout0_50ck19 = 0 time = 200
.meas tran vdout0_50ck19 FIND v(dout0_50) AT=200.05n

* CHECK dout0_51 Vdout0_51ck19 = 0 time = 200
.meas tran vdout0_51ck19 FIND v(dout0_51) AT=200.05n

* CHECK dout0_52 Vdout0_52ck19 = 1.8 time = 200
.meas tran vdout0_52ck19 FIND v(dout0_52) AT=200.05n

* CHECK dout0_53 Vdout0_53ck19 = 1.8 time = 200
.meas tran vdout0_53ck19 FIND v(dout0_53) AT=200.05n

* CHECK dout0_54 Vdout0_54ck19 = 0 time = 200
.meas tran vdout0_54ck19 FIND v(dout0_54) AT=200.05n

* CHECK dout0_55 Vdout0_55ck19 = 1.8 time = 200
.meas tran vdout0_55ck19 FIND v(dout0_55) AT=200.05n

* CHECK dout0_56 Vdout0_56ck19 = 1.8 time = 200
.meas tran vdout0_56ck19 FIND v(dout0_56) AT=200.05n

* CHECK dout0_57 Vdout0_57ck19 = 1.8 time = 200
.meas tran vdout0_57ck19 FIND v(dout0_57) AT=200.05n

* CHECK dout0_58 Vdout0_58ck19 = 1.8 time = 200
.meas tran vdout0_58ck19 FIND v(dout0_58) AT=200.05n

* CHECK dout0_59 Vdout0_59ck19 = 1.8 time = 200
.meas tran vdout0_59ck19 FIND v(dout0_59) AT=200.05n

* CHECK dout0_60 Vdout0_60ck19 = 0 time = 200
.meas tran vdout0_60ck19 FIND v(dout0_60) AT=200.05n

* CHECK dout0_61 Vdout0_61ck19 = 1.8 time = 200
.meas tran vdout0_61ck19 FIND v(dout0_61) AT=200.05n

* CHECK dout0_62 Vdout0_62ck19 = 0 time = 200
.meas tran vdout0_62ck19 FIND v(dout0_62) AT=200.05n

* CHECK dout0_63 Vdout0_63ck19 = 1.8 time = 200
.meas tran vdout0_63ck19 FIND v(dout0_63) AT=200.05n

* CHECK dout0_64 Vdout0_64ck19 = 0 time = 200
.meas tran vdout0_64ck19 FIND v(dout0_64) AT=200.05n

* CHECK dout0_0 Vdout0_0ck20 = 1.8 time = 210
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=210.05n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 210
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=210.05n

* CHECK dout0_2 Vdout0_2ck20 = 0 time = 210
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=210.05n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 210
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=210.05n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 210
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=210.05n

* CHECK dout0_5 Vdout0_5ck20 = 1.8 time = 210
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=210.05n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 210
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=210.05n

* CHECK dout0_7 Vdout0_7ck20 = 1.8 time = 210
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=210.05n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 210
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=210.05n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 210
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=210.05n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 210
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=210.05n

* CHECK dout0_11 Vdout0_11ck20 = 0 time = 210
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=210.05n

* CHECK dout0_12 Vdout0_12ck20 = 1.8 time = 210
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=210.05n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 210
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=210.05n

* CHECK dout0_14 Vdout0_14ck20 = 1.8 time = 210
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=210.05n

* CHECK dout0_15 Vdout0_15ck20 = 1.8 time = 210
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=210.05n

* CHECK dout0_16 Vdout0_16ck20 = 0 time = 210
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=210.05n

* CHECK dout0_17 Vdout0_17ck20 = 1.8 time = 210
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=210.05n

* CHECK dout0_18 Vdout0_18ck20 = 0 time = 210
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=210.05n

* CHECK dout0_19 Vdout0_19ck20 = 0 time = 210
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=210.05n

* CHECK dout0_20 Vdout0_20ck20 = 1.8 time = 210
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=210.05n

* CHECK dout0_21 Vdout0_21ck20 = 0 time = 210
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=210.05n

* CHECK dout0_22 Vdout0_22ck20 = 1.8 time = 210
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=210.05n

* CHECK dout0_23 Vdout0_23ck20 = 0 time = 210
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=210.05n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 210
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=210.05n

* CHECK dout0_25 Vdout0_25ck20 = 0 time = 210
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=210.05n

* CHECK dout0_26 Vdout0_26ck20 = 1.8 time = 210
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=210.05n

* CHECK dout0_27 Vdout0_27ck20 = 0 time = 210
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=210.05n

* CHECK dout0_28 Vdout0_28ck20 = 0 time = 210
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=210.05n

* CHECK dout0_29 Vdout0_29ck20 = 1.8 time = 210
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=210.05n

* CHECK dout0_30 Vdout0_30ck20 = 1.8 time = 210
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=210.05n

* CHECK dout0_31 Vdout0_31ck20 = 1.8 time = 210
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=210.05n

* CHECK dout0_32 Vdout0_32ck20 = 1.8 time = 210
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=210.05n

* CHECK dout0_33 Vdout0_33ck20 = 1.8 time = 210
.meas tran vdout0_33ck20 FIND v(dout0_33) AT=210.05n

* CHECK dout0_34 Vdout0_34ck20 = 0 time = 210
.meas tran vdout0_34ck20 FIND v(dout0_34) AT=210.05n

* CHECK dout0_35 Vdout0_35ck20 = 1.8 time = 210
.meas tran vdout0_35ck20 FIND v(dout0_35) AT=210.05n

* CHECK dout0_36 Vdout0_36ck20 = 1.8 time = 210
.meas tran vdout0_36ck20 FIND v(dout0_36) AT=210.05n

* CHECK dout0_37 Vdout0_37ck20 = 1.8 time = 210
.meas tran vdout0_37ck20 FIND v(dout0_37) AT=210.05n

* CHECK dout0_38 Vdout0_38ck20 = 0 time = 210
.meas tran vdout0_38ck20 FIND v(dout0_38) AT=210.05n

* CHECK dout0_39 Vdout0_39ck20 = 0 time = 210
.meas tran vdout0_39ck20 FIND v(dout0_39) AT=210.05n

* CHECK dout0_40 Vdout0_40ck20 = 1.8 time = 210
.meas tran vdout0_40ck20 FIND v(dout0_40) AT=210.05n

* CHECK dout0_41 Vdout0_41ck20 = 1.8 time = 210
.meas tran vdout0_41ck20 FIND v(dout0_41) AT=210.05n

* CHECK dout0_42 Vdout0_42ck20 = 0 time = 210
.meas tran vdout0_42ck20 FIND v(dout0_42) AT=210.05n

* CHECK dout0_43 Vdout0_43ck20 = 1.8 time = 210
.meas tran vdout0_43ck20 FIND v(dout0_43) AT=210.05n

* CHECK dout0_44 Vdout0_44ck20 = 0 time = 210
.meas tran vdout0_44ck20 FIND v(dout0_44) AT=210.05n

* CHECK dout0_45 Vdout0_45ck20 = 1.8 time = 210
.meas tran vdout0_45ck20 FIND v(dout0_45) AT=210.05n

* CHECK dout0_46 Vdout0_46ck20 = 1.8 time = 210
.meas tran vdout0_46ck20 FIND v(dout0_46) AT=210.05n

* CHECK dout0_47 Vdout0_47ck20 = 1.8 time = 210
.meas tran vdout0_47ck20 FIND v(dout0_47) AT=210.05n

* CHECK dout0_48 Vdout0_48ck20 = 1.8 time = 210
.meas tran vdout0_48ck20 FIND v(dout0_48) AT=210.05n

* CHECK dout0_49 Vdout0_49ck20 = 1.8 time = 210
.meas tran vdout0_49ck20 FIND v(dout0_49) AT=210.05n

* CHECK dout0_50 Vdout0_50ck20 = 1.8 time = 210
.meas tran vdout0_50ck20 FIND v(dout0_50) AT=210.05n

* CHECK dout0_51 Vdout0_51ck20 = 0 time = 210
.meas tran vdout0_51ck20 FIND v(dout0_51) AT=210.05n

* CHECK dout0_52 Vdout0_52ck20 = 1.8 time = 210
.meas tran vdout0_52ck20 FIND v(dout0_52) AT=210.05n

* CHECK dout0_53 Vdout0_53ck20 = 0 time = 210
.meas tran vdout0_53ck20 FIND v(dout0_53) AT=210.05n

* CHECK dout0_54 Vdout0_54ck20 = 1.8 time = 210
.meas tran vdout0_54ck20 FIND v(dout0_54) AT=210.05n

* CHECK dout0_55 Vdout0_55ck20 = 0 time = 210
.meas tran vdout0_55ck20 FIND v(dout0_55) AT=210.05n

* CHECK dout0_56 Vdout0_56ck20 = 1.8 time = 210
.meas tran vdout0_56ck20 FIND v(dout0_56) AT=210.05n

* CHECK dout0_57 Vdout0_57ck20 = 0 time = 210
.meas tran vdout0_57ck20 FIND v(dout0_57) AT=210.05n

* CHECK dout0_58 Vdout0_58ck20 = 1.8 time = 210
.meas tran vdout0_58ck20 FIND v(dout0_58) AT=210.05n

* CHECK dout0_59 Vdout0_59ck20 = 0 time = 210
.meas tran vdout0_59ck20 FIND v(dout0_59) AT=210.05n

* CHECK dout0_60 Vdout0_60ck20 = 0 time = 210
.meas tran vdout0_60ck20 FIND v(dout0_60) AT=210.05n

* CHECK dout0_61 Vdout0_61ck20 = 1.8 time = 210
.meas tran vdout0_61ck20 FIND v(dout0_61) AT=210.05n

* CHECK dout0_62 Vdout0_62ck20 = 1.8 time = 210
.meas tran vdout0_62ck20 FIND v(dout0_62) AT=210.05n

* CHECK dout0_63 Vdout0_63ck20 = 1.8 time = 210
.meas tran vdout0_63ck20 FIND v(dout0_63) AT=210.05n

* CHECK dout0_64 Vdout0_64ck20 = 0 time = 210
.meas tran vdout0_64ck20 FIND v(dout0_64) AT=210.05n

* CHECK dout0_0 Vdout0_0ck23 = 1.8 time = 240
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=240.05n

* CHECK dout0_1 Vdout0_1ck23 = 0 time = 240
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=240.05n

* CHECK dout0_2 Vdout0_2ck23 = 1.8 time = 240
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=240.05n

* CHECK dout0_3 Vdout0_3ck23 = 1.8 time = 240
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=240.05n

* CHECK dout0_4 Vdout0_4ck23 = 0 time = 240
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=240.05n

* CHECK dout0_5 Vdout0_5ck23 = 1.8 time = 240
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=240.05n

* CHECK dout0_6 Vdout0_6ck23 = 1.8 time = 240
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=240.05n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 240
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=240.05n

* CHECK dout0_8 Vdout0_8ck23 = 1.8 time = 240
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=240.05n

* CHECK dout0_9 Vdout0_9ck23 = 1.8 time = 240
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=240.05n

* CHECK dout0_10 Vdout0_10ck23 = 1.8 time = 240
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=240.05n

* CHECK dout0_11 Vdout0_11ck23 = 0 time = 240
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=240.05n

* CHECK dout0_12 Vdout0_12ck23 = 1.8 time = 240
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=240.05n

* CHECK dout0_13 Vdout0_13ck23 = 0 time = 240
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=240.05n

* CHECK dout0_14 Vdout0_14ck23 = 1.8 time = 240
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=240.05n

* CHECK dout0_15 Vdout0_15ck23 = 1.8 time = 240
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=240.05n

* CHECK dout0_16 Vdout0_16ck23 = 1.8 time = 240
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=240.05n

* CHECK dout0_17 Vdout0_17ck23 = 0 time = 240
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=240.05n

* CHECK dout0_18 Vdout0_18ck23 = 0 time = 240
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=240.05n

* CHECK dout0_19 Vdout0_19ck23 = 0 time = 240
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=240.05n

* CHECK dout0_20 Vdout0_20ck23 = 1.8 time = 240
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=240.05n

* CHECK dout0_21 Vdout0_21ck23 = 0 time = 240
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=240.05n

* CHECK dout0_22 Vdout0_22ck23 = 0 time = 240
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=240.05n

* CHECK dout0_23 Vdout0_23ck23 = 1.8 time = 240
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=240.05n

* CHECK dout0_24 Vdout0_24ck23 = 0 time = 240
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=240.05n

* CHECK dout0_25 Vdout0_25ck23 = 0 time = 240
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=240.05n

* CHECK dout0_26 Vdout0_26ck23 = 1.8 time = 240
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=240.05n

* CHECK dout0_27 Vdout0_27ck23 = 0 time = 240
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=240.05n

* CHECK dout0_28 Vdout0_28ck23 = 1.8 time = 240
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=240.05n

* CHECK dout0_29 Vdout0_29ck23 = 0 time = 240
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=240.05n

* CHECK dout0_30 Vdout0_30ck23 = 1.8 time = 240
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=240.05n

* CHECK dout0_31 Vdout0_31ck23 = 1.8 time = 240
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=240.05n

* CHECK dout0_32 Vdout0_32ck23 = 0 time = 240
.meas tran vdout0_32ck23 FIND v(dout0_32) AT=240.05n

* CHECK dout0_33 Vdout0_33ck23 = 0 time = 240
.meas tran vdout0_33ck23 FIND v(dout0_33) AT=240.05n

* CHECK dout0_34 Vdout0_34ck23 = 1.8 time = 240
.meas tran vdout0_34ck23 FIND v(dout0_34) AT=240.05n

* CHECK dout0_35 Vdout0_35ck23 = 0 time = 240
.meas tran vdout0_35ck23 FIND v(dout0_35) AT=240.05n

* CHECK dout0_36 Vdout0_36ck23 = 0 time = 240
.meas tran vdout0_36ck23 FIND v(dout0_36) AT=240.05n

* CHECK dout0_37 Vdout0_37ck23 = 1.8 time = 240
.meas tran vdout0_37ck23 FIND v(dout0_37) AT=240.05n

* CHECK dout0_38 Vdout0_38ck23 = 0 time = 240
.meas tran vdout0_38ck23 FIND v(dout0_38) AT=240.05n

* CHECK dout0_39 Vdout0_39ck23 = 1.8 time = 240
.meas tran vdout0_39ck23 FIND v(dout0_39) AT=240.05n

* CHECK dout0_40 Vdout0_40ck23 = 0 time = 240
.meas tran vdout0_40ck23 FIND v(dout0_40) AT=240.05n

* CHECK dout0_41 Vdout0_41ck23 = 1.8 time = 240
.meas tran vdout0_41ck23 FIND v(dout0_41) AT=240.05n

* CHECK dout0_42 Vdout0_42ck23 = 0 time = 240
.meas tran vdout0_42ck23 FIND v(dout0_42) AT=240.05n

* CHECK dout0_43 Vdout0_43ck23 = 1.8 time = 240
.meas tran vdout0_43ck23 FIND v(dout0_43) AT=240.05n

* CHECK dout0_44 Vdout0_44ck23 = 0 time = 240
.meas tran vdout0_44ck23 FIND v(dout0_44) AT=240.05n

* CHECK dout0_45 Vdout0_45ck23 = 0 time = 240
.meas tran vdout0_45ck23 FIND v(dout0_45) AT=240.05n

* CHECK dout0_46 Vdout0_46ck23 = 0 time = 240
.meas tran vdout0_46ck23 FIND v(dout0_46) AT=240.05n

* CHECK dout0_47 Vdout0_47ck23 = 1.8 time = 240
.meas tran vdout0_47ck23 FIND v(dout0_47) AT=240.05n

* CHECK dout0_48 Vdout0_48ck23 = 0 time = 240
.meas tran vdout0_48ck23 FIND v(dout0_48) AT=240.05n

* CHECK dout0_49 Vdout0_49ck23 = 1.8 time = 240
.meas tran vdout0_49ck23 FIND v(dout0_49) AT=240.05n

* CHECK dout0_50 Vdout0_50ck23 = 0 time = 240
.meas tran vdout0_50ck23 FIND v(dout0_50) AT=240.05n

* CHECK dout0_51 Vdout0_51ck23 = 0 time = 240
.meas tran vdout0_51ck23 FIND v(dout0_51) AT=240.05n

* CHECK dout0_52 Vdout0_52ck23 = 0 time = 240
.meas tran vdout0_52ck23 FIND v(dout0_52) AT=240.05n

* CHECK dout0_53 Vdout0_53ck23 = 0 time = 240
.meas tran vdout0_53ck23 FIND v(dout0_53) AT=240.05n

* CHECK dout0_54 Vdout0_54ck23 = 0 time = 240
.meas tran vdout0_54ck23 FIND v(dout0_54) AT=240.05n

* CHECK dout0_55 Vdout0_55ck23 = 0 time = 240
.meas tran vdout0_55ck23 FIND v(dout0_55) AT=240.05n

* CHECK dout0_56 Vdout0_56ck23 = 0 time = 240
.meas tran vdout0_56ck23 FIND v(dout0_56) AT=240.05n

* CHECK dout0_57 Vdout0_57ck23 = 1.8 time = 240
.meas tran vdout0_57ck23 FIND v(dout0_57) AT=240.05n

* CHECK dout0_58 Vdout0_58ck23 = 0 time = 240
.meas tran vdout0_58ck23 FIND v(dout0_58) AT=240.05n

* CHECK dout0_59 Vdout0_59ck23 = 0 time = 240
.meas tran vdout0_59ck23 FIND v(dout0_59) AT=240.05n

* CHECK dout0_60 Vdout0_60ck23 = 1.8 time = 240
.meas tran vdout0_60ck23 FIND v(dout0_60) AT=240.05n

* CHECK dout0_61 Vdout0_61ck23 = 1.8 time = 240
.meas tran vdout0_61ck23 FIND v(dout0_61) AT=240.05n

* CHECK dout0_62 Vdout0_62ck23 = 1.8 time = 240
.meas tran vdout0_62ck23 FIND v(dout0_62) AT=240.05n

* CHECK dout0_63 Vdout0_63ck23 = 1.8 time = 240
.meas tran vdout0_63ck23 FIND v(dout0_63) AT=240.05n

* CHECK dout0_64 Vdout0_64ck23 = 0 time = 240
.meas tran vdout0_64ck23 FIND v(dout0_64) AT=240.05n

* CHECK dout0_0 Vdout0_0ck25 = 0 time = 260
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=260.05n

* CHECK dout0_1 Vdout0_1ck25 = 0 time = 260
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=260.05n

* CHECK dout0_2 Vdout0_2ck25 = 1.8 time = 260
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=260.05n

* CHECK dout0_3 Vdout0_3ck25 = 1.8 time = 260
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=260.05n

* CHECK dout0_4 Vdout0_4ck25 = 1.8 time = 260
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=260.05n

* CHECK dout0_5 Vdout0_5ck25 = 1.8 time = 260
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=260.05n

* CHECK dout0_6 Vdout0_6ck25 = 0 time = 260
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=260.05n

* CHECK dout0_7 Vdout0_7ck25 = 0 time = 260
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=260.05n

* CHECK dout0_8 Vdout0_8ck25 = 1.8 time = 260
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=260.05n

* CHECK dout0_9 Vdout0_9ck25 = 1.8 time = 260
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=260.05n

* CHECK dout0_10 Vdout0_10ck25 = 1.8 time = 260
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=260.05n

* CHECK dout0_11 Vdout0_11ck25 = 1.8 time = 260
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=260.05n

* CHECK dout0_12 Vdout0_12ck25 = 1.8 time = 260
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=260.05n

* CHECK dout0_13 Vdout0_13ck25 = 0 time = 260
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=260.05n

* CHECK dout0_14 Vdout0_14ck25 = 0 time = 260
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=260.05n

* CHECK dout0_15 Vdout0_15ck25 = 0 time = 260
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=260.05n

* CHECK dout0_16 Vdout0_16ck25 = 0 time = 260
.meas tran vdout0_16ck25 FIND v(dout0_16) AT=260.05n

* CHECK dout0_17 Vdout0_17ck25 = 0 time = 260
.meas tran vdout0_17ck25 FIND v(dout0_17) AT=260.05n

* CHECK dout0_18 Vdout0_18ck25 = 0 time = 260
.meas tran vdout0_18ck25 FIND v(dout0_18) AT=260.05n

* CHECK dout0_19 Vdout0_19ck25 = 0 time = 260
.meas tran vdout0_19ck25 FIND v(dout0_19) AT=260.05n

* CHECK dout0_20 Vdout0_20ck25 = 0 time = 260
.meas tran vdout0_20ck25 FIND v(dout0_20) AT=260.05n

* CHECK dout0_21 Vdout0_21ck25 = 0 time = 260
.meas tran vdout0_21ck25 FIND v(dout0_21) AT=260.05n

* CHECK dout0_22 Vdout0_22ck25 = 0 time = 260
.meas tran vdout0_22ck25 FIND v(dout0_22) AT=260.05n

* CHECK dout0_23 Vdout0_23ck25 = 1.8 time = 260
.meas tran vdout0_23ck25 FIND v(dout0_23) AT=260.05n

* CHECK dout0_24 Vdout0_24ck25 = 1.8 time = 260
.meas tran vdout0_24ck25 FIND v(dout0_24) AT=260.05n

* CHECK dout0_25 Vdout0_25ck25 = 0 time = 260
.meas tran vdout0_25ck25 FIND v(dout0_25) AT=260.05n

* CHECK dout0_26 Vdout0_26ck25 = 0 time = 260
.meas tran vdout0_26ck25 FIND v(dout0_26) AT=260.05n

* CHECK dout0_27 Vdout0_27ck25 = 1.8 time = 260
.meas tran vdout0_27ck25 FIND v(dout0_27) AT=260.05n

* CHECK dout0_28 Vdout0_28ck25 = 1.8 time = 260
.meas tran vdout0_28ck25 FIND v(dout0_28) AT=260.05n

* CHECK dout0_29 Vdout0_29ck25 = 0 time = 260
.meas tran vdout0_29ck25 FIND v(dout0_29) AT=260.05n

* CHECK dout0_30 Vdout0_30ck25 = 0 time = 260
.meas tran vdout0_30ck25 FIND v(dout0_30) AT=260.05n

* CHECK dout0_31 Vdout0_31ck25 = 1.8 time = 260
.meas tran vdout0_31ck25 FIND v(dout0_31) AT=260.05n

* CHECK dout0_32 Vdout0_32ck25 = 1.8 time = 260
.meas tran vdout0_32ck25 FIND v(dout0_32) AT=260.05n

* CHECK dout0_33 Vdout0_33ck25 = 1.8 time = 260
.meas tran vdout0_33ck25 FIND v(dout0_33) AT=260.05n

* CHECK dout0_34 Vdout0_34ck25 = 0 time = 260
.meas tran vdout0_34ck25 FIND v(dout0_34) AT=260.05n

* CHECK dout0_35 Vdout0_35ck25 = 0 time = 260
.meas tran vdout0_35ck25 FIND v(dout0_35) AT=260.05n

* CHECK dout0_36 Vdout0_36ck25 = 1.8 time = 260
.meas tran vdout0_36ck25 FIND v(dout0_36) AT=260.05n

* CHECK dout0_37 Vdout0_37ck25 = 0 time = 260
.meas tran vdout0_37ck25 FIND v(dout0_37) AT=260.05n

* CHECK dout0_38 Vdout0_38ck25 = 0 time = 260
.meas tran vdout0_38ck25 FIND v(dout0_38) AT=260.05n

* CHECK dout0_39 Vdout0_39ck25 = 1.8 time = 260
.meas tran vdout0_39ck25 FIND v(dout0_39) AT=260.05n

* CHECK dout0_40 Vdout0_40ck25 = 1.8 time = 260
.meas tran vdout0_40ck25 FIND v(dout0_40) AT=260.05n

* CHECK dout0_41 Vdout0_41ck25 = 1.8 time = 260
.meas tran vdout0_41ck25 FIND v(dout0_41) AT=260.05n

* CHECK dout0_42 Vdout0_42ck25 = 0 time = 260
.meas tran vdout0_42ck25 FIND v(dout0_42) AT=260.05n

* CHECK dout0_43 Vdout0_43ck25 = 1.8 time = 260
.meas tran vdout0_43ck25 FIND v(dout0_43) AT=260.05n

* CHECK dout0_44 Vdout0_44ck25 = 1.8 time = 260
.meas tran vdout0_44ck25 FIND v(dout0_44) AT=260.05n

* CHECK dout0_45 Vdout0_45ck25 = 0 time = 260
.meas tran vdout0_45ck25 FIND v(dout0_45) AT=260.05n

* CHECK dout0_46 Vdout0_46ck25 = 1.8 time = 260
.meas tran vdout0_46ck25 FIND v(dout0_46) AT=260.05n

* CHECK dout0_47 Vdout0_47ck25 = 1.8 time = 260
.meas tran vdout0_47ck25 FIND v(dout0_47) AT=260.05n

* CHECK dout0_48 Vdout0_48ck25 = 0 time = 260
.meas tran vdout0_48ck25 FIND v(dout0_48) AT=260.05n

* CHECK dout0_49 Vdout0_49ck25 = 0 time = 260
.meas tran vdout0_49ck25 FIND v(dout0_49) AT=260.05n

* CHECK dout0_50 Vdout0_50ck25 = 0 time = 260
.meas tran vdout0_50ck25 FIND v(dout0_50) AT=260.05n

* CHECK dout0_51 Vdout0_51ck25 = 0 time = 260
.meas tran vdout0_51ck25 FIND v(dout0_51) AT=260.05n

* CHECK dout0_52 Vdout0_52ck25 = 1.8 time = 260
.meas tran vdout0_52ck25 FIND v(dout0_52) AT=260.05n

* CHECK dout0_53 Vdout0_53ck25 = 1.8 time = 260
.meas tran vdout0_53ck25 FIND v(dout0_53) AT=260.05n

* CHECK dout0_54 Vdout0_54ck25 = 0 time = 260
.meas tran vdout0_54ck25 FIND v(dout0_54) AT=260.05n

* CHECK dout0_55 Vdout0_55ck25 = 1.8 time = 260
.meas tran vdout0_55ck25 FIND v(dout0_55) AT=260.05n

* CHECK dout0_56 Vdout0_56ck25 = 1.8 time = 260
.meas tran vdout0_56ck25 FIND v(dout0_56) AT=260.05n

* CHECK dout0_57 Vdout0_57ck25 = 1.8 time = 260
.meas tran vdout0_57ck25 FIND v(dout0_57) AT=260.05n

* CHECK dout0_58 Vdout0_58ck25 = 1.8 time = 260
.meas tran vdout0_58ck25 FIND v(dout0_58) AT=260.05n

* CHECK dout0_59 Vdout0_59ck25 = 1.8 time = 260
.meas tran vdout0_59ck25 FIND v(dout0_59) AT=260.05n

* CHECK dout0_60 Vdout0_60ck25 = 0 time = 260
.meas tran vdout0_60ck25 FIND v(dout0_60) AT=260.05n

* CHECK dout0_61 Vdout0_61ck25 = 1.8 time = 260
.meas tran vdout0_61ck25 FIND v(dout0_61) AT=260.05n

* CHECK dout0_62 Vdout0_62ck25 = 0 time = 260
.meas tran vdout0_62ck25 FIND v(dout0_62) AT=260.05n

* CHECK dout0_63 Vdout0_63ck25 = 1.8 time = 260
.meas tran vdout0_63ck25 FIND v(dout0_63) AT=260.05n

* CHECK dout0_64 Vdout0_64ck25 = 0 time = 260
.meas tran vdout0_64ck25 FIND v(dout0_64) AT=260.05n

* CHECK dout0_0 Vdout0_0ck26 = 1.8 time = 270
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=270.05n

* CHECK dout0_1 Vdout0_1ck26 = 0 time = 270
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=270.05n

* CHECK dout0_2 Vdout0_2ck26 = 1.8 time = 270
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=270.05n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 270
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=270.05n

* CHECK dout0_4 Vdout0_4ck26 = 1.8 time = 270
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=270.05n

* CHECK dout0_5 Vdout0_5ck26 = 1.8 time = 270
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=270.05n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 270
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=270.05n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 270
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=270.05n

* CHECK dout0_8 Vdout0_8ck26 = 0 time = 270
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=270.05n

* CHECK dout0_9 Vdout0_9ck26 = 1.8 time = 270
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=270.05n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 270
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=270.05n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 270
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=270.05n

* CHECK dout0_12 Vdout0_12ck26 = 0 time = 270
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=270.05n

* CHECK dout0_13 Vdout0_13ck26 = 1.8 time = 270
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=270.05n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 270
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=270.05n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 270
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=270.05n

* CHECK dout0_16 Vdout0_16ck26 = 0 time = 270
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=270.05n

* CHECK dout0_17 Vdout0_17ck26 = 1.8 time = 270
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=270.05n

* CHECK dout0_18 Vdout0_18ck26 = 1.8 time = 270
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=270.05n

* CHECK dout0_19 Vdout0_19ck26 = 0 time = 270
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=270.05n

* CHECK dout0_20 Vdout0_20ck26 = 0 time = 270
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=270.05n

* CHECK dout0_21 Vdout0_21ck26 = 0 time = 270
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=270.05n

* CHECK dout0_22 Vdout0_22ck26 = 0 time = 270
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=270.05n

* CHECK dout0_23 Vdout0_23ck26 = 0 time = 270
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=270.05n

* CHECK dout0_24 Vdout0_24ck26 = 0 time = 270
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=270.05n

* CHECK dout0_25 Vdout0_25ck26 = 0 time = 270
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=270.05n

* CHECK dout0_26 Vdout0_26ck26 = 0 time = 270
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=270.05n

* CHECK dout0_27 Vdout0_27ck26 = 1.8 time = 270
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=270.05n

* CHECK dout0_28 Vdout0_28ck26 = 1.8 time = 270
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=270.05n

* CHECK dout0_29 Vdout0_29ck26 = 0 time = 270
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=270.05n

* CHECK dout0_30 Vdout0_30ck26 = 0 time = 270
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=270.05n

* CHECK dout0_31 Vdout0_31ck26 = 0 time = 270
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=270.05n

* CHECK dout0_32 Vdout0_32ck26 = 1.8 time = 270
.meas tran vdout0_32ck26 FIND v(dout0_32) AT=270.05n

* CHECK dout0_33 Vdout0_33ck26 = 1.8 time = 270
.meas tran vdout0_33ck26 FIND v(dout0_33) AT=270.05n

* CHECK dout0_34 Vdout0_34ck26 = 0 time = 270
.meas tran vdout0_34ck26 FIND v(dout0_34) AT=270.05n

* CHECK dout0_35 Vdout0_35ck26 = 0 time = 270
.meas tran vdout0_35ck26 FIND v(dout0_35) AT=270.05n

* CHECK dout0_36 Vdout0_36ck26 = 0 time = 270
.meas tran vdout0_36ck26 FIND v(dout0_36) AT=270.05n

* CHECK dout0_37 Vdout0_37ck26 = 0 time = 270
.meas tran vdout0_37ck26 FIND v(dout0_37) AT=270.05n

* CHECK dout0_38 Vdout0_38ck26 = 1.8 time = 270
.meas tran vdout0_38ck26 FIND v(dout0_38) AT=270.05n

* CHECK dout0_39 Vdout0_39ck26 = 0 time = 270
.meas tran vdout0_39ck26 FIND v(dout0_39) AT=270.05n

* CHECK dout0_40 Vdout0_40ck26 = 0 time = 270
.meas tran vdout0_40ck26 FIND v(dout0_40) AT=270.05n

* CHECK dout0_41 Vdout0_41ck26 = 0 time = 270
.meas tran vdout0_41ck26 FIND v(dout0_41) AT=270.05n

* CHECK dout0_42 Vdout0_42ck26 = 0 time = 270
.meas tran vdout0_42ck26 FIND v(dout0_42) AT=270.05n

* CHECK dout0_43 Vdout0_43ck26 = 1.8 time = 270
.meas tran vdout0_43ck26 FIND v(dout0_43) AT=270.05n

* CHECK dout0_44 Vdout0_44ck26 = 1.8 time = 270
.meas tran vdout0_44ck26 FIND v(dout0_44) AT=270.05n

* CHECK dout0_45 Vdout0_45ck26 = 0 time = 270
.meas tran vdout0_45ck26 FIND v(dout0_45) AT=270.05n

* CHECK dout0_46 Vdout0_46ck26 = 1.8 time = 270
.meas tran vdout0_46ck26 FIND v(dout0_46) AT=270.05n

* CHECK dout0_47 Vdout0_47ck26 = 0 time = 270
.meas tran vdout0_47ck26 FIND v(dout0_47) AT=270.05n

* CHECK dout0_48 Vdout0_48ck26 = 0 time = 270
.meas tran vdout0_48ck26 FIND v(dout0_48) AT=270.05n

* CHECK dout0_49 Vdout0_49ck26 = 0 time = 270
.meas tran vdout0_49ck26 FIND v(dout0_49) AT=270.05n

* CHECK dout0_50 Vdout0_50ck26 = 1.8 time = 270
.meas tran vdout0_50ck26 FIND v(dout0_50) AT=270.05n

* CHECK dout0_51 Vdout0_51ck26 = 0 time = 270
.meas tran vdout0_51ck26 FIND v(dout0_51) AT=270.05n

* CHECK dout0_52 Vdout0_52ck26 = 1.8 time = 270
.meas tran vdout0_52ck26 FIND v(dout0_52) AT=270.05n

* CHECK dout0_53 Vdout0_53ck26 = 1.8 time = 270
.meas tran vdout0_53ck26 FIND v(dout0_53) AT=270.05n

* CHECK dout0_54 Vdout0_54ck26 = 1.8 time = 270
.meas tran vdout0_54ck26 FIND v(dout0_54) AT=270.05n

* CHECK dout0_55 Vdout0_55ck26 = 1.8 time = 270
.meas tran vdout0_55ck26 FIND v(dout0_55) AT=270.05n

* CHECK dout0_56 Vdout0_56ck26 = 1.8 time = 270
.meas tran vdout0_56ck26 FIND v(dout0_56) AT=270.05n

* CHECK dout0_57 Vdout0_57ck26 = 0 time = 270
.meas tran vdout0_57ck26 FIND v(dout0_57) AT=270.05n

* CHECK dout0_58 Vdout0_58ck26 = 0 time = 270
.meas tran vdout0_58ck26 FIND v(dout0_58) AT=270.05n

* CHECK dout0_59 Vdout0_59ck26 = 0 time = 270
.meas tran vdout0_59ck26 FIND v(dout0_59) AT=270.05n

* CHECK dout0_60 Vdout0_60ck26 = 1.8 time = 270
.meas tran vdout0_60ck26 FIND v(dout0_60) AT=270.05n

* CHECK dout0_61 Vdout0_61ck26 = 0 time = 270
.meas tran vdout0_61ck26 FIND v(dout0_61) AT=270.05n

* CHECK dout0_62 Vdout0_62ck26 = 0 time = 270
.meas tran vdout0_62ck26 FIND v(dout0_62) AT=270.05n

* CHECK dout0_63 Vdout0_63ck26 = 0 time = 270
.meas tran vdout0_63ck26 FIND v(dout0_63) AT=270.05n

* CHECK dout0_64 Vdout0_64ck26 = 0 time = 270
.meas tran vdout0_64ck26 FIND v(dout0_64) AT=270.05n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 280
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=280.05n

* CHECK dout0_1 Vdout0_1ck27 = 0 time = 280
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=280.05n

* CHECK dout0_2 Vdout0_2ck27 = 1.8 time = 280
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=280.05n

* CHECK dout0_3 Vdout0_3ck27 = 0 time = 280
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=280.05n

* CHECK dout0_4 Vdout0_4ck27 = 0 time = 280
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=280.05n

* CHECK dout0_5 Vdout0_5ck27 = 0 time = 280
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=280.05n

* CHECK dout0_6 Vdout0_6ck27 = 0 time = 280
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=280.05n

* CHECK dout0_7 Vdout0_7ck27 = 1.8 time = 280
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=280.05n

* CHECK dout0_8 Vdout0_8ck27 = 1.8 time = 280
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=280.05n

* CHECK dout0_9 Vdout0_9ck27 = 1.8 time = 280
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=280.05n

* CHECK dout0_10 Vdout0_10ck27 = 0 time = 280
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=280.05n

* CHECK dout0_11 Vdout0_11ck27 = 0 time = 280
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=280.05n

* CHECK dout0_12 Vdout0_12ck27 = 0 time = 280
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=280.05n

* CHECK dout0_13 Vdout0_13ck27 = 0 time = 280
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=280.05n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 280
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=280.05n

* CHECK dout0_15 Vdout0_15ck27 = 1.8 time = 280
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=280.05n

* CHECK dout0_16 Vdout0_16ck27 = 1.8 time = 280
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=280.05n

* CHECK dout0_17 Vdout0_17ck27 = 0 time = 280
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=280.05n

* CHECK dout0_18 Vdout0_18ck27 = 0 time = 280
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=280.05n

* CHECK dout0_19 Vdout0_19ck27 = 0 time = 280
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=280.05n

* CHECK dout0_20 Vdout0_20ck27 = 1.8 time = 280
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=280.05n

* CHECK dout0_21 Vdout0_21ck27 = 0 time = 280
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=280.05n

* CHECK dout0_22 Vdout0_22ck27 = 0 time = 280
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=280.05n

* CHECK dout0_23 Vdout0_23ck27 = 1.8 time = 280
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=280.05n

* CHECK dout0_24 Vdout0_24ck27 = 0 time = 280
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=280.05n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 280
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=280.05n

* CHECK dout0_26 Vdout0_26ck27 = 1.8 time = 280
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=280.05n

* CHECK dout0_27 Vdout0_27ck27 = 0 time = 280
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=280.05n

* CHECK dout0_28 Vdout0_28ck27 = 1.8 time = 280
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=280.05n

* CHECK dout0_29 Vdout0_29ck27 = 0 time = 280
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=280.05n

* CHECK dout0_30 Vdout0_30ck27 = 1.8 time = 280
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=280.05n

* CHECK dout0_31 Vdout0_31ck27 = 1.8 time = 280
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=280.05n

* CHECK dout0_32 Vdout0_32ck27 = 0 time = 280
.meas tran vdout0_32ck27 FIND v(dout0_32) AT=280.05n

* CHECK dout0_33 Vdout0_33ck27 = 0 time = 280
.meas tran vdout0_33ck27 FIND v(dout0_33) AT=280.05n

* CHECK dout0_34 Vdout0_34ck27 = 1.8 time = 280
.meas tran vdout0_34ck27 FIND v(dout0_34) AT=280.05n

* CHECK dout0_35 Vdout0_35ck27 = 0 time = 280
.meas tran vdout0_35ck27 FIND v(dout0_35) AT=280.05n

* CHECK dout0_36 Vdout0_36ck27 = 0 time = 280
.meas tran vdout0_36ck27 FIND v(dout0_36) AT=280.05n

* CHECK dout0_37 Vdout0_37ck27 = 1.8 time = 280
.meas tran vdout0_37ck27 FIND v(dout0_37) AT=280.05n

* CHECK dout0_38 Vdout0_38ck27 = 0 time = 280
.meas tran vdout0_38ck27 FIND v(dout0_38) AT=280.05n

* CHECK dout0_39 Vdout0_39ck27 = 1.8 time = 280
.meas tran vdout0_39ck27 FIND v(dout0_39) AT=280.05n

* CHECK dout0_40 Vdout0_40ck27 = 0 time = 280
.meas tran vdout0_40ck27 FIND v(dout0_40) AT=280.05n

* CHECK dout0_41 Vdout0_41ck27 = 1.8 time = 280
.meas tran vdout0_41ck27 FIND v(dout0_41) AT=280.05n

* CHECK dout0_42 Vdout0_42ck27 = 0 time = 280
.meas tran vdout0_42ck27 FIND v(dout0_42) AT=280.05n

* CHECK dout0_43 Vdout0_43ck27 = 1.8 time = 280
.meas tran vdout0_43ck27 FIND v(dout0_43) AT=280.05n

* CHECK dout0_44 Vdout0_44ck27 = 0 time = 280
.meas tran vdout0_44ck27 FIND v(dout0_44) AT=280.05n

* CHECK dout0_45 Vdout0_45ck27 = 0 time = 280
.meas tran vdout0_45ck27 FIND v(dout0_45) AT=280.05n

* CHECK dout0_46 Vdout0_46ck27 = 0 time = 280
.meas tran vdout0_46ck27 FIND v(dout0_46) AT=280.05n

* CHECK dout0_47 Vdout0_47ck27 = 1.8 time = 280
.meas tran vdout0_47ck27 FIND v(dout0_47) AT=280.05n

* CHECK dout0_48 Vdout0_48ck27 = 1.8 time = 280
.meas tran vdout0_48ck27 FIND v(dout0_48) AT=280.05n

* CHECK dout0_49 Vdout0_49ck27 = 0 time = 280
.meas tran vdout0_49ck27 FIND v(dout0_49) AT=280.05n

* CHECK dout0_50 Vdout0_50ck27 = 0 time = 280
.meas tran vdout0_50ck27 FIND v(dout0_50) AT=280.05n

* CHECK dout0_51 Vdout0_51ck27 = 0 time = 280
.meas tran vdout0_51ck27 FIND v(dout0_51) AT=280.05n

* CHECK dout0_52 Vdout0_52ck27 = 1.8 time = 280
.meas tran vdout0_52ck27 FIND v(dout0_52) AT=280.05n

* CHECK dout0_53 Vdout0_53ck27 = 0 time = 280
.meas tran vdout0_53ck27 FIND v(dout0_53) AT=280.05n

* CHECK dout0_54 Vdout0_54ck27 = 1.8 time = 280
.meas tran vdout0_54ck27 FIND v(dout0_54) AT=280.05n

* CHECK dout0_55 Vdout0_55ck27 = 1.8 time = 280
.meas tran vdout0_55ck27 FIND v(dout0_55) AT=280.05n

* CHECK dout0_56 Vdout0_56ck27 = 0 time = 280
.meas tran vdout0_56ck27 FIND v(dout0_56) AT=280.05n

* CHECK dout0_57 Vdout0_57ck27 = 1.8 time = 280
.meas tran vdout0_57ck27 FIND v(dout0_57) AT=280.05n

* CHECK dout0_58 Vdout0_58ck27 = 0 time = 280
.meas tran vdout0_58ck27 FIND v(dout0_58) AT=280.05n

* CHECK dout0_59 Vdout0_59ck27 = 0 time = 280
.meas tran vdout0_59ck27 FIND v(dout0_59) AT=280.05n

* CHECK dout0_60 Vdout0_60ck27 = 1.8 time = 280
.meas tran vdout0_60ck27 FIND v(dout0_60) AT=280.05n

* CHECK dout0_61 Vdout0_61ck27 = 0 time = 280
.meas tran vdout0_61ck27 FIND v(dout0_61) AT=280.05n

* CHECK dout0_62 Vdout0_62ck27 = 0 time = 280
.meas tran vdout0_62ck27 FIND v(dout0_62) AT=280.05n

* CHECK dout0_63 Vdout0_63ck27 = 1.8 time = 280
.meas tran vdout0_63ck27 FIND v(dout0_63) AT=280.05n

* CHECK dout0_64 Vdout0_64ck27 = 0 time = 280
.meas tran vdout0_64ck27 FIND v(dout0_64) AT=280.05n

* CHECK dout0_0 Vdout0_0ck32 = 1.8 time = 330
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=330.05n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 330
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=330.05n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 330
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=330.05n

* CHECK dout0_3 Vdout0_3ck32 = 0 time = 330
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=330.05n

* CHECK dout0_4 Vdout0_4ck32 = 0 time = 330
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=330.05n

* CHECK dout0_5 Vdout0_5ck32 = 1.8 time = 330
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=330.05n

* CHECK dout0_6 Vdout0_6ck32 = 0 time = 330
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=330.05n

* CHECK dout0_7 Vdout0_7ck32 = 1.8 time = 330
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=330.05n

* CHECK dout0_8 Vdout0_8ck32 = 0 time = 330
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=330.05n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 330
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=330.05n

* CHECK dout0_10 Vdout0_10ck32 = 0 time = 330
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=330.05n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 330
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=330.05n

* CHECK dout0_12 Vdout0_12ck32 = 1.8 time = 330
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=330.05n

* CHECK dout0_13 Vdout0_13ck32 = 0 time = 330
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=330.05n

* CHECK dout0_14 Vdout0_14ck32 = 1.8 time = 330
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=330.05n

* CHECK dout0_15 Vdout0_15ck32 = 1.8 time = 330
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=330.05n

* CHECK dout0_16 Vdout0_16ck32 = 0 time = 330
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=330.05n

* CHECK dout0_17 Vdout0_17ck32 = 1.8 time = 330
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=330.05n

* CHECK dout0_18 Vdout0_18ck32 = 0 time = 330
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=330.05n

* CHECK dout0_19 Vdout0_19ck32 = 0 time = 330
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=330.05n

* CHECK dout0_20 Vdout0_20ck32 = 1.8 time = 330
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=330.05n

* CHECK dout0_21 Vdout0_21ck32 = 0 time = 330
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=330.05n

* CHECK dout0_22 Vdout0_22ck32 = 1.8 time = 330
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=330.05n

* CHECK dout0_23 Vdout0_23ck32 = 0 time = 330
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=330.05n

* CHECK dout0_24 Vdout0_24ck32 = 0 time = 330
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=330.05n

* CHECK dout0_25 Vdout0_25ck32 = 0 time = 330
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=330.05n

* CHECK dout0_26 Vdout0_26ck32 = 1.8 time = 330
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=330.05n

* CHECK dout0_27 Vdout0_27ck32 = 0 time = 330
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=330.05n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 330
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=330.05n

* CHECK dout0_29 Vdout0_29ck32 = 1.8 time = 330
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=330.05n

* CHECK dout0_30 Vdout0_30ck32 = 1.8 time = 330
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=330.05n

* CHECK dout0_31 Vdout0_31ck32 = 1.8 time = 330
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=330.05n

* CHECK dout0_32 Vdout0_32ck32 = 1.8 time = 330
.meas tran vdout0_32ck32 FIND v(dout0_32) AT=330.05n

* CHECK dout0_33 Vdout0_33ck32 = 1.8 time = 330
.meas tran vdout0_33ck32 FIND v(dout0_33) AT=330.05n

* CHECK dout0_34 Vdout0_34ck32 = 0 time = 330
.meas tran vdout0_34ck32 FIND v(dout0_34) AT=330.05n

* CHECK dout0_35 Vdout0_35ck32 = 1.8 time = 330
.meas tran vdout0_35ck32 FIND v(dout0_35) AT=330.05n

* CHECK dout0_36 Vdout0_36ck32 = 1.8 time = 330
.meas tran vdout0_36ck32 FIND v(dout0_36) AT=330.05n

* CHECK dout0_37 Vdout0_37ck32 = 1.8 time = 330
.meas tran vdout0_37ck32 FIND v(dout0_37) AT=330.05n

* CHECK dout0_38 Vdout0_38ck32 = 0 time = 330
.meas tran vdout0_38ck32 FIND v(dout0_38) AT=330.05n

* CHECK dout0_39 Vdout0_39ck32 = 0 time = 330
.meas tran vdout0_39ck32 FIND v(dout0_39) AT=330.05n

* CHECK dout0_40 Vdout0_40ck32 = 1.8 time = 330
.meas tran vdout0_40ck32 FIND v(dout0_40) AT=330.05n

* CHECK dout0_41 Vdout0_41ck32 = 1.8 time = 330
.meas tran vdout0_41ck32 FIND v(dout0_41) AT=330.05n

* CHECK dout0_42 Vdout0_42ck32 = 0 time = 330
.meas tran vdout0_42ck32 FIND v(dout0_42) AT=330.05n

* CHECK dout0_43 Vdout0_43ck32 = 1.8 time = 330
.meas tran vdout0_43ck32 FIND v(dout0_43) AT=330.05n

* CHECK dout0_44 Vdout0_44ck32 = 0 time = 330
.meas tran vdout0_44ck32 FIND v(dout0_44) AT=330.05n

* CHECK dout0_45 Vdout0_45ck32 = 1.8 time = 330
.meas tran vdout0_45ck32 FIND v(dout0_45) AT=330.05n

* CHECK dout0_46 Vdout0_46ck32 = 1.8 time = 330
.meas tran vdout0_46ck32 FIND v(dout0_46) AT=330.05n

* CHECK dout0_47 Vdout0_47ck32 = 1.8 time = 330
.meas tran vdout0_47ck32 FIND v(dout0_47) AT=330.05n

* CHECK dout0_48 Vdout0_48ck32 = 1.8 time = 330
.meas tran vdout0_48ck32 FIND v(dout0_48) AT=330.05n

* CHECK dout0_49 Vdout0_49ck32 = 1.8 time = 330
.meas tran vdout0_49ck32 FIND v(dout0_49) AT=330.05n

* CHECK dout0_50 Vdout0_50ck32 = 1.8 time = 330
.meas tran vdout0_50ck32 FIND v(dout0_50) AT=330.05n

* CHECK dout0_51 Vdout0_51ck32 = 0 time = 330
.meas tran vdout0_51ck32 FIND v(dout0_51) AT=330.05n

* CHECK dout0_52 Vdout0_52ck32 = 1.8 time = 330
.meas tran vdout0_52ck32 FIND v(dout0_52) AT=330.05n

* CHECK dout0_53 Vdout0_53ck32 = 0 time = 330
.meas tran vdout0_53ck32 FIND v(dout0_53) AT=330.05n

* CHECK dout0_54 Vdout0_54ck32 = 1.8 time = 330
.meas tran vdout0_54ck32 FIND v(dout0_54) AT=330.05n

* CHECK dout0_55 Vdout0_55ck32 = 0 time = 330
.meas tran vdout0_55ck32 FIND v(dout0_55) AT=330.05n

* CHECK dout0_56 Vdout0_56ck32 = 1.8 time = 330
.meas tran vdout0_56ck32 FIND v(dout0_56) AT=330.05n

* CHECK dout0_57 Vdout0_57ck32 = 0 time = 330
.meas tran vdout0_57ck32 FIND v(dout0_57) AT=330.05n

* CHECK dout0_58 Vdout0_58ck32 = 1.8 time = 330
.meas tran vdout0_58ck32 FIND v(dout0_58) AT=330.05n

* CHECK dout0_59 Vdout0_59ck32 = 0 time = 330
.meas tran vdout0_59ck32 FIND v(dout0_59) AT=330.05n

* CHECK dout0_60 Vdout0_60ck32 = 0 time = 330
.meas tran vdout0_60ck32 FIND v(dout0_60) AT=330.05n

* CHECK dout0_61 Vdout0_61ck32 = 1.8 time = 330
.meas tran vdout0_61ck32 FIND v(dout0_61) AT=330.05n

* CHECK dout0_62 Vdout0_62ck32 = 1.8 time = 330
.meas tran vdout0_62ck32 FIND v(dout0_62) AT=330.05n

* CHECK dout0_63 Vdout0_63ck32 = 1.8 time = 330
.meas tran vdout0_63ck32 FIND v(dout0_63) AT=330.05n

* CHECK dout0_64 Vdout0_64ck32 = 0 time = 330
.meas tran vdout0_64ck32 FIND v(dout0_64) AT=330.05n

* CHECK dout0_0 Vdout0_0ck38 = 1.8 time = 390
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=390.05n

* CHECK dout0_1 Vdout0_1ck38 = 0 time = 390
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=390.05n

* CHECK dout0_2 Vdout0_2ck38 = 1.8 time = 390
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=390.05n

* CHECK dout0_3 Vdout0_3ck38 = 0 time = 390
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=390.05n

* CHECK dout0_4 Vdout0_4ck38 = 1.8 time = 390
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=390.05n

* CHECK dout0_5 Vdout0_5ck38 = 0 time = 390
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=390.05n

* CHECK dout0_6 Vdout0_6ck38 = 1.8 time = 390
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=390.05n

* CHECK dout0_7 Vdout0_7ck38 = 0 time = 390
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=390.05n

* CHECK dout0_8 Vdout0_8ck38 = 0 time = 390
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=390.05n

* CHECK dout0_9 Vdout0_9ck38 = 0 time = 390
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=390.05n

* CHECK dout0_10 Vdout0_10ck38 = 1.8 time = 390
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=390.05n

* CHECK dout0_11 Vdout0_11ck38 = 1.8 time = 390
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=390.05n

* CHECK dout0_12 Vdout0_12ck38 = 1.8 time = 390
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=390.05n

* CHECK dout0_13 Vdout0_13ck38 = 0 time = 390
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=390.05n

* CHECK dout0_14 Vdout0_14ck38 = 0 time = 390
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=390.05n

* CHECK dout0_15 Vdout0_15ck38 = 0 time = 390
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=390.05n

* CHECK dout0_16 Vdout0_16ck38 = 1.8 time = 390
.meas tran vdout0_16ck38 FIND v(dout0_16) AT=390.05n

* CHECK dout0_17 Vdout0_17ck38 = 1.8 time = 390
.meas tran vdout0_17ck38 FIND v(dout0_17) AT=390.05n

* CHECK dout0_18 Vdout0_18ck38 = 1.8 time = 390
.meas tran vdout0_18ck38 FIND v(dout0_18) AT=390.05n

* CHECK dout0_19 Vdout0_19ck38 = 1.8 time = 390
.meas tran vdout0_19ck38 FIND v(dout0_19) AT=390.05n

* CHECK dout0_20 Vdout0_20ck38 = 1.8 time = 390
.meas tran vdout0_20ck38 FIND v(dout0_20) AT=390.05n

* CHECK dout0_21 Vdout0_21ck38 = 0 time = 390
.meas tran vdout0_21ck38 FIND v(dout0_21) AT=390.05n

* CHECK dout0_22 Vdout0_22ck38 = 1.8 time = 390
.meas tran vdout0_22ck38 FIND v(dout0_22) AT=390.05n

* CHECK dout0_23 Vdout0_23ck38 = 1.8 time = 390
.meas tran vdout0_23ck38 FIND v(dout0_23) AT=390.05n

* CHECK dout0_24 Vdout0_24ck38 = 1.8 time = 390
.meas tran vdout0_24ck38 FIND v(dout0_24) AT=390.05n

* CHECK dout0_25 Vdout0_25ck38 = 0 time = 390
.meas tran vdout0_25ck38 FIND v(dout0_25) AT=390.05n

* CHECK dout0_26 Vdout0_26ck38 = 0 time = 390
.meas tran vdout0_26ck38 FIND v(dout0_26) AT=390.05n

* CHECK dout0_27 Vdout0_27ck38 = 0 time = 390
.meas tran vdout0_27ck38 FIND v(dout0_27) AT=390.05n

* CHECK dout0_28 Vdout0_28ck38 = 0 time = 390
.meas tran vdout0_28ck38 FIND v(dout0_28) AT=390.05n

* CHECK dout0_29 Vdout0_29ck38 = 1.8 time = 390
.meas tran vdout0_29ck38 FIND v(dout0_29) AT=390.05n

* CHECK dout0_30 Vdout0_30ck38 = 0 time = 390
.meas tran vdout0_30ck38 FIND v(dout0_30) AT=390.05n

* CHECK dout0_31 Vdout0_31ck38 = 1.8 time = 390
.meas tran vdout0_31ck38 FIND v(dout0_31) AT=390.05n

* CHECK dout0_32 Vdout0_32ck38 = 1.8 time = 390
.meas tran vdout0_32ck38 FIND v(dout0_32) AT=390.05n

* CHECK dout0_33 Vdout0_33ck38 = 0 time = 390
.meas tran vdout0_33ck38 FIND v(dout0_33) AT=390.05n

* CHECK dout0_34 Vdout0_34ck38 = 0 time = 390
.meas tran vdout0_34ck38 FIND v(dout0_34) AT=390.05n

* CHECK dout0_35 Vdout0_35ck38 = 1.8 time = 390
.meas tran vdout0_35ck38 FIND v(dout0_35) AT=390.05n

* CHECK dout0_36 Vdout0_36ck38 = 1.8 time = 390
.meas tran vdout0_36ck38 FIND v(dout0_36) AT=390.05n

* CHECK dout0_37 Vdout0_37ck38 = 0 time = 390
.meas tran vdout0_37ck38 FIND v(dout0_37) AT=390.05n

* CHECK dout0_38 Vdout0_38ck38 = 1.8 time = 390
.meas tran vdout0_38ck38 FIND v(dout0_38) AT=390.05n

* CHECK dout0_39 Vdout0_39ck38 = 1.8 time = 390
.meas tran vdout0_39ck38 FIND v(dout0_39) AT=390.05n

* CHECK dout0_40 Vdout0_40ck38 = 0 time = 390
.meas tran vdout0_40ck38 FIND v(dout0_40) AT=390.05n

* CHECK dout0_41 Vdout0_41ck38 = 0 time = 390
.meas tran vdout0_41ck38 FIND v(dout0_41) AT=390.05n

* CHECK dout0_42 Vdout0_42ck38 = 0 time = 390
.meas tran vdout0_42ck38 FIND v(dout0_42) AT=390.05n

* CHECK dout0_43 Vdout0_43ck38 = 0 time = 390
.meas tran vdout0_43ck38 FIND v(dout0_43) AT=390.05n

* CHECK dout0_44 Vdout0_44ck38 = 0 time = 390
.meas tran vdout0_44ck38 FIND v(dout0_44) AT=390.05n

* CHECK dout0_45 Vdout0_45ck38 = 0 time = 390
.meas tran vdout0_45ck38 FIND v(dout0_45) AT=390.05n

* CHECK dout0_46 Vdout0_46ck38 = 0 time = 390
.meas tran vdout0_46ck38 FIND v(dout0_46) AT=390.05n

* CHECK dout0_47 Vdout0_47ck38 = 1.8 time = 390
.meas tran vdout0_47ck38 FIND v(dout0_47) AT=390.05n

* CHECK dout0_48 Vdout0_48ck38 = 0 time = 390
.meas tran vdout0_48ck38 FIND v(dout0_48) AT=390.05n

* CHECK dout0_49 Vdout0_49ck38 = 1.8 time = 390
.meas tran vdout0_49ck38 FIND v(dout0_49) AT=390.05n

* CHECK dout0_50 Vdout0_50ck38 = 0 time = 390
.meas tran vdout0_50ck38 FIND v(dout0_50) AT=390.05n

* CHECK dout0_51 Vdout0_51ck38 = 0 time = 390
.meas tran vdout0_51ck38 FIND v(dout0_51) AT=390.05n

* CHECK dout0_52 Vdout0_52ck38 = 1.8 time = 390
.meas tran vdout0_52ck38 FIND v(dout0_52) AT=390.05n

* CHECK dout0_53 Vdout0_53ck38 = 1.8 time = 390
.meas tran vdout0_53ck38 FIND v(dout0_53) AT=390.05n

* CHECK dout0_54 Vdout0_54ck38 = 0 time = 390
.meas tran vdout0_54ck38 FIND v(dout0_54) AT=390.05n

* CHECK dout0_55 Vdout0_55ck38 = 0 time = 390
.meas tran vdout0_55ck38 FIND v(dout0_55) AT=390.05n

* CHECK dout0_56 Vdout0_56ck38 = 0 time = 390
.meas tran vdout0_56ck38 FIND v(dout0_56) AT=390.05n

* CHECK dout0_57 Vdout0_57ck38 = 0 time = 390
.meas tran vdout0_57ck38 FIND v(dout0_57) AT=390.05n

* CHECK dout0_58 Vdout0_58ck38 = 0 time = 390
.meas tran vdout0_58ck38 FIND v(dout0_58) AT=390.05n

* CHECK dout0_59 Vdout0_59ck38 = 0 time = 390
.meas tran vdout0_59ck38 FIND v(dout0_59) AT=390.05n

* CHECK dout0_60 Vdout0_60ck38 = 0 time = 390
.meas tran vdout0_60ck38 FIND v(dout0_60) AT=390.05n

* CHECK dout0_61 Vdout0_61ck38 = 1.8 time = 390
.meas tran vdout0_61ck38 FIND v(dout0_61) AT=390.05n

* CHECK dout0_62 Vdout0_62ck38 = 1.8 time = 390
.meas tran vdout0_62ck38 FIND v(dout0_62) AT=390.05n

* CHECK dout0_63 Vdout0_63ck38 = 0 time = 390
.meas tran vdout0_63ck38 FIND v(dout0_63) AT=390.05n

* CHECK dout0_64 Vdout0_64ck38 = 0 time = 390
.meas tran vdout0_64ck38 FIND v(dout0_64) AT=390.05n

* CHECK dout0_0 Vdout0_0ck42 = 0 time = 430
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=430.05n

* CHECK dout0_1 Vdout0_1ck42 = 1.8 time = 430
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=430.05n

* CHECK dout0_2 Vdout0_2ck42 = 0 time = 430
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=430.05n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 430
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=430.05n

* CHECK dout0_4 Vdout0_4ck42 = 1.8 time = 430
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=430.05n

* CHECK dout0_5 Vdout0_5ck42 = 1.8 time = 430
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=430.05n

* CHECK dout0_6 Vdout0_6ck42 = 1.8 time = 430
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=430.05n

* CHECK dout0_7 Vdout0_7ck42 = 1.8 time = 430
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=430.05n

* CHECK dout0_8 Vdout0_8ck42 = 1.8 time = 430
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=430.05n

* CHECK dout0_9 Vdout0_9ck42 = 1.8 time = 430
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=430.05n

* CHECK dout0_10 Vdout0_10ck42 = 1.8 time = 430
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=430.05n

* CHECK dout0_11 Vdout0_11ck42 = 1.8 time = 430
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=430.05n

* CHECK dout0_12 Vdout0_12ck42 = 1.8 time = 430
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=430.05n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 430
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=430.05n

* CHECK dout0_14 Vdout0_14ck42 = 0 time = 430
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=430.05n

* CHECK dout0_15 Vdout0_15ck42 = 0 time = 430
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=430.05n

* CHECK dout0_16 Vdout0_16ck42 = 0 time = 430
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=430.05n

* CHECK dout0_17 Vdout0_17ck42 = 1.8 time = 430
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=430.05n

* CHECK dout0_18 Vdout0_18ck42 = 0 time = 430
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=430.05n

* CHECK dout0_19 Vdout0_19ck42 = 1.8 time = 430
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=430.05n

* CHECK dout0_20 Vdout0_20ck42 = 1.8 time = 430
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=430.05n

* CHECK dout0_21 Vdout0_21ck42 = 1.8 time = 430
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=430.05n

* CHECK dout0_22 Vdout0_22ck42 = 0 time = 430
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=430.05n

* CHECK dout0_23 Vdout0_23ck42 = 1.8 time = 430
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=430.05n

* CHECK dout0_24 Vdout0_24ck42 = 1.8 time = 430
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=430.05n

* CHECK dout0_25 Vdout0_25ck42 = 0 time = 430
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=430.05n

* CHECK dout0_26 Vdout0_26ck42 = 1.8 time = 430
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=430.05n

* CHECK dout0_27 Vdout0_27ck42 = 1.8 time = 430
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=430.05n

* CHECK dout0_28 Vdout0_28ck42 = 0 time = 430
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=430.05n

* CHECK dout0_29 Vdout0_29ck42 = 1.8 time = 430
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=430.05n

* CHECK dout0_30 Vdout0_30ck42 = 0 time = 430
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=430.05n

* CHECK dout0_31 Vdout0_31ck42 = 0 time = 430
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=430.05n

* CHECK dout0_32 Vdout0_32ck42 = 1.8 time = 430
.meas tran vdout0_32ck42 FIND v(dout0_32) AT=430.05n

* CHECK dout0_33 Vdout0_33ck42 = 0 time = 430
.meas tran vdout0_33ck42 FIND v(dout0_33) AT=430.05n

* CHECK dout0_34 Vdout0_34ck42 = 1.8 time = 430
.meas tran vdout0_34ck42 FIND v(dout0_34) AT=430.05n

* CHECK dout0_35 Vdout0_35ck42 = 1.8 time = 430
.meas tran vdout0_35ck42 FIND v(dout0_35) AT=430.05n

* CHECK dout0_36 Vdout0_36ck42 = 0 time = 430
.meas tran vdout0_36ck42 FIND v(dout0_36) AT=430.05n

* CHECK dout0_37 Vdout0_37ck42 = 1.8 time = 430
.meas tran vdout0_37ck42 FIND v(dout0_37) AT=430.05n

* CHECK dout0_38 Vdout0_38ck42 = 1.8 time = 430
.meas tran vdout0_38ck42 FIND v(dout0_38) AT=430.05n

* CHECK dout0_39 Vdout0_39ck42 = 0 time = 430
.meas tran vdout0_39ck42 FIND v(dout0_39) AT=430.05n

* CHECK dout0_40 Vdout0_40ck42 = 0 time = 430
.meas tran vdout0_40ck42 FIND v(dout0_40) AT=430.05n

* CHECK dout0_41 Vdout0_41ck42 = 0 time = 430
.meas tran vdout0_41ck42 FIND v(dout0_41) AT=430.05n

* CHECK dout0_42 Vdout0_42ck42 = 1.8 time = 430
.meas tran vdout0_42ck42 FIND v(dout0_42) AT=430.05n

* CHECK dout0_43 Vdout0_43ck42 = 0 time = 430
.meas tran vdout0_43ck42 FIND v(dout0_43) AT=430.05n

* CHECK dout0_44 Vdout0_44ck42 = 1.8 time = 430
.meas tran vdout0_44ck42 FIND v(dout0_44) AT=430.05n

* CHECK dout0_45 Vdout0_45ck42 = 0 time = 430
.meas tran vdout0_45ck42 FIND v(dout0_45) AT=430.05n

* CHECK dout0_46 Vdout0_46ck42 = 0 time = 430
.meas tran vdout0_46ck42 FIND v(dout0_46) AT=430.05n

* CHECK dout0_47 Vdout0_47ck42 = 0 time = 430
.meas tran vdout0_47ck42 FIND v(dout0_47) AT=430.05n

* CHECK dout0_48 Vdout0_48ck42 = 0 time = 430
.meas tran vdout0_48ck42 FIND v(dout0_48) AT=430.05n

* CHECK dout0_49 Vdout0_49ck42 = 0 time = 430
.meas tran vdout0_49ck42 FIND v(dout0_49) AT=430.05n

* CHECK dout0_50 Vdout0_50ck42 = 1.8 time = 430
.meas tran vdout0_50ck42 FIND v(dout0_50) AT=430.05n

* CHECK dout0_51 Vdout0_51ck42 = 0 time = 430
.meas tran vdout0_51ck42 FIND v(dout0_51) AT=430.05n

* CHECK dout0_52 Vdout0_52ck42 = 1.8 time = 430
.meas tran vdout0_52ck42 FIND v(dout0_52) AT=430.05n

* CHECK dout0_53 Vdout0_53ck42 = 0 time = 430
.meas tran vdout0_53ck42 FIND v(dout0_53) AT=430.05n

* CHECK dout0_54 Vdout0_54ck42 = 1.8 time = 430
.meas tran vdout0_54ck42 FIND v(dout0_54) AT=430.05n

* CHECK dout0_55 Vdout0_55ck42 = 0 time = 430
.meas tran vdout0_55ck42 FIND v(dout0_55) AT=430.05n

* CHECK dout0_56 Vdout0_56ck42 = 0 time = 430
.meas tran vdout0_56ck42 FIND v(dout0_56) AT=430.05n

* CHECK dout0_57 Vdout0_57ck42 = 1.8 time = 430
.meas tran vdout0_57ck42 FIND v(dout0_57) AT=430.05n

* CHECK dout0_58 Vdout0_58ck42 = 1.8 time = 430
.meas tran vdout0_58ck42 FIND v(dout0_58) AT=430.05n

* CHECK dout0_59 Vdout0_59ck42 = 0 time = 430
.meas tran vdout0_59ck42 FIND v(dout0_59) AT=430.05n

* CHECK dout0_60 Vdout0_60ck42 = 1.8 time = 430
.meas tran vdout0_60ck42 FIND v(dout0_60) AT=430.05n

* CHECK dout0_61 Vdout0_61ck42 = 0 time = 430
.meas tran vdout0_61ck42 FIND v(dout0_61) AT=430.05n

* CHECK dout0_62 Vdout0_62ck42 = 1.8 time = 430
.meas tran vdout0_62ck42 FIND v(dout0_62) AT=430.05n

* CHECK dout0_63 Vdout0_63ck42 = 1.8 time = 430
.meas tran vdout0_63ck42 FIND v(dout0_63) AT=430.05n

* CHECK dout0_64 Vdout0_64ck42 = 0 time = 430
.meas tran vdout0_64ck42 FIND v(dout0_64) AT=430.05n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 1.8 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 0 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 0 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 1.8 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 1.8 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_8 Vdout0_8ck47 = 1.8 time = 480
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=480.05n

* CHECK dout0_9 Vdout0_9ck47 = 1.8 time = 480
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=480.05n

* CHECK dout0_10 Vdout0_10ck47 = 0 time = 480
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=480.05n

* CHECK dout0_11 Vdout0_11ck47 = 1.8 time = 480
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=480.05n

* CHECK dout0_12 Vdout0_12ck47 = 1.8 time = 480
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=480.05n

* CHECK dout0_13 Vdout0_13ck47 = 0 time = 480
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=480.05n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 480
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=480.05n

* CHECK dout0_15 Vdout0_15ck47 = 0 time = 480
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=480.05n

* CHECK dout0_16 Vdout0_16ck47 = 0 time = 480
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=480.05n

* CHECK dout0_17 Vdout0_17ck47 = 1.8 time = 480
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=480.05n

* CHECK dout0_18 Vdout0_18ck47 = 0 time = 480
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=480.05n

* CHECK dout0_19 Vdout0_19ck47 = 0 time = 480
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=480.05n

* CHECK dout0_20 Vdout0_20ck47 = 1.8 time = 480
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=480.05n

* CHECK dout0_21 Vdout0_21ck47 = 0 time = 480
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=480.05n

* CHECK dout0_22 Vdout0_22ck47 = 1.8 time = 480
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=480.05n

* CHECK dout0_23 Vdout0_23ck47 = 0 time = 480
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=480.05n

* CHECK dout0_24 Vdout0_24ck47 = 1.8 time = 480
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=480.05n

* CHECK dout0_25 Vdout0_25ck47 = 1.8 time = 480
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=480.05n

* CHECK dout0_26 Vdout0_26ck47 = 1.8 time = 480
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=480.05n

* CHECK dout0_27 Vdout0_27ck47 = 0 time = 480
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=480.05n

* CHECK dout0_28 Vdout0_28ck47 = 1.8 time = 480
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=480.05n

* CHECK dout0_29 Vdout0_29ck47 = 0 time = 480
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=480.05n

* CHECK dout0_30 Vdout0_30ck47 = 0 time = 480
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=480.05n

* CHECK dout0_31 Vdout0_31ck47 = 1.8 time = 480
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=480.05n

* CHECK dout0_32 Vdout0_32ck47 = 1.8 time = 480
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=480.05n

* CHECK dout0_33 Vdout0_33ck47 = 0 time = 480
.meas tran vdout0_33ck47 FIND v(dout0_33) AT=480.05n

* CHECK dout0_34 Vdout0_34ck47 = 0 time = 480
.meas tran vdout0_34ck47 FIND v(dout0_34) AT=480.05n

* CHECK dout0_35 Vdout0_35ck47 = 0 time = 480
.meas tran vdout0_35ck47 FIND v(dout0_35) AT=480.05n

* CHECK dout0_36 Vdout0_36ck47 = 1.8 time = 480
.meas tran vdout0_36ck47 FIND v(dout0_36) AT=480.05n

* CHECK dout0_37 Vdout0_37ck47 = 1.8 time = 480
.meas tran vdout0_37ck47 FIND v(dout0_37) AT=480.05n

* CHECK dout0_38 Vdout0_38ck47 = 0 time = 480
.meas tran vdout0_38ck47 FIND v(dout0_38) AT=480.05n

* CHECK dout0_39 Vdout0_39ck47 = 0 time = 480
.meas tran vdout0_39ck47 FIND v(dout0_39) AT=480.05n

* CHECK dout0_40 Vdout0_40ck47 = 1.8 time = 480
.meas tran vdout0_40ck47 FIND v(dout0_40) AT=480.05n

* CHECK dout0_41 Vdout0_41ck47 = 0 time = 480
.meas tran vdout0_41ck47 FIND v(dout0_41) AT=480.05n

* CHECK dout0_42 Vdout0_42ck47 = 1.8 time = 480
.meas tran vdout0_42ck47 FIND v(dout0_42) AT=480.05n

* CHECK dout0_43 Vdout0_43ck47 = 1.8 time = 480
.meas tran vdout0_43ck47 FIND v(dout0_43) AT=480.05n

* CHECK dout0_44 Vdout0_44ck47 = 1.8 time = 480
.meas tran vdout0_44ck47 FIND v(dout0_44) AT=480.05n

* CHECK dout0_45 Vdout0_45ck47 = 1.8 time = 480
.meas tran vdout0_45ck47 FIND v(dout0_45) AT=480.05n

* CHECK dout0_46 Vdout0_46ck47 = 0 time = 480
.meas tran vdout0_46ck47 FIND v(dout0_46) AT=480.05n

* CHECK dout0_47 Vdout0_47ck47 = 0 time = 480
.meas tran vdout0_47ck47 FIND v(dout0_47) AT=480.05n

* CHECK dout0_48 Vdout0_48ck47 = 1.8 time = 480
.meas tran vdout0_48ck47 FIND v(dout0_48) AT=480.05n

* CHECK dout0_49 Vdout0_49ck47 = 1.8 time = 480
.meas tran vdout0_49ck47 FIND v(dout0_49) AT=480.05n

* CHECK dout0_50 Vdout0_50ck47 = 0 time = 480
.meas tran vdout0_50ck47 FIND v(dout0_50) AT=480.05n

* CHECK dout0_51 Vdout0_51ck47 = 1.8 time = 480
.meas tran vdout0_51ck47 FIND v(dout0_51) AT=480.05n

* CHECK dout0_52 Vdout0_52ck47 = 1.8 time = 480
.meas tran vdout0_52ck47 FIND v(dout0_52) AT=480.05n

* CHECK dout0_53 Vdout0_53ck47 = 1.8 time = 480
.meas tran vdout0_53ck47 FIND v(dout0_53) AT=480.05n

* CHECK dout0_54 Vdout0_54ck47 = 1.8 time = 480
.meas tran vdout0_54ck47 FIND v(dout0_54) AT=480.05n

* CHECK dout0_55 Vdout0_55ck47 = 0 time = 480
.meas tran vdout0_55ck47 FIND v(dout0_55) AT=480.05n

* CHECK dout0_56 Vdout0_56ck47 = 0 time = 480
.meas tran vdout0_56ck47 FIND v(dout0_56) AT=480.05n

* CHECK dout0_57 Vdout0_57ck47 = 1.8 time = 480
.meas tran vdout0_57ck47 FIND v(dout0_57) AT=480.05n

* CHECK dout0_58 Vdout0_58ck47 = 1.8 time = 480
.meas tran vdout0_58ck47 FIND v(dout0_58) AT=480.05n

* CHECK dout0_59 Vdout0_59ck47 = 0 time = 480
.meas tran vdout0_59ck47 FIND v(dout0_59) AT=480.05n

* CHECK dout0_60 Vdout0_60ck47 = 0 time = 480
.meas tran vdout0_60ck47 FIND v(dout0_60) AT=480.05n

* CHECK dout0_61 Vdout0_61ck47 = 0 time = 480
.meas tran vdout0_61ck47 FIND v(dout0_61) AT=480.05n

* CHECK dout0_62 Vdout0_62ck47 = 1.8 time = 480
.meas tran vdout0_62ck47 FIND v(dout0_62) AT=480.05n

* CHECK dout0_63 Vdout0_63ck47 = 0 time = 480
.meas tran vdout0_63ck47 FIND v(dout0_63) AT=480.05n

* CHECK dout0_64 Vdout0_64ck47 = 0 time = 480
.meas tran vdout0_64ck47 FIND v(dout0_64) AT=480.05n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 490
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=490.05n

* CHECK dout0_1 Vdout0_1ck48 = 0 time = 490
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=490.05n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 490
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=490.05n

* CHECK dout0_3 Vdout0_3ck48 = 0 time = 490
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=490.05n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 490
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=490.05n

* CHECK dout0_5 Vdout0_5ck48 = 1.8 time = 490
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=490.05n

* CHECK dout0_6 Vdout0_6ck48 = 0 time = 490
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=490.05n

* CHECK dout0_7 Vdout0_7ck48 = 0 time = 490
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=490.05n

* CHECK dout0_8 Vdout0_8ck48 = 1.8 time = 490
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=490.05n

* CHECK dout0_9 Vdout0_9ck48 = 1.8 time = 490
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=490.05n

* CHECK dout0_10 Vdout0_10ck48 = 1.8 time = 490
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=490.05n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 490
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=490.05n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 490
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=490.05n

* CHECK dout0_13 Vdout0_13ck48 = 1.8 time = 490
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=490.05n

* CHECK dout0_14 Vdout0_14ck48 = 0 time = 490
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=490.05n

* CHECK dout0_15 Vdout0_15ck48 = 0 time = 490
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=490.05n

* CHECK dout0_16 Vdout0_16ck48 = 0 time = 490
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=490.05n

* CHECK dout0_17 Vdout0_17ck48 = 0 time = 490
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=490.05n

* CHECK dout0_18 Vdout0_18ck48 = 1.8 time = 490
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=490.05n

* CHECK dout0_19 Vdout0_19ck48 = 0 time = 490
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=490.05n

* CHECK dout0_20 Vdout0_20ck48 = 0 time = 490
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=490.05n

* CHECK dout0_21 Vdout0_21ck48 = 1.8 time = 490
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=490.05n

* CHECK dout0_22 Vdout0_22ck48 = 0 time = 490
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=490.05n

* CHECK dout0_23 Vdout0_23ck48 = 0 time = 490
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=490.05n

* CHECK dout0_24 Vdout0_24ck48 = 0 time = 490
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=490.05n

* CHECK dout0_25 Vdout0_25ck48 = 0 time = 490
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=490.05n

* CHECK dout0_26 Vdout0_26ck48 = 1.8 time = 490
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=490.05n

* CHECK dout0_27 Vdout0_27ck48 = 0 time = 490
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=490.05n

* CHECK dout0_28 Vdout0_28ck48 = 1.8 time = 490
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=490.05n

* CHECK dout0_29 Vdout0_29ck48 = 0 time = 490
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=490.05n

* CHECK dout0_30 Vdout0_30ck48 = 0 time = 490
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=490.05n

* CHECK dout0_31 Vdout0_31ck48 = 0 time = 490
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=490.05n

* CHECK dout0_32 Vdout0_32ck48 = 1.8 time = 490
.meas tran vdout0_32ck48 FIND v(dout0_32) AT=490.05n

* CHECK dout0_33 Vdout0_33ck48 = 0 time = 490
.meas tran vdout0_33ck48 FIND v(dout0_33) AT=490.05n

* CHECK dout0_34 Vdout0_34ck48 = 1.8 time = 490
.meas tran vdout0_34ck48 FIND v(dout0_34) AT=490.05n

* CHECK dout0_35 Vdout0_35ck48 = 0 time = 490
.meas tran vdout0_35ck48 FIND v(dout0_35) AT=490.05n

* CHECK dout0_36 Vdout0_36ck48 = 0 time = 490
.meas tran vdout0_36ck48 FIND v(dout0_36) AT=490.05n

* CHECK dout0_37 Vdout0_37ck48 = 0 time = 490
.meas tran vdout0_37ck48 FIND v(dout0_37) AT=490.05n

* CHECK dout0_38 Vdout0_38ck48 = 0 time = 490
.meas tran vdout0_38ck48 FIND v(dout0_38) AT=490.05n

* CHECK dout0_39 Vdout0_39ck48 = 0 time = 490
.meas tran vdout0_39ck48 FIND v(dout0_39) AT=490.05n

* CHECK dout0_40 Vdout0_40ck48 = 1.8 time = 490
.meas tran vdout0_40ck48 FIND v(dout0_40) AT=490.05n

* CHECK dout0_41 Vdout0_41ck48 = 1.8 time = 490
.meas tran vdout0_41ck48 FIND v(dout0_41) AT=490.05n

* CHECK dout0_42 Vdout0_42ck48 = 1.8 time = 490
.meas tran vdout0_42ck48 FIND v(dout0_42) AT=490.05n

* CHECK dout0_43 Vdout0_43ck48 = 1.8 time = 490
.meas tran vdout0_43ck48 FIND v(dout0_43) AT=490.05n

* CHECK dout0_44 Vdout0_44ck48 = 0 time = 490
.meas tran vdout0_44ck48 FIND v(dout0_44) AT=490.05n

* CHECK dout0_45 Vdout0_45ck48 = 0 time = 490
.meas tran vdout0_45ck48 FIND v(dout0_45) AT=490.05n

* CHECK dout0_46 Vdout0_46ck48 = 1.8 time = 490
.meas tran vdout0_46ck48 FIND v(dout0_46) AT=490.05n

* CHECK dout0_47 Vdout0_47ck48 = 0 time = 490
.meas tran vdout0_47ck48 FIND v(dout0_47) AT=490.05n

* CHECK dout0_48 Vdout0_48ck48 = 1.8 time = 490
.meas tran vdout0_48ck48 FIND v(dout0_48) AT=490.05n

* CHECK dout0_49 Vdout0_49ck48 = 1.8 time = 490
.meas tran vdout0_49ck48 FIND v(dout0_49) AT=490.05n

* CHECK dout0_50 Vdout0_50ck48 = 0 time = 490
.meas tran vdout0_50ck48 FIND v(dout0_50) AT=490.05n

* CHECK dout0_51 Vdout0_51ck48 = 1.8 time = 490
.meas tran vdout0_51ck48 FIND v(dout0_51) AT=490.05n

* CHECK dout0_52 Vdout0_52ck48 = 0 time = 490
.meas tran vdout0_52ck48 FIND v(dout0_52) AT=490.05n

* CHECK dout0_53 Vdout0_53ck48 = 1.8 time = 490
.meas tran vdout0_53ck48 FIND v(dout0_53) AT=490.05n

* CHECK dout0_54 Vdout0_54ck48 = 0 time = 490
.meas tran vdout0_54ck48 FIND v(dout0_54) AT=490.05n

* CHECK dout0_55 Vdout0_55ck48 = 1.8 time = 490
.meas tran vdout0_55ck48 FIND v(dout0_55) AT=490.05n

* CHECK dout0_56 Vdout0_56ck48 = 0 time = 490
.meas tran vdout0_56ck48 FIND v(dout0_56) AT=490.05n

* CHECK dout0_57 Vdout0_57ck48 = 0 time = 490
.meas tran vdout0_57ck48 FIND v(dout0_57) AT=490.05n

* CHECK dout0_58 Vdout0_58ck48 = 0 time = 490
.meas tran vdout0_58ck48 FIND v(dout0_58) AT=490.05n

* CHECK dout0_59 Vdout0_59ck48 = 0 time = 490
.meas tran vdout0_59ck48 FIND v(dout0_59) AT=490.05n

* CHECK dout0_60 Vdout0_60ck48 = 1.8 time = 490
.meas tran vdout0_60ck48 FIND v(dout0_60) AT=490.05n

* CHECK dout0_61 Vdout0_61ck48 = 0 time = 490
.meas tran vdout0_61ck48 FIND v(dout0_61) AT=490.05n

* CHECK dout0_62 Vdout0_62ck48 = 0 time = 490
.meas tran vdout0_62ck48 FIND v(dout0_62) AT=490.05n

* CHECK dout0_63 Vdout0_63ck48 = 0 time = 490
.meas tran vdout0_63ck48 FIND v(dout0_63) AT=490.05n

* CHECK dout0_64 Vdout0_64ck48 = 0 time = 490
.meas tran vdout0_64ck48 FIND v(dout0_64) AT=490.05n

* CHECK dout0_0 Vdout0_0ck49 = 0 time = 500
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=500.05n

* CHECK dout0_1 Vdout0_1ck49 = 1.8 time = 500
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=500.05n

* CHECK dout0_2 Vdout0_2ck49 = 0 time = 500
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=500.05n

* CHECK dout0_3 Vdout0_3ck49 = 0 time = 500
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=500.05n

* CHECK dout0_4 Vdout0_4ck49 = 1.8 time = 500
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=500.05n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 500
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=500.05n

* CHECK dout0_6 Vdout0_6ck49 = 1.8 time = 500
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=500.05n

* CHECK dout0_7 Vdout0_7ck49 = 1.8 time = 500
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=500.05n

* CHECK dout0_8 Vdout0_8ck49 = 1.8 time = 500
.meas tran vdout0_8ck49 FIND v(dout0_8) AT=500.05n

* CHECK dout0_9 Vdout0_9ck49 = 1.8 time = 500
.meas tran vdout0_9ck49 FIND v(dout0_9) AT=500.05n

* CHECK dout0_10 Vdout0_10ck49 = 0 time = 500
.meas tran vdout0_10ck49 FIND v(dout0_10) AT=500.05n

* CHECK dout0_11 Vdout0_11ck49 = 1.8 time = 500
.meas tran vdout0_11ck49 FIND v(dout0_11) AT=500.05n

* CHECK dout0_12 Vdout0_12ck49 = 1.8 time = 500
.meas tran vdout0_12ck49 FIND v(dout0_12) AT=500.05n

* CHECK dout0_13 Vdout0_13ck49 = 0 time = 500
.meas tran vdout0_13ck49 FIND v(dout0_13) AT=500.05n

* CHECK dout0_14 Vdout0_14ck49 = 0 time = 500
.meas tran vdout0_14ck49 FIND v(dout0_14) AT=500.05n

* CHECK dout0_15 Vdout0_15ck49 = 0 time = 500
.meas tran vdout0_15ck49 FIND v(dout0_15) AT=500.05n

* CHECK dout0_16 Vdout0_16ck49 = 0 time = 500
.meas tran vdout0_16ck49 FIND v(dout0_16) AT=500.05n

* CHECK dout0_17 Vdout0_17ck49 = 1.8 time = 500
.meas tran vdout0_17ck49 FIND v(dout0_17) AT=500.05n

* CHECK dout0_18 Vdout0_18ck49 = 0 time = 500
.meas tran vdout0_18ck49 FIND v(dout0_18) AT=500.05n

* CHECK dout0_19 Vdout0_19ck49 = 0 time = 500
.meas tran vdout0_19ck49 FIND v(dout0_19) AT=500.05n

* CHECK dout0_20 Vdout0_20ck49 = 1.8 time = 500
.meas tran vdout0_20ck49 FIND v(dout0_20) AT=500.05n

* CHECK dout0_21 Vdout0_21ck49 = 0 time = 500
.meas tran vdout0_21ck49 FIND v(dout0_21) AT=500.05n

* CHECK dout0_22 Vdout0_22ck49 = 1.8 time = 500
.meas tran vdout0_22ck49 FIND v(dout0_22) AT=500.05n

* CHECK dout0_23 Vdout0_23ck49 = 0 time = 500
.meas tran vdout0_23ck49 FIND v(dout0_23) AT=500.05n

* CHECK dout0_24 Vdout0_24ck49 = 1.8 time = 500
.meas tran vdout0_24ck49 FIND v(dout0_24) AT=500.05n

* CHECK dout0_25 Vdout0_25ck49 = 1.8 time = 500
.meas tran vdout0_25ck49 FIND v(dout0_25) AT=500.05n

* CHECK dout0_26 Vdout0_26ck49 = 1.8 time = 500
.meas tran vdout0_26ck49 FIND v(dout0_26) AT=500.05n

* CHECK dout0_27 Vdout0_27ck49 = 0 time = 500
.meas tran vdout0_27ck49 FIND v(dout0_27) AT=500.05n

* CHECK dout0_28 Vdout0_28ck49 = 1.8 time = 500
.meas tran vdout0_28ck49 FIND v(dout0_28) AT=500.05n

* CHECK dout0_29 Vdout0_29ck49 = 0 time = 500
.meas tran vdout0_29ck49 FIND v(dout0_29) AT=500.05n

* CHECK dout0_30 Vdout0_30ck49 = 0 time = 500
.meas tran vdout0_30ck49 FIND v(dout0_30) AT=500.05n

* CHECK dout0_31 Vdout0_31ck49 = 1.8 time = 500
.meas tran vdout0_31ck49 FIND v(dout0_31) AT=500.05n

* CHECK dout0_32 Vdout0_32ck49 = 1.8 time = 500
.meas tran vdout0_32ck49 FIND v(dout0_32) AT=500.05n

* CHECK dout0_33 Vdout0_33ck49 = 0 time = 500
.meas tran vdout0_33ck49 FIND v(dout0_33) AT=500.05n

* CHECK dout0_34 Vdout0_34ck49 = 0 time = 500
.meas tran vdout0_34ck49 FIND v(dout0_34) AT=500.05n

* CHECK dout0_35 Vdout0_35ck49 = 0 time = 500
.meas tran vdout0_35ck49 FIND v(dout0_35) AT=500.05n

* CHECK dout0_36 Vdout0_36ck49 = 1.8 time = 500
.meas tran vdout0_36ck49 FIND v(dout0_36) AT=500.05n

* CHECK dout0_37 Vdout0_37ck49 = 1.8 time = 500
.meas tran vdout0_37ck49 FIND v(dout0_37) AT=500.05n

* CHECK dout0_38 Vdout0_38ck49 = 0 time = 500
.meas tran vdout0_38ck49 FIND v(dout0_38) AT=500.05n

* CHECK dout0_39 Vdout0_39ck49 = 0 time = 500
.meas tran vdout0_39ck49 FIND v(dout0_39) AT=500.05n

* CHECK dout0_40 Vdout0_40ck49 = 1.8 time = 500
.meas tran vdout0_40ck49 FIND v(dout0_40) AT=500.05n

* CHECK dout0_41 Vdout0_41ck49 = 0 time = 500
.meas tran vdout0_41ck49 FIND v(dout0_41) AT=500.05n

* CHECK dout0_42 Vdout0_42ck49 = 1.8 time = 500
.meas tran vdout0_42ck49 FIND v(dout0_42) AT=500.05n

* CHECK dout0_43 Vdout0_43ck49 = 1.8 time = 500
.meas tran vdout0_43ck49 FIND v(dout0_43) AT=500.05n

* CHECK dout0_44 Vdout0_44ck49 = 1.8 time = 500
.meas tran vdout0_44ck49 FIND v(dout0_44) AT=500.05n

* CHECK dout0_45 Vdout0_45ck49 = 1.8 time = 500
.meas tran vdout0_45ck49 FIND v(dout0_45) AT=500.05n

* CHECK dout0_46 Vdout0_46ck49 = 0 time = 500
.meas tran vdout0_46ck49 FIND v(dout0_46) AT=500.05n

* CHECK dout0_47 Vdout0_47ck49 = 0 time = 500
.meas tran vdout0_47ck49 FIND v(dout0_47) AT=500.05n

* CHECK dout0_48 Vdout0_48ck49 = 1.8 time = 500
.meas tran vdout0_48ck49 FIND v(dout0_48) AT=500.05n

* CHECK dout0_49 Vdout0_49ck49 = 1.8 time = 500
.meas tran vdout0_49ck49 FIND v(dout0_49) AT=500.05n

* CHECK dout0_50 Vdout0_50ck49 = 0 time = 500
.meas tran vdout0_50ck49 FIND v(dout0_50) AT=500.05n

* CHECK dout0_51 Vdout0_51ck49 = 1.8 time = 500
.meas tran vdout0_51ck49 FIND v(dout0_51) AT=500.05n

* CHECK dout0_52 Vdout0_52ck49 = 1.8 time = 500
.meas tran vdout0_52ck49 FIND v(dout0_52) AT=500.05n

* CHECK dout0_53 Vdout0_53ck49 = 1.8 time = 500
.meas tran vdout0_53ck49 FIND v(dout0_53) AT=500.05n

* CHECK dout0_54 Vdout0_54ck49 = 1.8 time = 500
.meas tran vdout0_54ck49 FIND v(dout0_54) AT=500.05n

* CHECK dout0_55 Vdout0_55ck49 = 0 time = 500
.meas tran vdout0_55ck49 FIND v(dout0_55) AT=500.05n

* CHECK dout0_56 Vdout0_56ck49 = 0 time = 500
.meas tran vdout0_56ck49 FIND v(dout0_56) AT=500.05n

* CHECK dout0_57 Vdout0_57ck49 = 1.8 time = 500
.meas tran vdout0_57ck49 FIND v(dout0_57) AT=500.05n

* CHECK dout0_58 Vdout0_58ck49 = 1.8 time = 500
.meas tran vdout0_58ck49 FIND v(dout0_58) AT=500.05n

* CHECK dout0_59 Vdout0_59ck49 = 0 time = 500
.meas tran vdout0_59ck49 FIND v(dout0_59) AT=500.05n

* CHECK dout0_60 Vdout0_60ck49 = 0 time = 500
.meas tran vdout0_60ck49 FIND v(dout0_60) AT=500.05n

* CHECK dout0_61 Vdout0_61ck49 = 0 time = 500
.meas tran vdout0_61ck49 FIND v(dout0_61) AT=500.05n

* CHECK dout0_62 Vdout0_62ck49 = 1.8 time = 500
.meas tran vdout0_62ck49 FIND v(dout0_62) AT=500.05n

* CHECK dout0_63 Vdout0_63ck49 = 0 time = 500
.meas tran vdout0_63ck49 FIND v(dout0_63) AT=500.05n

* CHECK dout0_64 Vdout0_64ck49 = 0 time = 500
.meas tran vdout0_64ck49 FIND v(dout0_64) AT=500.05n

* CHECK dout0_0 Vdout0_0ck51 = 1.8 time = 520
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=520.05n

* CHECK dout0_1 Vdout0_1ck51 = 0 time = 520
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=520.05n

* CHECK dout0_2 Vdout0_2ck51 = 1.8 time = 520
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=520.05n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 520
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=520.05n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 520
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=520.05n

* CHECK dout0_5 Vdout0_5ck51 = 0 time = 520
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=520.05n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 520
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=520.05n

* CHECK dout0_7 Vdout0_7ck51 = 0 time = 520
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=520.05n

* CHECK dout0_8 Vdout0_8ck51 = 1.8 time = 520
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=520.05n

* CHECK dout0_9 Vdout0_9ck51 = 0 time = 520
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=520.05n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 520
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=520.05n

* CHECK dout0_11 Vdout0_11ck51 = 1.8 time = 520
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=520.05n

* CHECK dout0_12 Vdout0_12ck51 = 0 time = 520
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=520.05n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 520
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=520.05n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 520
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=520.05n

* CHECK dout0_15 Vdout0_15ck51 = 1.8 time = 520
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=520.05n

* CHECK dout0_16 Vdout0_16ck51 = 1.8 time = 520
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=520.05n

* CHECK dout0_17 Vdout0_17ck51 = 0 time = 520
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=520.05n

* CHECK dout0_18 Vdout0_18ck51 = 1.8 time = 520
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=520.05n

* CHECK dout0_19 Vdout0_19ck51 = 1.8 time = 520
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=520.05n

* CHECK dout0_20 Vdout0_20ck51 = 0 time = 520
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=520.05n

* CHECK dout0_21 Vdout0_21ck51 = 0 time = 520
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=520.05n

* CHECK dout0_22 Vdout0_22ck51 = 1.8 time = 520
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=520.05n

* CHECK dout0_23 Vdout0_23ck51 = 1.8 time = 520
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=520.05n

* CHECK dout0_24 Vdout0_24ck51 = 0 time = 520
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=520.05n

* CHECK dout0_25 Vdout0_25ck51 = 1.8 time = 520
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=520.05n

* CHECK dout0_26 Vdout0_26ck51 = 0 time = 520
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=520.05n

* CHECK dout0_27 Vdout0_27ck51 = 0 time = 520
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=520.05n

* CHECK dout0_28 Vdout0_28ck51 = 0 time = 520
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=520.05n

* CHECK dout0_29 Vdout0_29ck51 = 1.8 time = 520
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=520.05n

* CHECK dout0_30 Vdout0_30ck51 = 1.8 time = 520
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=520.05n

* CHECK dout0_31 Vdout0_31ck51 = 0 time = 520
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=520.05n

* CHECK dout0_32 Vdout0_32ck51 = 1.8 time = 520
.meas tran vdout0_32ck51 FIND v(dout0_32) AT=520.05n

* CHECK dout0_33 Vdout0_33ck51 = 0 time = 520
.meas tran vdout0_33ck51 FIND v(dout0_33) AT=520.05n

* CHECK dout0_34 Vdout0_34ck51 = 1.8 time = 520
.meas tran vdout0_34ck51 FIND v(dout0_34) AT=520.05n

* CHECK dout0_35 Vdout0_35ck51 = 0 time = 520
.meas tran vdout0_35ck51 FIND v(dout0_35) AT=520.05n

* CHECK dout0_36 Vdout0_36ck51 = 0 time = 520
.meas tran vdout0_36ck51 FIND v(dout0_36) AT=520.05n

* CHECK dout0_37 Vdout0_37ck51 = 0 time = 520
.meas tran vdout0_37ck51 FIND v(dout0_37) AT=520.05n

* CHECK dout0_38 Vdout0_38ck51 = 1.8 time = 520
.meas tran vdout0_38ck51 FIND v(dout0_38) AT=520.05n

* CHECK dout0_39 Vdout0_39ck51 = 0 time = 520
.meas tran vdout0_39ck51 FIND v(dout0_39) AT=520.05n

* CHECK dout0_40 Vdout0_40ck51 = 0 time = 520
.meas tran vdout0_40ck51 FIND v(dout0_40) AT=520.05n

* CHECK dout0_41 Vdout0_41ck51 = 1.8 time = 520
.meas tran vdout0_41ck51 FIND v(dout0_41) AT=520.05n

* CHECK dout0_42 Vdout0_42ck51 = 0 time = 520
.meas tran vdout0_42ck51 FIND v(dout0_42) AT=520.05n

* CHECK dout0_43 Vdout0_43ck51 = 0 time = 520
.meas tran vdout0_43ck51 FIND v(dout0_43) AT=520.05n

* CHECK dout0_44 Vdout0_44ck51 = 0 time = 520
.meas tran vdout0_44ck51 FIND v(dout0_44) AT=520.05n

* CHECK dout0_45 Vdout0_45ck51 = 0 time = 520
.meas tran vdout0_45ck51 FIND v(dout0_45) AT=520.05n

* CHECK dout0_46 Vdout0_46ck51 = 1.8 time = 520
.meas tran vdout0_46ck51 FIND v(dout0_46) AT=520.05n

* CHECK dout0_47 Vdout0_47ck51 = 1.8 time = 520
.meas tran vdout0_47ck51 FIND v(dout0_47) AT=520.05n

* CHECK dout0_48 Vdout0_48ck51 = 0 time = 520
.meas tran vdout0_48ck51 FIND v(dout0_48) AT=520.05n

* CHECK dout0_49 Vdout0_49ck51 = 1.8 time = 520
.meas tran vdout0_49ck51 FIND v(dout0_49) AT=520.05n

* CHECK dout0_50 Vdout0_50ck51 = 0 time = 520
.meas tran vdout0_50ck51 FIND v(dout0_50) AT=520.05n

* CHECK dout0_51 Vdout0_51ck51 = 1.8 time = 520
.meas tran vdout0_51ck51 FIND v(dout0_51) AT=520.05n

* CHECK dout0_52 Vdout0_52ck51 = 0 time = 520
.meas tran vdout0_52ck51 FIND v(dout0_52) AT=520.05n

* CHECK dout0_53 Vdout0_53ck51 = 1.8 time = 520
.meas tran vdout0_53ck51 FIND v(dout0_53) AT=520.05n

* CHECK dout0_54 Vdout0_54ck51 = 1.8 time = 520
.meas tran vdout0_54ck51 FIND v(dout0_54) AT=520.05n

* CHECK dout0_55 Vdout0_55ck51 = 1.8 time = 520
.meas tran vdout0_55ck51 FIND v(dout0_55) AT=520.05n

* CHECK dout0_56 Vdout0_56ck51 = 1.8 time = 520
.meas tran vdout0_56ck51 FIND v(dout0_56) AT=520.05n

* CHECK dout0_57 Vdout0_57ck51 = 0 time = 520
.meas tran vdout0_57ck51 FIND v(dout0_57) AT=520.05n

* CHECK dout0_58 Vdout0_58ck51 = 1.8 time = 520
.meas tran vdout0_58ck51 FIND v(dout0_58) AT=520.05n

* CHECK dout0_59 Vdout0_59ck51 = 1.8 time = 520
.meas tran vdout0_59ck51 FIND v(dout0_59) AT=520.05n

* CHECK dout0_60 Vdout0_60ck51 = 0 time = 520
.meas tran vdout0_60ck51 FIND v(dout0_60) AT=520.05n

* CHECK dout0_61 Vdout0_61ck51 = 1.8 time = 520
.meas tran vdout0_61ck51 FIND v(dout0_61) AT=520.05n

* CHECK dout0_62 Vdout0_62ck51 = 1.8 time = 520
.meas tran vdout0_62ck51 FIND v(dout0_62) AT=520.05n

* CHECK dout0_63 Vdout0_63ck51 = 1.8 time = 520
.meas tran vdout0_63ck51 FIND v(dout0_63) AT=520.05n

* CHECK dout0_64 Vdout0_64ck51 = 0 time = 520
.meas tran vdout0_64ck51 FIND v(dout0_64) AT=520.05n

* CHECK dout0_0 Vdout0_0ck52 = 1.8 time = 530
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=530.05n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 530
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=530.05n

* CHECK dout0_2 Vdout0_2ck52 = 1.8 time = 530
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=530.05n

* CHECK dout0_3 Vdout0_3ck52 = 0 time = 530
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=530.05n

* CHECK dout0_4 Vdout0_4ck52 = 0 time = 530
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=530.05n

* CHECK dout0_5 Vdout0_5ck52 = 0 time = 530
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=530.05n

* CHECK dout0_6 Vdout0_6ck52 = 0 time = 530
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=530.05n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 530
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=530.05n

* CHECK dout0_8 Vdout0_8ck52 = 1.8 time = 530
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=530.05n

* CHECK dout0_9 Vdout0_9ck52 = 0 time = 530
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=530.05n

* CHECK dout0_10 Vdout0_10ck52 = 0 time = 530
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=530.05n

* CHECK dout0_11 Vdout0_11ck52 = 1.8 time = 530
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=530.05n

* CHECK dout0_12 Vdout0_12ck52 = 0 time = 530
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=530.05n

* CHECK dout0_13 Vdout0_13ck52 = 0 time = 530
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=530.05n

* CHECK dout0_14 Vdout0_14ck52 = 0 time = 530
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=530.05n

* CHECK dout0_15 Vdout0_15ck52 = 1.8 time = 530
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=530.05n

* CHECK dout0_16 Vdout0_16ck52 = 1.8 time = 530
.meas tran vdout0_16ck52 FIND v(dout0_16) AT=530.05n

* CHECK dout0_17 Vdout0_17ck52 = 0 time = 530
.meas tran vdout0_17ck52 FIND v(dout0_17) AT=530.05n

* CHECK dout0_18 Vdout0_18ck52 = 1.8 time = 530
.meas tran vdout0_18ck52 FIND v(dout0_18) AT=530.05n

* CHECK dout0_19 Vdout0_19ck52 = 1.8 time = 530
.meas tran vdout0_19ck52 FIND v(dout0_19) AT=530.05n

* CHECK dout0_20 Vdout0_20ck52 = 0 time = 530
.meas tran vdout0_20ck52 FIND v(dout0_20) AT=530.05n

* CHECK dout0_21 Vdout0_21ck52 = 0 time = 530
.meas tran vdout0_21ck52 FIND v(dout0_21) AT=530.05n

* CHECK dout0_22 Vdout0_22ck52 = 1.8 time = 530
.meas tran vdout0_22ck52 FIND v(dout0_22) AT=530.05n

* CHECK dout0_23 Vdout0_23ck52 = 1.8 time = 530
.meas tran vdout0_23ck52 FIND v(dout0_23) AT=530.05n

* CHECK dout0_24 Vdout0_24ck52 = 0 time = 530
.meas tran vdout0_24ck52 FIND v(dout0_24) AT=530.05n

* CHECK dout0_25 Vdout0_25ck52 = 1.8 time = 530
.meas tran vdout0_25ck52 FIND v(dout0_25) AT=530.05n

* CHECK dout0_26 Vdout0_26ck52 = 0 time = 530
.meas tran vdout0_26ck52 FIND v(dout0_26) AT=530.05n

* CHECK dout0_27 Vdout0_27ck52 = 0 time = 530
.meas tran vdout0_27ck52 FIND v(dout0_27) AT=530.05n

* CHECK dout0_28 Vdout0_28ck52 = 0 time = 530
.meas tran vdout0_28ck52 FIND v(dout0_28) AT=530.05n

* CHECK dout0_29 Vdout0_29ck52 = 1.8 time = 530
.meas tran vdout0_29ck52 FIND v(dout0_29) AT=530.05n

* CHECK dout0_30 Vdout0_30ck52 = 1.8 time = 530
.meas tran vdout0_30ck52 FIND v(dout0_30) AT=530.05n

* CHECK dout0_31 Vdout0_31ck52 = 0 time = 530
.meas tran vdout0_31ck52 FIND v(dout0_31) AT=530.05n

* CHECK dout0_32 Vdout0_32ck52 = 1.8 time = 530
.meas tran vdout0_32ck52 FIND v(dout0_32) AT=530.05n

* CHECK dout0_33 Vdout0_33ck52 = 0 time = 530
.meas tran vdout0_33ck52 FIND v(dout0_33) AT=530.05n

* CHECK dout0_34 Vdout0_34ck52 = 1.8 time = 530
.meas tran vdout0_34ck52 FIND v(dout0_34) AT=530.05n

* CHECK dout0_35 Vdout0_35ck52 = 0 time = 530
.meas tran vdout0_35ck52 FIND v(dout0_35) AT=530.05n

* CHECK dout0_36 Vdout0_36ck52 = 0 time = 530
.meas tran vdout0_36ck52 FIND v(dout0_36) AT=530.05n

* CHECK dout0_37 Vdout0_37ck52 = 0 time = 530
.meas tran vdout0_37ck52 FIND v(dout0_37) AT=530.05n

* CHECK dout0_38 Vdout0_38ck52 = 1.8 time = 530
.meas tran vdout0_38ck52 FIND v(dout0_38) AT=530.05n

* CHECK dout0_39 Vdout0_39ck52 = 0 time = 530
.meas tran vdout0_39ck52 FIND v(dout0_39) AT=530.05n

* CHECK dout0_40 Vdout0_40ck52 = 0 time = 530
.meas tran vdout0_40ck52 FIND v(dout0_40) AT=530.05n

* CHECK dout0_41 Vdout0_41ck52 = 1.8 time = 530
.meas tran vdout0_41ck52 FIND v(dout0_41) AT=530.05n

* CHECK dout0_42 Vdout0_42ck52 = 0 time = 530
.meas tran vdout0_42ck52 FIND v(dout0_42) AT=530.05n

* CHECK dout0_43 Vdout0_43ck52 = 0 time = 530
.meas tran vdout0_43ck52 FIND v(dout0_43) AT=530.05n

* CHECK dout0_44 Vdout0_44ck52 = 0 time = 530
.meas tran vdout0_44ck52 FIND v(dout0_44) AT=530.05n

* CHECK dout0_45 Vdout0_45ck52 = 0 time = 530
.meas tran vdout0_45ck52 FIND v(dout0_45) AT=530.05n

* CHECK dout0_46 Vdout0_46ck52 = 1.8 time = 530
.meas tran vdout0_46ck52 FIND v(dout0_46) AT=530.05n

* CHECK dout0_47 Vdout0_47ck52 = 1.8 time = 530
.meas tran vdout0_47ck52 FIND v(dout0_47) AT=530.05n

* CHECK dout0_48 Vdout0_48ck52 = 0 time = 530
.meas tran vdout0_48ck52 FIND v(dout0_48) AT=530.05n

* CHECK dout0_49 Vdout0_49ck52 = 1.8 time = 530
.meas tran vdout0_49ck52 FIND v(dout0_49) AT=530.05n

* CHECK dout0_50 Vdout0_50ck52 = 0 time = 530
.meas tran vdout0_50ck52 FIND v(dout0_50) AT=530.05n

* CHECK dout0_51 Vdout0_51ck52 = 1.8 time = 530
.meas tran vdout0_51ck52 FIND v(dout0_51) AT=530.05n

* CHECK dout0_52 Vdout0_52ck52 = 0 time = 530
.meas tran vdout0_52ck52 FIND v(dout0_52) AT=530.05n

* CHECK dout0_53 Vdout0_53ck52 = 1.8 time = 530
.meas tran vdout0_53ck52 FIND v(dout0_53) AT=530.05n

* CHECK dout0_54 Vdout0_54ck52 = 1.8 time = 530
.meas tran vdout0_54ck52 FIND v(dout0_54) AT=530.05n

* CHECK dout0_55 Vdout0_55ck52 = 1.8 time = 530
.meas tran vdout0_55ck52 FIND v(dout0_55) AT=530.05n

* CHECK dout0_56 Vdout0_56ck52 = 1.8 time = 530
.meas tran vdout0_56ck52 FIND v(dout0_56) AT=530.05n

* CHECK dout0_57 Vdout0_57ck52 = 0 time = 530
.meas tran vdout0_57ck52 FIND v(dout0_57) AT=530.05n

* CHECK dout0_58 Vdout0_58ck52 = 1.8 time = 530
.meas tran vdout0_58ck52 FIND v(dout0_58) AT=530.05n

* CHECK dout0_59 Vdout0_59ck52 = 1.8 time = 530
.meas tran vdout0_59ck52 FIND v(dout0_59) AT=530.05n

* CHECK dout0_60 Vdout0_60ck52 = 0 time = 530
.meas tran vdout0_60ck52 FIND v(dout0_60) AT=530.05n

* CHECK dout0_61 Vdout0_61ck52 = 1.8 time = 530
.meas tran vdout0_61ck52 FIND v(dout0_61) AT=530.05n

* CHECK dout0_62 Vdout0_62ck52 = 1.8 time = 530
.meas tran vdout0_62ck52 FIND v(dout0_62) AT=530.05n

* CHECK dout0_63 Vdout0_63ck52 = 1.8 time = 530
.meas tran vdout0_63ck52 FIND v(dout0_63) AT=530.05n

* CHECK dout0_64 Vdout0_64ck52 = 0 time = 530
.meas tran vdout0_64ck52 FIND v(dout0_64) AT=530.05n

* CHECK dout0_0 Vdout0_0ck57 = 0 time = 580
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=580.05n

* CHECK dout0_1 Vdout0_1ck57 = 1.8 time = 580
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=580.05n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 580
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=580.05n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 580
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=580.05n

* CHECK dout0_4 Vdout0_4ck57 = 1.8 time = 580
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=580.05n

* CHECK dout0_5 Vdout0_5ck57 = 1.8 time = 580
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=580.05n

* CHECK dout0_6 Vdout0_6ck57 = 1.8 time = 580
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=580.05n

* CHECK dout0_7 Vdout0_7ck57 = 1.8 time = 580
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=580.05n

* CHECK dout0_8 Vdout0_8ck57 = 1.8 time = 580
.meas tran vdout0_8ck57 FIND v(dout0_8) AT=580.05n

* CHECK dout0_9 Vdout0_9ck57 = 1.8 time = 580
.meas tran vdout0_9ck57 FIND v(dout0_9) AT=580.05n

* CHECK dout0_10 Vdout0_10ck57 = 1.8 time = 580
.meas tran vdout0_10ck57 FIND v(dout0_10) AT=580.05n

* CHECK dout0_11 Vdout0_11ck57 = 1.8 time = 580
.meas tran vdout0_11ck57 FIND v(dout0_11) AT=580.05n

* CHECK dout0_12 Vdout0_12ck57 = 1.8 time = 580
.meas tran vdout0_12ck57 FIND v(dout0_12) AT=580.05n

* CHECK dout0_13 Vdout0_13ck57 = 0 time = 580
.meas tran vdout0_13ck57 FIND v(dout0_13) AT=580.05n

* CHECK dout0_14 Vdout0_14ck57 = 0 time = 580
.meas tran vdout0_14ck57 FIND v(dout0_14) AT=580.05n

* CHECK dout0_15 Vdout0_15ck57 = 0 time = 580
.meas tran vdout0_15ck57 FIND v(dout0_15) AT=580.05n

* CHECK dout0_16 Vdout0_16ck57 = 0 time = 580
.meas tran vdout0_16ck57 FIND v(dout0_16) AT=580.05n

* CHECK dout0_17 Vdout0_17ck57 = 1.8 time = 580
.meas tran vdout0_17ck57 FIND v(dout0_17) AT=580.05n

* CHECK dout0_18 Vdout0_18ck57 = 0 time = 580
.meas tran vdout0_18ck57 FIND v(dout0_18) AT=580.05n

* CHECK dout0_19 Vdout0_19ck57 = 1.8 time = 580
.meas tran vdout0_19ck57 FIND v(dout0_19) AT=580.05n

* CHECK dout0_20 Vdout0_20ck57 = 1.8 time = 580
.meas tran vdout0_20ck57 FIND v(dout0_20) AT=580.05n

* CHECK dout0_21 Vdout0_21ck57 = 1.8 time = 580
.meas tran vdout0_21ck57 FIND v(dout0_21) AT=580.05n

* CHECK dout0_22 Vdout0_22ck57 = 0 time = 580
.meas tran vdout0_22ck57 FIND v(dout0_22) AT=580.05n

* CHECK dout0_23 Vdout0_23ck57 = 1.8 time = 580
.meas tran vdout0_23ck57 FIND v(dout0_23) AT=580.05n

* CHECK dout0_24 Vdout0_24ck57 = 1.8 time = 580
.meas tran vdout0_24ck57 FIND v(dout0_24) AT=580.05n

* CHECK dout0_25 Vdout0_25ck57 = 0 time = 580
.meas tran vdout0_25ck57 FIND v(dout0_25) AT=580.05n

* CHECK dout0_26 Vdout0_26ck57 = 1.8 time = 580
.meas tran vdout0_26ck57 FIND v(dout0_26) AT=580.05n

* CHECK dout0_27 Vdout0_27ck57 = 1.8 time = 580
.meas tran vdout0_27ck57 FIND v(dout0_27) AT=580.05n

* CHECK dout0_28 Vdout0_28ck57 = 0 time = 580
.meas tran vdout0_28ck57 FIND v(dout0_28) AT=580.05n

* CHECK dout0_29 Vdout0_29ck57 = 1.8 time = 580
.meas tran vdout0_29ck57 FIND v(dout0_29) AT=580.05n

* CHECK dout0_30 Vdout0_30ck57 = 0 time = 580
.meas tran vdout0_30ck57 FIND v(dout0_30) AT=580.05n

* CHECK dout0_31 Vdout0_31ck57 = 0 time = 580
.meas tran vdout0_31ck57 FIND v(dout0_31) AT=580.05n

* CHECK dout0_32 Vdout0_32ck57 = 1.8 time = 580
.meas tran vdout0_32ck57 FIND v(dout0_32) AT=580.05n

* CHECK dout0_33 Vdout0_33ck57 = 0 time = 580
.meas tran vdout0_33ck57 FIND v(dout0_33) AT=580.05n

* CHECK dout0_34 Vdout0_34ck57 = 1.8 time = 580
.meas tran vdout0_34ck57 FIND v(dout0_34) AT=580.05n

* CHECK dout0_35 Vdout0_35ck57 = 1.8 time = 580
.meas tran vdout0_35ck57 FIND v(dout0_35) AT=580.05n

* CHECK dout0_36 Vdout0_36ck57 = 0 time = 580
.meas tran vdout0_36ck57 FIND v(dout0_36) AT=580.05n

* CHECK dout0_37 Vdout0_37ck57 = 1.8 time = 580
.meas tran vdout0_37ck57 FIND v(dout0_37) AT=580.05n

* CHECK dout0_38 Vdout0_38ck57 = 1.8 time = 580
.meas tran vdout0_38ck57 FIND v(dout0_38) AT=580.05n

* CHECK dout0_39 Vdout0_39ck57 = 0 time = 580
.meas tran vdout0_39ck57 FIND v(dout0_39) AT=580.05n

* CHECK dout0_40 Vdout0_40ck57 = 0 time = 580
.meas tran vdout0_40ck57 FIND v(dout0_40) AT=580.05n

* CHECK dout0_41 Vdout0_41ck57 = 0 time = 580
.meas tran vdout0_41ck57 FIND v(dout0_41) AT=580.05n

* CHECK dout0_42 Vdout0_42ck57 = 1.8 time = 580
.meas tran vdout0_42ck57 FIND v(dout0_42) AT=580.05n

* CHECK dout0_43 Vdout0_43ck57 = 0 time = 580
.meas tran vdout0_43ck57 FIND v(dout0_43) AT=580.05n

* CHECK dout0_44 Vdout0_44ck57 = 1.8 time = 580
.meas tran vdout0_44ck57 FIND v(dout0_44) AT=580.05n

* CHECK dout0_45 Vdout0_45ck57 = 0 time = 580
.meas tran vdout0_45ck57 FIND v(dout0_45) AT=580.05n

* CHECK dout0_46 Vdout0_46ck57 = 0 time = 580
.meas tran vdout0_46ck57 FIND v(dout0_46) AT=580.05n

* CHECK dout0_47 Vdout0_47ck57 = 0 time = 580
.meas tran vdout0_47ck57 FIND v(dout0_47) AT=580.05n

* CHECK dout0_48 Vdout0_48ck57 = 0 time = 580
.meas tran vdout0_48ck57 FIND v(dout0_48) AT=580.05n

* CHECK dout0_49 Vdout0_49ck57 = 0 time = 580
.meas tran vdout0_49ck57 FIND v(dout0_49) AT=580.05n

* CHECK dout0_50 Vdout0_50ck57 = 1.8 time = 580
.meas tran vdout0_50ck57 FIND v(dout0_50) AT=580.05n

* CHECK dout0_51 Vdout0_51ck57 = 0 time = 580
.meas tran vdout0_51ck57 FIND v(dout0_51) AT=580.05n

* CHECK dout0_52 Vdout0_52ck57 = 1.8 time = 580
.meas tran vdout0_52ck57 FIND v(dout0_52) AT=580.05n

* CHECK dout0_53 Vdout0_53ck57 = 0 time = 580
.meas tran vdout0_53ck57 FIND v(dout0_53) AT=580.05n

* CHECK dout0_54 Vdout0_54ck57 = 1.8 time = 580
.meas tran vdout0_54ck57 FIND v(dout0_54) AT=580.05n

* CHECK dout0_55 Vdout0_55ck57 = 0 time = 580
.meas tran vdout0_55ck57 FIND v(dout0_55) AT=580.05n

* CHECK dout0_56 Vdout0_56ck57 = 0 time = 580
.meas tran vdout0_56ck57 FIND v(dout0_56) AT=580.05n

* CHECK dout0_57 Vdout0_57ck57 = 1.8 time = 580
.meas tran vdout0_57ck57 FIND v(dout0_57) AT=580.05n

* CHECK dout0_58 Vdout0_58ck57 = 1.8 time = 580
.meas tran vdout0_58ck57 FIND v(dout0_58) AT=580.05n

* CHECK dout0_59 Vdout0_59ck57 = 0 time = 580
.meas tran vdout0_59ck57 FIND v(dout0_59) AT=580.05n

* CHECK dout0_60 Vdout0_60ck57 = 1.8 time = 580
.meas tran vdout0_60ck57 FIND v(dout0_60) AT=580.05n

* CHECK dout0_61 Vdout0_61ck57 = 0 time = 580
.meas tran vdout0_61ck57 FIND v(dout0_61) AT=580.05n

* CHECK dout0_62 Vdout0_62ck57 = 1.8 time = 580
.meas tran vdout0_62ck57 FIND v(dout0_62) AT=580.05n

* CHECK dout0_63 Vdout0_63ck57 = 1.8 time = 580
.meas tran vdout0_63ck57 FIND v(dout0_63) AT=580.05n

* CHECK dout0_64 Vdout0_64ck57 = 0 time = 580
.meas tran vdout0_64ck57 FIND v(dout0_64) AT=580.05n

* CHECK dout0_0 Vdout0_0ck60 = 1.8 time = 610
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=610.05n

* CHECK dout0_1 Vdout0_1ck60 = 0 time = 610
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=610.05n

* CHECK dout0_2 Vdout0_2ck60 = 1.8 time = 610
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=610.05n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 610
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=610.05n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 610
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=610.05n

* CHECK dout0_5 Vdout0_5ck60 = 0 time = 610
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=610.05n

* CHECK dout0_6 Vdout0_6ck60 = 1.8 time = 610
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=610.05n

* CHECK dout0_7 Vdout0_7ck60 = 1.8 time = 610
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=610.05n

* CHECK dout0_8 Vdout0_8ck60 = 0 time = 610
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=610.05n

* CHECK dout0_9 Vdout0_9ck60 = 0 time = 610
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=610.05n

* CHECK dout0_10 Vdout0_10ck60 = 0 time = 610
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=610.05n

* CHECK dout0_11 Vdout0_11ck60 = 1.8 time = 610
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=610.05n

* CHECK dout0_12 Vdout0_12ck60 = 1.8 time = 610
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=610.05n

* CHECK dout0_13 Vdout0_13ck60 = 0 time = 610
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=610.05n

* CHECK dout0_14 Vdout0_14ck60 = 1.8 time = 610
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=610.05n

* CHECK dout0_15 Vdout0_15ck60 = 0 time = 610
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=610.05n

* CHECK dout0_16 Vdout0_16ck60 = 1.8 time = 610
.meas tran vdout0_16ck60 FIND v(dout0_16) AT=610.05n

* CHECK dout0_17 Vdout0_17ck60 = 0 time = 610
.meas tran vdout0_17ck60 FIND v(dout0_17) AT=610.05n

* CHECK dout0_18 Vdout0_18ck60 = 1.8 time = 610
.meas tran vdout0_18ck60 FIND v(dout0_18) AT=610.05n

* CHECK dout0_19 Vdout0_19ck60 = 0 time = 610
.meas tran vdout0_19ck60 FIND v(dout0_19) AT=610.05n

* CHECK dout0_20 Vdout0_20ck60 = 0 time = 610
.meas tran vdout0_20ck60 FIND v(dout0_20) AT=610.05n

* CHECK dout0_21 Vdout0_21ck60 = 0 time = 610
.meas tran vdout0_21ck60 FIND v(dout0_21) AT=610.05n

* CHECK dout0_22 Vdout0_22ck60 = 1.8 time = 610
.meas tran vdout0_22ck60 FIND v(dout0_22) AT=610.05n

* CHECK dout0_23 Vdout0_23ck60 = 1.8 time = 610
.meas tran vdout0_23ck60 FIND v(dout0_23) AT=610.05n

* CHECK dout0_24 Vdout0_24ck60 = 1.8 time = 610
.meas tran vdout0_24ck60 FIND v(dout0_24) AT=610.05n

* CHECK dout0_25 Vdout0_25ck60 = 0 time = 610
.meas tran vdout0_25ck60 FIND v(dout0_25) AT=610.05n

* CHECK dout0_26 Vdout0_26ck60 = 0 time = 610
.meas tran vdout0_26ck60 FIND v(dout0_26) AT=610.05n

* CHECK dout0_27 Vdout0_27ck60 = 1.8 time = 610
.meas tran vdout0_27ck60 FIND v(dout0_27) AT=610.05n

* CHECK dout0_28 Vdout0_28ck60 = 1.8 time = 610
.meas tran vdout0_28ck60 FIND v(dout0_28) AT=610.05n

* CHECK dout0_29 Vdout0_29ck60 = 0 time = 610
.meas tran vdout0_29ck60 FIND v(dout0_29) AT=610.05n

* CHECK dout0_30 Vdout0_30ck60 = 0 time = 610
.meas tran vdout0_30ck60 FIND v(dout0_30) AT=610.05n

* CHECK dout0_31 Vdout0_31ck60 = 1.8 time = 610
.meas tran vdout0_31ck60 FIND v(dout0_31) AT=610.05n

* CHECK dout0_32 Vdout0_32ck60 = 0 time = 610
.meas tran vdout0_32ck60 FIND v(dout0_32) AT=610.05n

* CHECK dout0_33 Vdout0_33ck60 = 0 time = 610
.meas tran vdout0_33ck60 FIND v(dout0_33) AT=610.05n

* CHECK dout0_34 Vdout0_34ck60 = 0 time = 610
.meas tran vdout0_34ck60 FIND v(dout0_34) AT=610.05n

* CHECK dout0_35 Vdout0_35ck60 = 1.8 time = 610
.meas tran vdout0_35ck60 FIND v(dout0_35) AT=610.05n

* CHECK dout0_36 Vdout0_36ck60 = 0 time = 610
.meas tran vdout0_36ck60 FIND v(dout0_36) AT=610.05n

* CHECK dout0_37 Vdout0_37ck60 = 0 time = 610
.meas tran vdout0_37ck60 FIND v(dout0_37) AT=610.05n

* CHECK dout0_38 Vdout0_38ck60 = 0 time = 610
.meas tran vdout0_38ck60 FIND v(dout0_38) AT=610.05n

* CHECK dout0_39 Vdout0_39ck60 = 0 time = 610
.meas tran vdout0_39ck60 FIND v(dout0_39) AT=610.05n

* CHECK dout0_40 Vdout0_40ck60 = 0 time = 610
.meas tran vdout0_40ck60 FIND v(dout0_40) AT=610.05n

* CHECK dout0_41 Vdout0_41ck60 = 1.8 time = 610
.meas tran vdout0_41ck60 FIND v(dout0_41) AT=610.05n

* CHECK dout0_42 Vdout0_42ck60 = 1.8 time = 610
.meas tran vdout0_42ck60 FIND v(dout0_42) AT=610.05n

* CHECK dout0_43 Vdout0_43ck60 = 1.8 time = 610
.meas tran vdout0_43ck60 FIND v(dout0_43) AT=610.05n

* CHECK dout0_44 Vdout0_44ck60 = 0 time = 610
.meas tran vdout0_44ck60 FIND v(dout0_44) AT=610.05n

* CHECK dout0_45 Vdout0_45ck60 = 0 time = 610
.meas tran vdout0_45ck60 FIND v(dout0_45) AT=610.05n

* CHECK dout0_46 Vdout0_46ck60 = 1.8 time = 610
.meas tran vdout0_46ck60 FIND v(dout0_46) AT=610.05n

* CHECK dout0_47 Vdout0_47ck60 = 0 time = 610
.meas tran vdout0_47ck60 FIND v(dout0_47) AT=610.05n

* CHECK dout0_48 Vdout0_48ck60 = 0 time = 610
.meas tran vdout0_48ck60 FIND v(dout0_48) AT=610.05n

* CHECK dout0_49 Vdout0_49ck60 = 0 time = 610
.meas tran vdout0_49ck60 FIND v(dout0_49) AT=610.05n

* CHECK dout0_50 Vdout0_50ck60 = 1.8 time = 610
.meas tran vdout0_50ck60 FIND v(dout0_50) AT=610.05n

* CHECK dout0_51 Vdout0_51ck60 = 0 time = 610
.meas tran vdout0_51ck60 FIND v(dout0_51) AT=610.05n

* CHECK dout0_52 Vdout0_52ck60 = 0 time = 610
.meas tran vdout0_52ck60 FIND v(dout0_52) AT=610.05n

* CHECK dout0_53 Vdout0_53ck60 = 1.8 time = 610
.meas tran vdout0_53ck60 FIND v(dout0_53) AT=610.05n

* CHECK dout0_54 Vdout0_54ck60 = 1.8 time = 610
.meas tran vdout0_54ck60 FIND v(dout0_54) AT=610.05n

* CHECK dout0_55 Vdout0_55ck60 = 0 time = 610
.meas tran vdout0_55ck60 FIND v(dout0_55) AT=610.05n

* CHECK dout0_56 Vdout0_56ck60 = 1.8 time = 610
.meas tran vdout0_56ck60 FIND v(dout0_56) AT=610.05n

* CHECK dout0_57 Vdout0_57ck60 = 1.8 time = 610
.meas tran vdout0_57ck60 FIND v(dout0_57) AT=610.05n

* CHECK dout0_58 Vdout0_58ck60 = 0 time = 610
.meas tran vdout0_58ck60 FIND v(dout0_58) AT=610.05n

* CHECK dout0_59 Vdout0_59ck60 = 0 time = 610
.meas tran vdout0_59ck60 FIND v(dout0_59) AT=610.05n

* CHECK dout0_60 Vdout0_60ck60 = 0 time = 610
.meas tran vdout0_60ck60 FIND v(dout0_60) AT=610.05n

* CHECK dout0_61 Vdout0_61ck60 = 1.8 time = 610
.meas tran vdout0_61ck60 FIND v(dout0_61) AT=610.05n

* CHECK dout0_62 Vdout0_62ck60 = 0 time = 610
.meas tran vdout0_62ck60 FIND v(dout0_62) AT=610.05n

* CHECK dout0_63 Vdout0_63ck60 = 0 time = 610
.meas tran vdout0_63ck60 FIND v(dout0_63) AT=610.05n

* CHECK dout0_64 Vdout0_64ck60 = 0 time = 610
.meas tran vdout0_64ck60 FIND v(dout0_64) AT=610.05n

* CHECK dout0_0 Vdout0_0ck70 = 1.8 time = 710
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=710.05n

* CHECK dout0_1 Vdout0_1ck70 = 0 time = 710
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=710.05n

* CHECK dout0_2 Vdout0_2ck70 = 1.8 time = 710
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=710.05n

* CHECK dout0_3 Vdout0_3ck70 = 0 time = 710
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=710.05n

* CHECK dout0_4 Vdout0_4ck70 = 0 time = 710
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=710.05n

* CHECK dout0_5 Vdout0_5ck70 = 0 time = 710
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=710.05n

* CHECK dout0_6 Vdout0_6ck70 = 1.8 time = 710
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=710.05n

* CHECK dout0_7 Vdout0_7ck70 = 1.8 time = 710
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=710.05n

* CHECK dout0_8 Vdout0_8ck70 = 0 time = 710
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=710.05n

* CHECK dout0_9 Vdout0_9ck70 = 0 time = 710
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=710.05n

* CHECK dout0_10 Vdout0_10ck70 = 0 time = 710
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=710.05n

* CHECK dout0_11 Vdout0_11ck70 = 1.8 time = 710
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=710.05n

* CHECK dout0_12 Vdout0_12ck70 = 1.8 time = 710
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=710.05n

* CHECK dout0_13 Vdout0_13ck70 = 0 time = 710
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=710.05n

* CHECK dout0_14 Vdout0_14ck70 = 1.8 time = 710
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=710.05n

* CHECK dout0_15 Vdout0_15ck70 = 0 time = 710
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=710.05n

* CHECK dout0_16 Vdout0_16ck70 = 1.8 time = 710
.meas tran vdout0_16ck70 FIND v(dout0_16) AT=710.05n

* CHECK dout0_17 Vdout0_17ck70 = 0 time = 710
.meas tran vdout0_17ck70 FIND v(dout0_17) AT=710.05n

* CHECK dout0_18 Vdout0_18ck70 = 1.8 time = 710
.meas tran vdout0_18ck70 FIND v(dout0_18) AT=710.05n

* CHECK dout0_19 Vdout0_19ck70 = 0 time = 710
.meas tran vdout0_19ck70 FIND v(dout0_19) AT=710.05n

* CHECK dout0_20 Vdout0_20ck70 = 0 time = 710
.meas tran vdout0_20ck70 FIND v(dout0_20) AT=710.05n

* CHECK dout0_21 Vdout0_21ck70 = 0 time = 710
.meas tran vdout0_21ck70 FIND v(dout0_21) AT=710.05n

* CHECK dout0_22 Vdout0_22ck70 = 1.8 time = 710
.meas tran vdout0_22ck70 FIND v(dout0_22) AT=710.05n

* CHECK dout0_23 Vdout0_23ck70 = 1.8 time = 710
.meas tran vdout0_23ck70 FIND v(dout0_23) AT=710.05n

* CHECK dout0_24 Vdout0_24ck70 = 1.8 time = 710
.meas tran vdout0_24ck70 FIND v(dout0_24) AT=710.05n

* CHECK dout0_25 Vdout0_25ck70 = 0 time = 710
.meas tran vdout0_25ck70 FIND v(dout0_25) AT=710.05n

* CHECK dout0_26 Vdout0_26ck70 = 0 time = 710
.meas tran vdout0_26ck70 FIND v(dout0_26) AT=710.05n

* CHECK dout0_27 Vdout0_27ck70 = 1.8 time = 710
.meas tran vdout0_27ck70 FIND v(dout0_27) AT=710.05n

* CHECK dout0_28 Vdout0_28ck70 = 1.8 time = 710
.meas tran vdout0_28ck70 FIND v(dout0_28) AT=710.05n

* CHECK dout0_29 Vdout0_29ck70 = 0 time = 710
.meas tran vdout0_29ck70 FIND v(dout0_29) AT=710.05n

* CHECK dout0_30 Vdout0_30ck70 = 0 time = 710
.meas tran vdout0_30ck70 FIND v(dout0_30) AT=710.05n

* CHECK dout0_31 Vdout0_31ck70 = 1.8 time = 710
.meas tran vdout0_31ck70 FIND v(dout0_31) AT=710.05n

* CHECK dout0_32 Vdout0_32ck70 = 0 time = 710
.meas tran vdout0_32ck70 FIND v(dout0_32) AT=710.05n

* CHECK dout0_33 Vdout0_33ck70 = 0 time = 710
.meas tran vdout0_33ck70 FIND v(dout0_33) AT=710.05n

* CHECK dout0_34 Vdout0_34ck70 = 0 time = 710
.meas tran vdout0_34ck70 FIND v(dout0_34) AT=710.05n

* CHECK dout0_35 Vdout0_35ck70 = 1.8 time = 710
.meas tran vdout0_35ck70 FIND v(dout0_35) AT=710.05n

* CHECK dout0_36 Vdout0_36ck70 = 0 time = 710
.meas tran vdout0_36ck70 FIND v(dout0_36) AT=710.05n

* CHECK dout0_37 Vdout0_37ck70 = 0 time = 710
.meas tran vdout0_37ck70 FIND v(dout0_37) AT=710.05n

* CHECK dout0_38 Vdout0_38ck70 = 0 time = 710
.meas tran vdout0_38ck70 FIND v(dout0_38) AT=710.05n

* CHECK dout0_39 Vdout0_39ck70 = 0 time = 710
.meas tran vdout0_39ck70 FIND v(dout0_39) AT=710.05n

* CHECK dout0_40 Vdout0_40ck70 = 0 time = 710
.meas tran vdout0_40ck70 FIND v(dout0_40) AT=710.05n

* CHECK dout0_41 Vdout0_41ck70 = 1.8 time = 710
.meas tran vdout0_41ck70 FIND v(dout0_41) AT=710.05n

* CHECK dout0_42 Vdout0_42ck70 = 1.8 time = 710
.meas tran vdout0_42ck70 FIND v(dout0_42) AT=710.05n

* CHECK dout0_43 Vdout0_43ck70 = 1.8 time = 710
.meas tran vdout0_43ck70 FIND v(dout0_43) AT=710.05n

* CHECK dout0_44 Vdout0_44ck70 = 0 time = 710
.meas tran vdout0_44ck70 FIND v(dout0_44) AT=710.05n

* CHECK dout0_45 Vdout0_45ck70 = 0 time = 710
.meas tran vdout0_45ck70 FIND v(dout0_45) AT=710.05n

* CHECK dout0_46 Vdout0_46ck70 = 1.8 time = 710
.meas tran vdout0_46ck70 FIND v(dout0_46) AT=710.05n

* CHECK dout0_47 Vdout0_47ck70 = 0 time = 710
.meas tran vdout0_47ck70 FIND v(dout0_47) AT=710.05n

* CHECK dout0_48 Vdout0_48ck70 = 0 time = 710
.meas tran vdout0_48ck70 FIND v(dout0_48) AT=710.05n

* CHECK dout0_49 Vdout0_49ck70 = 0 time = 710
.meas tran vdout0_49ck70 FIND v(dout0_49) AT=710.05n

* CHECK dout0_50 Vdout0_50ck70 = 1.8 time = 710
.meas tran vdout0_50ck70 FIND v(dout0_50) AT=710.05n

* CHECK dout0_51 Vdout0_51ck70 = 0 time = 710
.meas tran vdout0_51ck70 FIND v(dout0_51) AT=710.05n

* CHECK dout0_52 Vdout0_52ck70 = 0 time = 710
.meas tran vdout0_52ck70 FIND v(dout0_52) AT=710.05n

* CHECK dout0_53 Vdout0_53ck70 = 1.8 time = 710
.meas tran vdout0_53ck70 FIND v(dout0_53) AT=710.05n

* CHECK dout0_54 Vdout0_54ck70 = 1.8 time = 710
.meas tran vdout0_54ck70 FIND v(dout0_54) AT=710.05n

* CHECK dout0_55 Vdout0_55ck70 = 0 time = 710
.meas tran vdout0_55ck70 FIND v(dout0_55) AT=710.05n

* CHECK dout0_56 Vdout0_56ck70 = 1.8 time = 710
.meas tran vdout0_56ck70 FIND v(dout0_56) AT=710.05n

* CHECK dout0_57 Vdout0_57ck70 = 1.8 time = 710
.meas tran vdout0_57ck70 FIND v(dout0_57) AT=710.05n

* CHECK dout0_58 Vdout0_58ck70 = 0 time = 710
.meas tran vdout0_58ck70 FIND v(dout0_58) AT=710.05n

* CHECK dout0_59 Vdout0_59ck70 = 0 time = 710
.meas tran vdout0_59ck70 FIND v(dout0_59) AT=710.05n

* CHECK dout0_60 Vdout0_60ck70 = 0 time = 710
.meas tran vdout0_60ck70 FIND v(dout0_60) AT=710.05n

* CHECK dout0_61 Vdout0_61ck70 = 1.8 time = 710
.meas tran vdout0_61ck70 FIND v(dout0_61) AT=710.05n

* CHECK dout0_62 Vdout0_62ck70 = 0 time = 710
.meas tran vdout0_62ck70 FIND v(dout0_62) AT=710.05n

* CHECK dout0_63 Vdout0_63ck70 = 0 time = 710
.meas tran vdout0_63ck70 FIND v(dout0_63) AT=710.05n

* CHECK dout0_64 Vdout0_64ck70 = 0 time = 710
.meas tran vdout0_64ck70 FIND v(dout0_64) AT=710.05n

* CHECK dout0_0 Vdout0_0ck72 = 1.8 time = 730
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=730.05n

* CHECK dout0_1 Vdout0_1ck72 = 1.8 time = 730
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=730.05n

* CHECK dout0_2 Vdout0_2ck72 = 1.8 time = 730
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=730.05n

* CHECK dout0_3 Vdout0_3ck72 = 1.8 time = 730
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=730.05n

* CHECK dout0_4 Vdout0_4ck72 = 1.8 time = 730
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=730.05n

* CHECK dout0_5 Vdout0_5ck72 = 0 time = 730
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=730.05n

* CHECK dout0_6 Vdout0_6ck72 = 1.8 time = 730
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=730.05n

* CHECK dout0_7 Vdout0_7ck72 = 1.8 time = 730
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=730.05n

* CHECK dout0_8 Vdout0_8ck72 = 1.8 time = 730
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=730.05n

* CHECK dout0_9 Vdout0_9ck72 = 1.8 time = 730
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=730.05n

* CHECK dout0_10 Vdout0_10ck72 = 0 time = 730
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=730.05n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 730
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=730.05n

* CHECK dout0_12 Vdout0_12ck72 = 1.8 time = 730
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=730.05n

* CHECK dout0_13 Vdout0_13ck72 = 0 time = 730
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=730.05n

* CHECK dout0_14 Vdout0_14ck72 = 0 time = 730
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=730.05n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 730
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=730.05n

* CHECK dout0_16 Vdout0_16ck72 = 1.8 time = 730
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=730.05n

* CHECK dout0_17 Vdout0_17ck72 = 0 time = 730
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=730.05n

* CHECK dout0_18 Vdout0_18ck72 = 1.8 time = 730
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=730.05n

* CHECK dout0_19 Vdout0_19ck72 = 0 time = 730
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=730.05n

* CHECK dout0_20 Vdout0_20ck72 = 1.8 time = 730
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=730.05n

* CHECK dout0_21 Vdout0_21ck72 = 1.8 time = 730
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=730.05n

* CHECK dout0_22 Vdout0_22ck72 = 0 time = 730
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=730.05n

* CHECK dout0_23 Vdout0_23ck72 = 1.8 time = 730
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=730.05n

* CHECK dout0_24 Vdout0_24ck72 = 1.8 time = 730
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=730.05n

* CHECK dout0_25 Vdout0_25ck72 = 0 time = 730
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=730.05n

* CHECK dout0_26 Vdout0_26ck72 = 1.8 time = 730
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=730.05n

* CHECK dout0_27 Vdout0_27ck72 = 1.8 time = 730
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=730.05n

* CHECK dout0_28 Vdout0_28ck72 = 0 time = 730
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=730.05n

* CHECK dout0_29 Vdout0_29ck72 = 1.8 time = 730
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=730.05n

* CHECK dout0_30 Vdout0_30ck72 = 0 time = 730
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=730.05n

* CHECK dout0_31 Vdout0_31ck72 = 1.8 time = 730
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=730.05n

* CHECK dout0_32 Vdout0_32ck72 = 1.8 time = 730
.meas tran vdout0_32ck72 FIND v(dout0_32) AT=730.05n

* CHECK dout0_33 Vdout0_33ck72 = 1.8 time = 730
.meas tran vdout0_33ck72 FIND v(dout0_33) AT=730.05n

* CHECK dout0_34 Vdout0_34ck72 = 1.8 time = 730
.meas tran vdout0_34ck72 FIND v(dout0_34) AT=730.05n

* CHECK dout0_35 Vdout0_35ck72 = 1.8 time = 730
.meas tran vdout0_35ck72 FIND v(dout0_35) AT=730.05n

* CHECK dout0_36 Vdout0_36ck72 = 0 time = 730
.meas tran vdout0_36ck72 FIND v(dout0_36) AT=730.05n

* CHECK dout0_37 Vdout0_37ck72 = 0 time = 730
.meas tran vdout0_37ck72 FIND v(dout0_37) AT=730.05n

* CHECK dout0_38 Vdout0_38ck72 = 0 time = 730
.meas tran vdout0_38ck72 FIND v(dout0_38) AT=730.05n

* CHECK dout0_39 Vdout0_39ck72 = 0 time = 730
.meas tran vdout0_39ck72 FIND v(dout0_39) AT=730.05n

* CHECK dout0_40 Vdout0_40ck72 = 1.8 time = 730
.meas tran vdout0_40ck72 FIND v(dout0_40) AT=730.05n

* CHECK dout0_41 Vdout0_41ck72 = 1.8 time = 730
.meas tran vdout0_41ck72 FIND v(dout0_41) AT=730.05n

* CHECK dout0_42 Vdout0_42ck72 = 1.8 time = 730
.meas tran vdout0_42ck72 FIND v(dout0_42) AT=730.05n

* CHECK dout0_43 Vdout0_43ck72 = 1.8 time = 730
.meas tran vdout0_43ck72 FIND v(dout0_43) AT=730.05n

* CHECK dout0_44 Vdout0_44ck72 = 0 time = 730
.meas tran vdout0_44ck72 FIND v(dout0_44) AT=730.05n

* CHECK dout0_45 Vdout0_45ck72 = 0 time = 730
.meas tran vdout0_45ck72 FIND v(dout0_45) AT=730.05n

* CHECK dout0_46 Vdout0_46ck72 = 0 time = 730
.meas tran vdout0_46ck72 FIND v(dout0_46) AT=730.05n

* CHECK dout0_47 Vdout0_47ck72 = 1.8 time = 730
.meas tran vdout0_47ck72 FIND v(dout0_47) AT=730.05n

* CHECK dout0_48 Vdout0_48ck72 = 1.8 time = 730
.meas tran vdout0_48ck72 FIND v(dout0_48) AT=730.05n

* CHECK dout0_49 Vdout0_49ck72 = 1.8 time = 730
.meas tran vdout0_49ck72 FIND v(dout0_49) AT=730.05n

* CHECK dout0_50 Vdout0_50ck72 = 1.8 time = 730
.meas tran vdout0_50ck72 FIND v(dout0_50) AT=730.05n

* CHECK dout0_51 Vdout0_51ck72 = 1.8 time = 730
.meas tran vdout0_51ck72 FIND v(dout0_51) AT=730.05n

* CHECK dout0_52 Vdout0_52ck72 = 0 time = 730
.meas tran vdout0_52ck72 FIND v(dout0_52) AT=730.05n

* CHECK dout0_53 Vdout0_53ck72 = 0 time = 730
.meas tran vdout0_53ck72 FIND v(dout0_53) AT=730.05n

* CHECK dout0_54 Vdout0_54ck72 = 1.8 time = 730
.meas tran vdout0_54ck72 FIND v(dout0_54) AT=730.05n

* CHECK dout0_55 Vdout0_55ck72 = 1.8 time = 730
.meas tran vdout0_55ck72 FIND v(dout0_55) AT=730.05n

* CHECK dout0_56 Vdout0_56ck72 = 1.8 time = 730
.meas tran vdout0_56ck72 FIND v(dout0_56) AT=730.05n

* CHECK dout0_57 Vdout0_57ck72 = 1.8 time = 730
.meas tran vdout0_57ck72 FIND v(dout0_57) AT=730.05n

* CHECK dout0_58 Vdout0_58ck72 = 1.8 time = 730
.meas tran vdout0_58ck72 FIND v(dout0_58) AT=730.05n

* CHECK dout0_59 Vdout0_59ck72 = 0 time = 730
.meas tran vdout0_59ck72 FIND v(dout0_59) AT=730.05n

* CHECK dout0_60 Vdout0_60ck72 = 1.8 time = 730
.meas tran vdout0_60ck72 FIND v(dout0_60) AT=730.05n

* CHECK dout0_61 Vdout0_61ck72 = 1.8 time = 730
.meas tran vdout0_61ck72 FIND v(dout0_61) AT=730.05n

* CHECK dout0_62 Vdout0_62ck72 = 1.8 time = 730
.meas tran vdout0_62ck72 FIND v(dout0_62) AT=730.05n

* CHECK dout0_63 Vdout0_63ck72 = 1.8 time = 730
.meas tran vdout0_63ck72 FIND v(dout0_63) AT=730.05n

* CHECK dout0_64 Vdout0_64ck72 = 0 time = 730
.meas tran vdout0_64ck72 FIND v(dout0_64) AT=730.05n

* CHECK dout0_0 Vdout0_0ck73 = 1.8 time = 740
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=740.05n

* CHECK dout0_1 Vdout0_1ck73 = 1.8 time = 740
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=740.05n

* CHECK dout0_2 Vdout0_2ck73 = 1.8 time = 740
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=740.05n

* CHECK dout0_3 Vdout0_3ck73 = 1.8 time = 740
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=740.05n

* CHECK dout0_4 Vdout0_4ck73 = 1.8 time = 740
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=740.05n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 740
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=740.05n

* CHECK dout0_6 Vdout0_6ck73 = 1.8 time = 740
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=740.05n

* CHECK dout0_7 Vdout0_7ck73 = 1.8 time = 740
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=740.05n

* CHECK dout0_8 Vdout0_8ck73 = 1.8 time = 740
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=740.05n

* CHECK dout0_9 Vdout0_9ck73 = 1.8 time = 740
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=740.05n

* CHECK dout0_10 Vdout0_10ck73 = 0 time = 740
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=740.05n

* CHECK dout0_11 Vdout0_11ck73 = 0 time = 740
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=740.05n

* CHECK dout0_12 Vdout0_12ck73 = 1.8 time = 740
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=740.05n

* CHECK dout0_13 Vdout0_13ck73 = 0 time = 740
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=740.05n

* CHECK dout0_14 Vdout0_14ck73 = 0 time = 740
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=740.05n

* CHECK dout0_15 Vdout0_15ck73 = 0 time = 740
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=740.05n

* CHECK dout0_16 Vdout0_16ck73 = 1.8 time = 740
.meas tran vdout0_16ck73 FIND v(dout0_16) AT=740.05n

* CHECK dout0_17 Vdout0_17ck73 = 0 time = 740
.meas tran vdout0_17ck73 FIND v(dout0_17) AT=740.05n

* CHECK dout0_18 Vdout0_18ck73 = 1.8 time = 740
.meas tran vdout0_18ck73 FIND v(dout0_18) AT=740.05n

* CHECK dout0_19 Vdout0_19ck73 = 0 time = 740
.meas tran vdout0_19ck73 FIND v(dout0_19) AT=740.05n

* CHECK dout0_20 Vdout0_20ck73 = 1.8 time = 740
.meas tran vdout0_20ck73 FIND v(dout0_20) AT=740.05n

* CHECK dout0_21 Vdout0_21ck73 = 1.8 time = 740
.meas tran vdout0_21ck73 FIND v(dout0_21) AT=740.05n

* CHECK dout0_22 Vdout0_22ck73 = 0 time = 740
.meas tran vdout0_22ck73 FIND v(dout0_22) AT=740.05n

* CHECK dout0_23 Vdout0_23ck73 = 1.8 time = 740
.meas tran vdout0_23ck73 FIND v(dout0_23) AT=740.05n

* CHECK dout0_24 Vdout0_24ck73 = 1.8 time = 740
.meas tran vdout0_24ck73 FIND v(dout0_24) AT=740.05n

* CHECK dout0_25 Vdout0_25ck73 = 0 time = 740
.meas tran vdout0_25ck73 FIND v(dout0_25) AT=740.05n

* CHECK dout0_26 Vdout0_26ck73 = 1.8 time = 740
.meas tran vdout0_26ck73 FIND v(dout0_26) AT=740.05n

* CHECK dout0_27 Vdout0_27ck73 = 1.8 time = 740
.meas tran vdout0_27ck73 FIND v(dout0_27) AT=740.05n

* CHECK dout0_28 Vdout0_28ck73 = 0 time = 740
.meas tran vdout0_28ck73 FIND v(dout0_28) AT=740.05n

* CHECK dout0_29 Vdout0_29ck73 = 1.8 time = 740
.meas tran vdout0_29ck73 FIND v(dout0_29) AT=740.05n

* CHECK dout0_30 Vdout0_30ck73 = 0 time = 740
.meas tran vdout0_30ck73 FIND v(dout0_30) AT=740.05n

* CHECK dout0_31 Vdout0_31ck73 = 1.8 time = 740
.meas tran vdout0_31ck73 FIND v(dout0_31) AT=740.05n

* CHECK dout0_32 Vdout0_32ck73 = 1.8 time = 740
.meas tran vdout0_32ck73 FIND v(dout0_32) AT=740.05n

* CHECK dout0_33 Vdout0_33ck73 = 1.8 time = 740
.meas tran vdout0_33ck73 FIND v(dout0_33) AT=740.05n

* CHECK dout0_34 Vdout0_34ck73 = 1.8 time = 740
.meas tran vdout0_34ck73 FIND v(dout0_34) AT=740.05n

* CHECK dout0_35 Vdout0_35ck73 = 1.8 time = 740
.meas tran vdout0_35ck73 FIND v(dout0_35) AT=740.05n

* CHECK dout0_36 Vdout0_36ck73 = 0 time = 740
.meas tran vdout0_36ck73 FIND v(dout0_36) AT=740.05n

* CHECK dout0_37 Vdout0_37ck73 = 0 time = 740
.meas tran vdout0_37ck73 FIND v(dout0_37) AT=740.05n

* CHECK dout0_38 Vdout0_38ck73 = 0 time = 740
.meas tran vdout0_38ck73 FIND v(dout0_38) AT=740.05n

* CHECK dout0_39 Vdout0_39ck73 = 0 time = 740
.meas tran vdout0_39ck73 FIND v(dout0_39) AT=740.05n

* CHECK dout0_40 Vdout0_40ck73 = 1.8 time = 740
.meas tran vdout0_40ck73 FIND v(dout0_40) AT=740.05n

* CHECK dout0_41 Vdout0_41ck73 = 1.8 time = 740
.meas tran vdout0_41ck73 FIND v(dout0_41) AT=740.05n

* CHECK dout0_42 Vdout0_42ck73 = 1.8 time = 740
.meas tran vdout0_42ck73 FIND v(dout0_42) AT=740.05n

* CHECK dout0_43 Vdout0_43ck73 = 1.8 time = 740
.meas tran vdout0_43ck73 FIND v(dout0_43) AT=740.05n

* CHECK dout0_44 Vdout0_44ck73 = 0 time = 740
.meas tran vdout0_44ck73 FIND v(dout0_44) AT=740.05n

* CHECK dout0_45 Vdout0_45ck73 = 0 time = 740
.meas tran vdout0_45ck73 FIND v(dout0_45) AT=740.05n

* CHECK dout0_46 Vdout0_46ck73 = 0 time = 740
.meas tran vdout0_46ck73 FIND v(dout0_46) AT=740.05n

* CHECK dout0_47 Vdout0_47ck73 = 1.8 time = 740
.meas tran vdout0_47ck73 FIND v(dout0_47) AT=740.05n

* CHECK dout0_48 Vdout0_48ck73 = 1.8 time = 740
.meas tran vdout0_48ck73 FIND v(dout0_48) AT=740.05n

* CHECK dout0_49 Vdout0_49ck73 = 1.8 time = 740
.meas tran vdout0_49ck73 FIND v(dout0_49) AT=740.05n

* CHECK dout0_50 Vdout0_50ck73 = 1.8 time = 740
.meas tran vdout0_50ck73 FIND v(dout0_50) AT=740.05n

* CHECK dout0_51 Vdout0_51ck73 = 1.8 time = 740
.meas tran vdout0_51ck73 FIND v(dout0_51) AT=740.05n

* CHECK dout0_52 Vdout0_52ck73 = 0 time = 740
.meas tran vdout0_52ck73 FIND v(dout0_52) AT=740.05n

* CHECK dout0_53 Vdout0_53ck73 = 0 time = 740
.meas tran vdout0_53ck73 FIND v(dout0_53) AT=740.05n

* CHECK dout0_54 Vdout0_54ck73 = 1.8 time = 740
.meas tran vdout0_54ck73 FIND v(dout0_54) AT=740.05n

* CHECK dout0_55 Vdout0_55ck73 = 1.8 time = 740
.meas tran vdout0_55ck73 FIND v(dout0_55) AT=740.05n

* CHECK dout0_56 Vdout0_56ck73 = 1.8 time = 740
.meas tran vdout0_56ck73 FIND v(dout0_56) AT=740.05n

* CHECK dout0_57 Vdout0_57ck73 = 1.8 time = 740
.meas tran vdout0_57ck73 FIND v(dout0_57) AT=740.05n

* CHECK dout0_58 Vdout0_58ck73 = 1.8 time = 740
.meas tran vdout0_58ck73 FIND v(dout0_58) AT=740.05n

* CHECK dout0_59 Vdout0_59ck73 = 0 time = 740
.meas tran vdout0_59ck73 FIND v(dout0_59) AT=740.05n

* CHECK dout0_60 Vdout0_60ck73 = 1.8 time = 740
.meas tran vdout0_60ck73 FIND v(dout0_60) AT=740.05n

* CHECK dout0_61 Vdout0_61ck73 = 1.8 time = 740
.meas tran vdout0_61ck73 FIND v(dout0_61) AT=740.05n

* CHECK dout0_62 Vdout0_62ck73 = 1.8 time = 740
.meas tran vdout0_62ck73 FIND v(dout0_62) AT=740.05n

* CHECK dout0_63 Vdout0_63ck73 = 1.8 time = 740
.meas tran vdout0_63ck73 FIND v(dout0_63) AT=740.05n

* CHECK dout0_64 Vdout0_64ck73 = 0 time = 740
.meas tran vdout0_64ck73 FIND v(dout0_64) AT=740.05n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 750
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=750.05n

* CHECK dout0_1 Vdout0_1ck74 = 1.8 time = 750
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=750.05n

* CHECK dout0_2 Vdout0_2ck74 = 0 time = 750
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=750.05n

* CHECK dout0_3 Vdout0_3ck74 = 0 time = 750
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=750.05n

* CHECK dout0_4 Vdout0_4ck74 = 1.8 time = 750
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=750.05n

* CHECK dout0_5 Vdout0_5ck74 = 1.8 time = 750
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=750.05n

* CHECK dout0_6 Vdout0_6ck74 = 1.8 time = 750
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=750.05n

* CHECK dout0_7 Vdout0_7ck74 = 1.8 time = 750
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=750.05n

* CHECK dout0_8 Vdout0_8ck74 = 1.8 time = 750
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=750.05n

* CHECK dout0_9 Vdout0_9ck74 = 1.8 time = 750
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=750.05n

* CHECK dout0_10 Vdout0_10ck74 = 1.8 time = 750
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=750.05n

* CHECK dout0_11 Vdout0_11ck74 = 1.8 time = 750
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=750.05n

* CHECK dout0_12 Vdout0_12ck74 = 1.8 time = 750
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=750.05n

* CHECK dout0_13 Vdout0_13ck74 = 0 time = 750
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=750.05n

* CHECK dout0_14 Vdout0_14ck74 = 0 time = 750
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=750.05n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 750
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=750.05n

* CHECK dout0_16 Vdout0_16ck74 = 0 time = 750
.meas tran vdout0_16ck74 FIND v(dout0_16) AT=750.05n

* CHECK dout0_17 Vdout0_17ck74 = 1.8 time = 750
.meas tran vdout0_17ck74 FIND v(dout0_17) AT=750.05n

* CHECK dout0_18 Vdout0_18ck74 = 0 time = 750
.meas tran vdout0_18ck74 FIND v(dout0_18) AT=750.05n

* CHECK dout0_19 Vdout0_19ck74 = 1.8 time = 750
.meas tran vdout0_19ck74 FIND v(dout0_19) AT=750.05n

* CHECK dout0_20 Vdout0_20ck74 = 1.8 time = 750
.meas tran vdout0_20ck74 FIND v(dout0_20) AT=750.05n

* CHECK dout0_21 Vdout0_21ck74 = 1.8 time = 750
.meas tran vdout0_21ck74 FIND v(dout0_21) AT=750.05n

* CHECK dout0_22 Vdout0_22ck74 = 0 time = 750
.meas tran vdout0_22ck74 FIND v(dout0_22) AT=750.05n

* CHECK dout0_23 Vdout0_23ck74 = 1.8 time = 750
.meas tran vdout0_23ck74 FIND v(dout0_23) AT=750.05n

* CHECK dout0_24 Vdout0_24ck74 = 1.8 time = 750
.meas tran vdout0_24ck74 FIND v(dout0_24) AT=750.05n

* CHECK dout0_25 Vdout0_25ck74 = 0 time = 750
.meas tran vdout0_25ck74 FIND v(dout0_25) AT=750.05n

* CHECK dout0_26 Vdout0_26ck74 = 1.8 time = 750
.meas tran vdout0_26ck74 FIND v(dout0_26) AT=750.05n

* CHECK dout0_27 Vdout0_27ck74 = 1.8 time = 750
.meas tran vdout0_27ck74 FIND v(dout0_27) AT=750.05n

* CHECK dout0_28 Vdout0_28ck74 = 0 time = 750
.meas tran vdout0_28ck74 FIND v(dout0_28) AT=750.05n

* CHECK dout0_29 Vdout0_29ck74 = 1.8 time = 750
.meas tran vdout0_29ck74 FIND v(dout0_29) AT=750.05n

* CHECK dout0_30 Vdout0_30ck74 = 0 time = 750
.meas tran vdout0_30ck74 FIND v(dout0_30) AT=750.05n

* CHECK dout0_31 Vdout0_31ck74 = 0 time = 750
.meas tran vdout0_31ck74 FIND v(dout0_31) AT=750.05n

* CHECK dout0_32 Vdout0_32ck74 = 1.8 time = 750
.meas tran vdout0_32ck74 FIND v(dout0_32) AT=750.05n

* CHECK dout0_33 Vdout0_33ck74 = 0 time = 750
.meas tran vdout0_33ck74 FIND v(dout0_33) AT=750.05n

* CHECK dout0_34 Vdout0_34ck74 = 1.8 time = 750
.meas tran vdout0_34ck74 FIND v(dout0_34) AT=750.05n

* CHECK dout0_35 Vdout0_35ck74 = 1.8 time = 750
.meas tran vdout0_35ck74 FIND v(dout0_35) AT=750.05n

* CHECK dout0_36 Vdout0_36ck74 = 0 time = 750
.meas tran vdout0_36ck74 FIND v(dout0_36) AT=750.05n

* CHECK dout0_37 Vdout0_37ck74 = 1.8 time = 750
.meas tran vdout0_37ck74 FIND v(dout0_37) AT=750.05n

* CHECK dout0_38 Vdout0_38ck74 = 1.8 time = 750
.meas tran vdout0_38ck74 FIND v(dout0_38) AT=750.05n

* CHECK dout0_39 Vdout0_39ck74 = 0 time = 750
.meas tran vdout0_39ck74 FIND v(dout0_39) AT=750.05n

* CHECK dout0_40 Vdout0_40ck74 = 0 time = 750
.meas tran vdout0_40ck74 FIND v(dout0_40) AT=750.05n

* CHECK dout0_41 Vdout0_41ck74 = 0 time = 750
.meas tran vdout0_41ck74 FIND v(dout0_41) AT=750.05n

* CHECK dout0_42 Vdout0_42ck74 = 1.8 time = 750
.meas tran vdout0_42ck74 FIND v(dout0_42) AT=750.05n

* CHECK dout0_43 Vdout0_43ck74 = 0 time = 750
.meas tran vdout0_43ck74 FIND v(dout0_43) AT=750.05n

* CHECK dout0_44 Vdout0_44ck74 = 1.8 time = 750
.meas tran vdout0_44ck74 FIND v(dout0_44) AT=750.05n

* CHECK dout0_45 Vdout0_45ck74 = 0 time = 750
.meas tran vdout0_45ck74 FIND v(dout0_45) AT=750.05n

* CHECK dout0_46 Vdout0_46ck74 = 0 time = 750
.meas tran vdout0_46ck74 FIND v(dout0_46) AT=750.05n

* CHECK dout0_47 Vdout0_47ck74 = 0 time = 750
.meas tran vdout0_47ck74 FIND v(dout0_47) AT=750.05n

* CHECK dout0_48 Vdout0_48ck74 = 0 time = 750
.meas tran vdout0_48ck74 FIND v(dout0_48) AT=750.05n

* CHECK dout0_49 Vdout0_49ck74 = 0 time = 750
.meas tran vdout0_49ck74 FIND v(dout0_49) AT=750.05n

* CHECK dout0_50 Vdout0_50ck74 = 1.8 time = 750
.meas tran vdout0_50ck74 FIND v(dout0_50) AT=750.05n

* CHECK dout0_51 Vdout0_51ck74 = 0 time = 750
.meas tran vdout0_51ck74 FIND v(dout0_51) AT=750.05n

* CHECK dout0_52 Vdout0_52ck74 = 1.8 time = 750
.meas tran vdout0_52ck74 FIND v(dout0_52) AT=750.05n

* CHECK dout0_53 Vdout0_53ck74 = 0 time = 750
.meas tran vdout0_53ck74 FIND v(dout0_53) AT=750.05n

* CHECK dout0_54 Vdout0_54ck74 = 1.8 time = 750
.meas tran vdout0_54ck74 FIND v(dout0_54) AT=750.05n

* CHECK dout0_55 Vdout0_55ck74 = 0 time = 750
.meas tran vdout0_55ck74 FIND v(dout0_55) AT=750.05n

* CHECK dout0_56 Vdout0_56ck74 = 0 time = 750
.meas tran vdout0_56ck74 FIND v(dout0_56) AT=750.05n

* CHECK dout0_57 Vdout0_57ck74 = 1.8 time = 750
.meas tran vdout0_57ck74 FIND v(dout0_57) AT=750.05n

* CHECK dout0_58 Vdout0_58ck74 = 1.8 time = 750
.meas tran vdout0_58ck74 FIND v(dout0_58) AT=750.05n

* CHECK dout0_59 Vdout0_59ck74 = 0 time = 750
.meas tran vdout0_59ck74 FIND v(dout0_59) AT=750.05n

* CHECK dout0_60 Vdout0_60ck74 = 1.8 time = 750
.meas tran vdout0_60ck74 FIND v(dout0_60) AT=750.05n

* CHECK dout0_61 Vdout0_61ck74 = 0 time = 750
.meas tran vdout0_61ck74 FIND v(dout0_61) AT=750.05n

* CHECK dout0_62 Vdout0_62ck74 = 1.8 time = 750
.meas tran vdout0_62ck74 FIND v(dout0_62) AT=750.05n

* CHECK dout0_63 Vdout0_63ck74 = 1.8 time = 750
.meas tran vdout0_63ck74 FIND v(dout0_63) AT=750.05n

* CHECK dout0_64 Vdout0_64ck74 = 0 time = 750
.meas tran vdout0_64ck74 FIND v(dout0_64) AT=750.05n

* CHECK dout0_0 Vdout0_0ck77 = 0 time = 780
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=780.05n

* CHECK dout0_1 Vdout0_1ck77 = 0 time = 780
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=780.05n

* CHECK dout0_2 Vdout0_2ck77 = 1.8 time = 780
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=780.05n

* CHECK dout0_3 Vdout0_3ck77 = 1.8 time = 780
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=780.05n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 780
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=780.05n

* CHECK dout0_5 Vdout0_5ck77 = 0 time = 780
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=780.05n

* CHECK dout0_6 Vdout0_6ck77 = 1.8 time = 780
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=780.05n

* CHECK dout0_7 Vdout0_7ck77 = 0 time = 780
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=780.05n

* CHECK dout0_8 Vdout0_8ck77 = 0 time = 780
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=780.05n

* CHECK dout0_9 Vdout0_9ck77 = 1.8 time = 780
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=780.05n

* CHECK dout0_10 Vdout0_10ck77 = 0 time = 780
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=780.05n

* CHECK dout0_11 Vdout0_11ck77 = 1.8 time = 780
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=780.05n

* CHECK dout0_12 Vdout0_12ck77 = 0 time = 780
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=780.05n

* CHECK dout0_13 Vdout0_13ck77 = 0 time = 780
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=780.05n

* CHECK dout0_14 Vdout0_14ck77 = 1.8 time = 780
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=780.05n

* CHECK dout0_15 Vdout0_15ck77 = 1.8 time = 780
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=780.05n

* CHECK dout0_16 Vdout0_16ck77 = 0 time = 780
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=780.05n

* CHECK dout0_17 Vdout0_17ck77 = 0 time = 780
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=780.05n

* CHECK dout0_18 Vdout0_18ck77 = 1.8 time = 780
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=780.05n

* CHECK dout0_19 Vdout0_19ck77 = 1.8 time = 780
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=780.05n

* CHECK dout0_20 Vdout0_20ck77 = 1.8 time = 780
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=780.05n

* CHECK dout0_21 Vdout0_21ck77 = 1.8 time = 780
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=780.05n

* CHECK dout0_22 Vdout0_22ck77 = 1.8 time = 780
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=780.05n

* CHECK dout0_23 Vdout0_23ck77 = 0 time = 780
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=780.05n

* CHECK dout0_24 Vdout0_24ck77 = 1.8 time = 780
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=780.05n

* CHECK dout0_25 Vdout0_25ck77 = 0 time = 780
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=780.05n

* CHECK dout0_26 Vdout0_26ck77 = 1.8 time = 780
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=780.05n

* CHECK dout0_27 Vdout0_27ck77 = 0 time = 780
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=780.05n

* CHECK dout0_28 Vdout0_28ck77 = 0 time = 780
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=780.05n

* CHECK dout0_29 Vdout0_29ck77 = 1.8 time = 780
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=780.05n

* CHECK dout0_30 Vdout0_30ck77 = 0 time = 780
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=780.05n

* CHECK dout0_31 Vdout0_31ck77 = 0 time = 780
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=780.05n

* CHECK dout0_32 Vdout0_32ck77 = 0 time = 780
.meas tran vdout0_32ck77 FIND v(dout0_32) AT=780.05n

* CHECK dout0_33 Vdout0_33ck77 = 1.8 time = 780
.meas tran vdout0_33ck77 FIND v(dout0_33) AT=780.05n

* CHECK dout0_34 Vdout0_34ck77 = 1.8 time = 780
.meas tran vdout0_34ck77 FIND v(dout0_34) AT=780.05n

* CHECK dout0_35 Vdout0_35ck77 = 0 time = 780
.meas tran vdout0_35ck77 FIND v(dout0_35) AT=780.05n

* CHECK dout0_36 Vdout0_36ck77 = 0 time = 780
.meas tran vdout0_36ck77 FIND v(dout0_36) AT=780.05n

* CHECK dout0_37 Vdout0_37ck77 = 1.8 time = 780
.meas tran vdout0_37ck77 FIND v(dout0_37) AT=780.05n

* CHECK dout0_38 Vdout0_38ck77 = 1.8 time = 780
.meas tran vdout0_38ck77 FIND v(dout0_38) AT=780.05n

* CHECK dout0_39 Vdout0_39ck77 = 0 time = 780
.meas tran vdout0_39ck77 FIND v(dout0_39) AT=780.05n

* CHECK dout0_40 Vdout0_40ck77 = 0 time = 780
.meas tran vdout0_40ck77 FIND v(dout0_40) AT=780.05n

* CHECK dout0_41 Vdout0_41ck77 = 0 time = 780
.meas tran vdout0_41ck77 FIND v(dout0_41) AT=780.05n

* CHECK dout0_42 Vdout0_42ck77 = 1.8 time = 780
.meas tran vdout0_42ck77 FIND v(dout0_42) AT=780.05n

* CHECK dout0_43 Vdout0_43ck77 = 0 time = 780
.meas tran vdout0_43ck77 FIND v(dout0_43) AT=780.05n

* CHECK dout0_44 Vdout0_44ck77 = 1.8 time = 780
.meas tran vdout0_44ck77 FIND v(dout0_44) AT=780.05n

* CHECK dout0_45 Vdout0_45ck77 = 1.8 time = 780
.meas tran vdout0_45ck77 FIND v(dout0_45) AT=780.05n

* CHECK dout0_46 Vdout0_46ck77 = 0 time = 780
.meas tran vdout0_46ck77 FIND v(dout0_46) AT=780.05n

* CHECK dout0_47 Vdout0_47ck77 = 1.8 time = 780
.meas tran vdout0_47ck77 FIND v(dout0_47) AT=780.05n

* CHECK dout0_48 Vdout0_48ck77 = 0 time = 780
.meas tran vdout0_48ck77 FIND v(dout0_48) AT=780.05n

* CHECK dout0_49 Vdout0_49ck77 = 1.8 time = 780
.meas tran vdout0_49ck77 FIND v(dout0_49) AT=780.05n

* CHECK dout0_50 Vdout0_50ck77 = 1.8 time = 780
.meas tran vdout0_50ck77 FIND v(dout0_50) AT=780.05n

* CHECK dout0_51 Vdout0_51ck77 = 0 time = 780
.meas tran vdout0_51ck77 FIND v(dout0_51) AT=780.05n

* CHECK dout0_52 Vdout0_52ck77 = 0 time = 780
.meas tran vdout0_52ck77 FIND v(dout0_52) AT=780.05n

* CHECK dout0_53 Vdout0_53ck77 = 0 time = 780
.meas tran vdout0_53ck77 FIND v(dout0_53) AT=780.05n

* CHECK dout0_54 Vdout0_54ck77 = 0 time = 780
.meas tran vdout0_54ck77 FIND v(dout0_54) AT=780.05n

* CHECK dout0_55 Vdout0_55ck77 = 1.8 time = 780
.meas tran vdout0_55ck77 FIND v(dout0_55) AT=780.05n

* CHECK dout0_56 Vdout0_56ck77 = 0 time = 780
.meas tran vdout0_56ck77 FIND v(dout0_56) AT=780.05n

* CHECK dout0_57 Vdout0_57ck77 = 1.8 time = 780
.meas tran vdout0_57ck77 FIND v(dout0_57) AT=780.05n

* CHECK dout0_58 Vdout0_58ck77 = 1.8 time = 780
.meas tran vdout0_58ck77 FIND v(dout0_58) AT=780.05n

* CHECK dout0_59 Vdout0_59ck77 = 0 time = 780
.meas tran vdout0_59ck77 FIND v(dout0_59) AT=780.05n

* CHECK dout0_60 Vdout0_60ck77 = 1.8 time = 780
.meas tran vdout0_60ck77 FIND v(dout0_60) AT=780.05n

* CHECK dout0_61 Vdout0_61ck77 = 0 time = 780
.meas tran vdout0_61ck77 FIND v(dout0_61) AT=780.05n

* CHECK dout0_62 Vdout0_62ck77 = 0 time = 780
.meas tran vdout0_62ck77 FIND v(dout0_62) AT=780.05n

* CHECK dout0_63 Vdout0_63ck77 = 1.8 time = 780
.meas tran vdout0_63ck77 FIND v(dout0_63) AT=780.05n

* CHECK dout0_64 Vdout0_64ck77 = 0 time = 780
.meas tran vdout0_64ck77 FIND v(dout0_64) AT=780.05n

* CHECK dout0_0 Vdout0_0ck81 = 1.8 time = 820
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=820.05n

* CHECK dout0_1 Vdout0_1ck81 = 0 time = 820
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=820.05n

* CHECK dout0_2 Vdout0_2ck81 = 1.8 time = 820
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=820.05n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 820
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=820.05n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 820
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=820.05n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 820
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=820.05n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 820
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=820.05n

* CHECK dout0_7 Vdout0_7ck81 = 1.8 time = 820
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=820.05n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 820
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=820.05n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 820
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=820.05n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 820
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=820.05n

* CHECK dout0_11 Vdout0_11ck81 = 1.8 time = 820
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=820.05n

* CHECK dout0_12 Vdout0_12ck81 = 1.8 time = 820
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=820.05n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 820
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=820.05n

* CHECK dout0_14 Vdout0_14ck81 = 1.8 time = 820
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=820.05n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 820
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=820.05n

* CHECK dout0_16 Vdout0_16ck81 = 1.8 time = 820
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=820.05n

* CHECK dout0_17 Vdout0_17ck81 = 0 time = 820
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=820.05n

* CHECK dout0_18 Vdout0_18ck81 = 1.8 time = 820
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=820.05n

* CHECK dout0_19 Vdout0_19ck81 = 0 time = 820
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=820.05n

* CHECK dout0_20 Vdout0_20ck81 = 0 time = 820
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=820.05n

* CHECK dout0_21 Vdout0_21ck81 = 0 time = 820
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=820.05n

* CHECK dout0_22 Vdout0_22ck81 = 1.8 time = 820
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=820.05n

* CHECK dout0_23 Vdout0_23ck81 = 1.8 time = 820
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=820.05n

* CHECK dout0_24 Vdout0_24ck81 = 1.8 time = 820
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=820.05n

* CHECK dout0_25 Vdout0_25ck81 = 0 time = 820
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=820.05n

* CHECK dout0_26 Vdout0_26ck81 = 0 time = 820
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=820.05n

* CHECK dout0_27 Vdout0_27ck81 = 1.8 time = 820
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=820.05n

* CHECK dout0_28 Vdout0_28ck81 = 1.8 time = 820
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=820.05n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 820
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=820.05n

* CHECK dout0_30 Vdout0_30ck81 = 0 time = 820
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=820.05n

* CHECK dout0_31 Vdout0_31ck81 = 1.8 time = 820
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=820.05n

* CHECK dout0_32 Vdout0_32ck81 = 0 time = 820
.meas tran vdout0_32ck81 FIND v(dout0_32) AT=820.05n

* CHECK dout0_33 Vdout0_33ck81 = 0 time = 820
.meas tran vdout0_33ck81 FIND v(dout0_33) AT=820.05n

* CHECK dout0_34 Vdout0_34ck81 = 0 time = 820
.meas tran vdout0_34ck81 FIND v(dout0_34) AT=820.05n

* CHECK dout0_35 Vdout0_35ck81 = 1.8 time = 820
.meas tran vdout0_35ck81 FIND v(dout0_35) AT=820.05n

* CHECK dout0_36 Vdout0_36ck81 = 0 time = 820
.meas tran vdout0_36ck81 FIND v(dout0_36) AT=820.05n

* CHECK dout0_37 Vdout0_37ck81 = 0 time = 820
.meas tran vdout0_37ck81 FIND v(dout0_37) AT=820.05n

* CHECK dout0_38 Vdout0_38ck81 = 0 time = 820
.meas tran vdout0_38ck81 FIND v(dout0_38) AT=820.05n

* CHECK dout0_39 Vdout0_39ck81 = 0 time = 820
.meas tran vdout0_39ck81 FIND v(dout0_39) AT=820.05n

* CHECK dout0_40 Vdout0_40ck81 = 0 time = 820
.meas tran vdout0_40ck81 FIND v(dout0_40) AT=820.05n

* CHECK dout0_41 Vdout0_41ck81 = 1.8 time = 820
.meas tran vdout0_41ck81 FIND v(dout0_41) AT=820.05n

* CHECK dout0_42 Vdout0_42ck81 = 1.8 time = 820
.meas tran vdout0_42ck81 FIND v(dout0_42) AT=820.05n

* CHECK dout0_43 Vdout0_43ck81 = 1.8 time = 820
.meas tran vdout0_43ck81 FIND v(dout0_43) AT=820.05n

* CHECK dout0_44 Vdout0_44ck81 = 0 time = 820
.meas tran vdout0_44ck81 FIND v(dout0_44) AT=820.05n

* CHECK dout0_45 Vdout0_45ck81 = 0 time = 820
.meas tran vdout0_45ck81 FIND v(dout0_45) AT=820.05n

* CHECK dout0_46 Vdout0_46ck81 = 1.8 time = 820
.meas tran vdout0_46ck81 FIND v(dout0_46) AT=820.05n

* CHECK dout0_47 Vdout0_47ck81 = 0 time = 820
.meas tran vdout0_47ck81 FIND v(dout0_47) AT=820.05n

* CHECK dout0_48 Vdout0_48ck81 = 0 time = 820
.meas tran vdout0_48ck81 FIND v(dout0_48) AT=820.05n

* CHECK dout0_49 Vdout0_49ck81 = 0 time = 820
.meas tran vdout0_49ck81 FIND v(dout0_49) AT=820.05n

* CHECK dout0_50 Vdout0_50ck81 = 1.8 time = 820
.meas tran vdout0_50ck81 FIND v(dout0_50) AT=820.05n

* CHECK dout0_51 Vdout0_51ck81 = 0 time = 820
.meas tran vdout0_51ck81 FIND v(dout0_51) AT=820.05n

* CHECK dout0_52 Vdout0_52ck81 = 0 time = 820
.meas tran vdout0_52ck81 FIND v(dout0_52) AT=820.05n

* CHECK dout0_53 Vdout0_53ck81 = 1.8 time = 820
.meas tran vdout0_53ck81 FIND v(dout0_53) AT=820.05n

* CHECK dout0_54 Vdout0_54ck81 = 1.8 time = 820
.meas tran vdout0_54ck81 FIND v(dout0_54) AT=820.05n

* CHECK dout0_55 Vdout0_55ck81 = 0 time = 820
.meas tran vdout0_55ck81 FIND v(dout0_55) AT=820.05n

* CHECK dout0_56 Vdout0_56ck81 = 1.8 time = 820
.meas tran vdout0_56ck81 FIND v(dout0_56) AT=820.05n

* CHECK dout0_57 Vdout0_57ck81 = 1.8 time = 820
.meas tran vdout0_57ck81 FIND v(dout0_57) AT=820.05n

* CHECK dout0_58 Vdout0_58ck81 = 0 time = 820
.meas tran vdout0_58ck81 FIND v(dout0_58) AT=820.05n

* CHECK dout0_59 Vdout0_59ck81 = 0 time = 820
.meas tran vdout0_59ck81 FIND v(dout0_59) AT=820.05n

* CHECK dout0_60 Vdout0_60ck81 = 0 time = 820
.meas tran vdout0_60ck81 FIND v(dout0_60) AT=820.05n

* CHECK dout0_61 Vdout0_61ck81 = 1.8 time = 820
.meas tran vdout0_61ck81 FIND v(dout0_61) AT=820.05n

* CHECK dout0_62 Vdout0_62ck81 = 0 time = 820
.meas tran vdout0_62ck81 FIND v(dout0_62) AT=820.05n

* CHECK dout0_63 Vdout0_63ck81 = 0 time = 820
.meas tran vdout0_63ck81 FIND v(dout0_63) AT=820.05n

* CHECK dout0_64 Vdout0_64ck81 = 0 time = 820
.meas tran vdout0_64ck81 FIND v(dout0_64) AT=820.05n

* CHECK dout0_0 Vdout0_0ck82 = 1.8 time = 830
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=830.05n

* CHECK dout0_1 Vdout0_1ck82 = 0 time = 830
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=830.05n

* CHECK dout0_2 Vdout0_2ck82 = 1.8 time = 830
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=830.05n

* CHECK dout0_3 Vdout0_3ck82 = 0 time = 830
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=830.05n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 830
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=830.05n

* CHECK dout0_5 Vdout0_5ck82 = 0 time = 830
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=830.05n

* CHECK dout0_6 Vdout0_6ck82 = 1.8 time = 830
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=830.05n

* CHECK dout0_7 Vdout0_7ck82 = 1.8 time = 830
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=830.05n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 830
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=830.05n

* CHECK dout0_9 Vdout0_9ck82 = 0 time = 830
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=830.05n

* CHECK dout0_10 Vdout0_10ck82 = 0 time = 830
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=830.05n

* CHECK dout0_11 Vdout0_11ck82 = 1.8 time = 830
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=830.05n

* CHECK dout0_12 Vdout0_12ck82 = 1.8 time = 830
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=830.05n

* CHECK dout0_13 Vdout0_13ck82 = 0 time = 830
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=830.05n

* CHECK dout0_14 Vdout0_14ck82 = 1.8 time = 830
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=830.05n

* CHECK dout0_15 Vdout0_15ck82 = 0 time = 830
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=830.05n

* CHECK dout0_16 Vdout0_16ck82 = 1.8 time = 830
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=830.05n

* CHECK dout0_17 Vdout0_17ck82 = 0 time = 830
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=830.05n

* CHECK dout0_18 Vdout0_18ck82 = 1.8 time = 830
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=830.05n

* CHECK dout0_19 Vdout0_19ck82 = 0 time = 830
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=830.05n

* CHECK dout0_20 Vdout0_20ck82 = 0 time = 830
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=830.05n

* CHECK dout0_21 Vdout0_21ck82 = 0 time = 830
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=830.05n

* CHECK dout0_22 Vdout0_22ck82 = 1.8 time = 830
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=830.05n

* CHECK dout0_23 Vdout0_23ck82 = 1.8 time = 830
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=830.05n

* CHECK dout0_24 Vdout0_24ck82 = 1.8 time = 830
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=830.05n

* CHECK dout0_25 Vdout0_25ck82 = 0 time = 830
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=830.05n

* CHECK dout0_26 Vdout0_26ck82 = 0 time = 830
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=830.05n

* CHECK dout0_27 Vdout0_27ck82 = 1.8 time = 830
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=830.05n

* CHECK dout0_28 Vdout0_28ck82 = 1.8 time = 830
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=830.05n

* CHECK dout0_29 Vdout0_29ck82 = 0 time = 830
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=830.05n

* CHECK dout0_30 Vdout0_30ck82 = 0 time = 830
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=830.05n

* CHECK dout0_31 Vdout0_31ck82 = 1.8 time = 830
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=830.05n

* CHECK dout0_32 Vdout0_32ck82 = 0 time = 830
.meas tran vdout0_32ck82 FIND v(dout0_32) AT=830.05n

* CHECK dout0_33 Vdout0_33ck82 = 0 time = 830
.meas tran vdout0_33ck82 FIND v(dout0_33) AT=830.05n

* CHECK dout0_34 Vdout0_34ck82 = 0 time = 830
.meas tran vdout0_34ck82 FIND v(dout0_34) AT=830.05n

* CHECK dout0_35 Vdout0_35ck82 = 1.8 time = 830
.meas tran vdout0_35ck82 FIND v(dout0_35) AT=830.05n

* CHECK dout0_36 Vdout0_36ck82 = 0 time = 830
.meas tran vdout0_36ck82 FIND v(dout0_36) AT=830.05n

* CHECK dout0_37 Vdout0_37ck82 = 0 time = 830
.meas tran vdout0_37ck82 FIND v(dout0_37) AT=830.05n

* CHECK dout0_38 Vdout0_38ck82 = 0 time = 830
.meas tran vdout0_38ck82 FIND v(dout0_38) AT=830.05n

* CHECK dout0_39 Vdout0_39ck82 = 0 time = 830
.meas tran vdout0_39ck82 FIND v(dout0_39) AT=830.05n

* CHECK dout0_40 Vdout0_40ck82 = 0 time = 830
.meas tran vdout0_40ck82 FIND v(dout0_40) AT=830.05n

* CHECK dout0_41 Vdout0_41ck82 = 1.8 time = 830
.meas tran vdout0_41ck82 FIND v(dout0_41) AT=830.05n

* CHECK dout0_42 Vdout0_42ck82 = 1.8 time = 830
.meas tran vdout0_42ck82 FIND v(dout0_42) AT=830.05n

* CHECK dout0_43 Vdout0_43ck82 = 1.8 time = 830
.meas tran vdout0_43ck82 FIND v(dout0_43) AT=830.05n

* CHECK dout0_44 Vdout0_44ck82 = 0 time = 830
.meas tran vdout0_44ck82 FIND v(dout0_44) AT=830.05n

* CHECK dout0_45 Vdout0_45ck82 = 0 time = 830
.meas tran vdout0_45ck82 FIND v(dout0_45) AT=830.05n

* CHECK dout0_46 Vdout0_46ck82 = 1.8 time = 830
.meas tran vdout0_46ck82 FIND v(dout0_46) AT=830.05n

* CHECK dout0_47 Vdout0_47ck82 = 0 time = 830
.meas tran vdout0_47ck82 FIND v(dout0_47) AT=830.05n

* CHECK dout0_48 Vdout0_48ck82 = 0 time = 830
.meas tran vdout0_48ck82 FIND v(dout0_48) AT=830.05n

* CHECK dout0_49 Vdout0_49ck82 = 0 time = 830
.meas tran vdout0_49ck82 FIND v(dout0_49) AT=830.05n

* CHECK dout0_50 Vdout0_50ck82 = 1.8 time = 830
.meas tran vdout0_50ck82 FIND v(dout0_50) AT=830.05n

* CHECK dout0_51 Vdout0_51ck82 = 0 time = 830
.meas tran vdout0_51ck82 FIND v(dout0_51) AT=830.05n

* CHECK dout0_52 Vdout0_52ck82 = 0 time = 830
.meas tran vdout0_52ck82 FIND v(dout0_52) AT=830.05n

* CHECK dout0_53 Vdout0_53ck82 = 1.8 time = 830
.meas tran vdout0_53ck82 FIND v(dout0_53) AT=830.05n

* CHECK dout0_54 Vdout0_54ck82 = 1.8 time = 830
.meas tran vdout0_54ck82 FIND v(dout0_54) AT=830.05n

* CHECK dout0_55 Vdout0_55ck82 = 0 time = 830
.meas tran vdout0_55ck82 FIND v(dout0_55) AT=830.05n

* CHECK dout0_56 Vdout0_56ck82 = 1.8 time = 830
.meas tran vdout0_56ck82 FIND v(dout0_56) AT=830.05n

* CHECK dout0_57 Vdout0_57ck82 = 1.8 time = 830
.meas tran vdout0_57ck82 FIND v(dout0_57) AT=830.05n

* CHECK dout0_58 Vdout0_58ck82 = 0 time = 830
.meas tran vdout0_58ck82 FIND v(dout0_58) AT=830.05n

* CHECK dout0_59 Vdout0_59ck82 = 0 time = 830
.meas tran vdout0_59ck82 FIND v(dout0_59) AT=830.05n

* CHECK dout0_60 Vdout0_60ck82 = 0 time = 830
.meas tran vdout0_60ck82 FIND v(dout0_60) AT=830.05n

* CHECK dout0_61 Vdout0_61ck82 = 1.8 time = 830
.meas tran vdout0_61ck82 FIND v(dout0_61) AT=830.05n

* CHECK dout0_62 Vdout0_62ck82 = 0 time = 830
.meas tran vdout0_62ck82 FIND v(dout0_62) AT=830.05n

* CHECK dout0_63 Vdout0_63ck82 = 0 time = 830
.meas tran vdout0_63ck82 FIND v(dout0_63) AT=830.05n

* CHECK dout0_64 Vdout0_64ck82 = 0 time = 830
.meas tran vdout0_64ck82 FIND v(dout0_64) AT=830.05n

* CHECK dout0_0 Vdout0_0ck87 = 1.8 time = 880
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=880.05n

* CHECK dout0_1 Vdout0_1ck87 = 1.8 time = 880
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=880.05n

* CHECK dout0_2 Vdout0_2ck87 = 1.8 time = 880
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=880.05n

* CHECK dout0_3 Vdout0_3ck87 = 1.8 time = 880
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=880.05n

* CHECK dout0_4 Vdout0_4ck87 = 1.8 time = 880
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=880.05n

* CHECK dout0_5 Vdout0_5ck87 = 0 time = 880
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=880.05n

* CHECK dout0_6 Vdout0_6ck87 = 1.8 time = 880
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=880.05n

* CHECK dout0_7 Vdout0_7ck87 = 1.8 time = 880
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=880.05n

* CHECK dout0_8 Vdout0_8ck87 = 1.8 time = 880
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=880.05n

* CHECK dout0_9 Vdout0_9ck87 = 1.8 time = 880
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=880.05n

* CHECK dout0_10 Vdout0_10ck87 = 0 time = 880
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=880.05n

* CHECK dout0_11 Vdout0_11ck87 = 0 time = 880
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=880.05n

* CHECK dout0_12 Vdout0_12ck87 = 1.8 time = 880
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=880.05n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 880
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=880.05n

* CHECK dout0_14 Vdout0_14ck87 = 0 time = 880
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=880.05n

* CHECK dout0_15 Vdout0_15ck87 = 0 time = 880
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=880.05n

* CHECK dout0_16 Vdout0_16ck87 = 1.8 time = 880
.meas tran vdout0_16ck87 FIND v(dout0_16) AT=880.05n

* CHECK dout0_17 Vdout0_17ck87 = 0 time = 880
.meas tran vdout0_17ck87 FIND v(dout0_17) AT=880.05n

* CHECK dout0_18 Vdout0_18ck87 = 1.8 time = 880
.meas tran vdout0_18ck87 FIND v(dout0_18) AT=880.05n

* CHECK dout0_19 Vdout0_19ck87 = 0 time = 880
.meas tran vdout0_19ck87 FIND v(dout0_19) AT=880.05n

* CHECK dout0_20 Vdout0_20ck87 = 1.8 time = 880
.meas tran vdout0_20ck87 FIND v(dout0_20) AT=880.05n

* CHECK dout0_21 Vdout0_21ck87 = 1.8 time = 880
.meas tran vdout0_21ck87 FIND v(dout0_21) AT=880.05n

* CHECK dout0_22 Vdout0_22ck87 = 0 time = 880
.meas tran vdout0_22ck87 FIND v(dout0_22) AT=880.05n

* CHECK dout0_23 Vdout0_23ck87 = 1.8 time = 880
.meas tran vdout0_23ck87 FIND v(dout0_23) AT=880.05n

* CHECK dout0_24 Vdout0_24ck87 = 1.8 time = 880
.meas tran vdout0_24ck87 FIND v(dout0_24) AT=880.05n

* CHECK dout0_25 Vdout0_25ck87 = 0 time = 880
.meas tran vdout0_25ck87 FIND v(dout0_25) AT=880.05n

* CHECK dout0_26 Vdout0_26ck87 = 1.8 time = 880
.meas tran vdout0_26ck87 FIND v(dout0_26) AT=880.05n

* CHECK dout0_27 Vdout0_27ck87 = 1.8 time = 880
.meas tran vdout0_27ck87 FIND v(dout0_27) AT=880.05n

* CHECK dout0_28 Vdout0_28ck87 = 0 time = 880
.meas tran vdout0_28ck87 FIND v(dout0_28) AT=880.05n

* CHECK dout0_29 Vdout0_29ck87 = 1.8 time = 880
.meas tran vdout0_29ck87 FIND v(dout0_29) AT=880.05n

* CHECK dout0_30 Vdout0_30ck87 = 0 time = 880
.meas tran vdout0_30ck87 FIND v(dout0_30) AT=880.05n

* CHECK dout0_31 Vdout0_31ck87 = 1.8 time = 880
.meas tran vdout0_31ck87 FIND v(dout0_31) AT=880.05n

* CHECK dout0_32 Vdout0_32ck87 = 1.8 time = 880
.meas tran vdout0_32ck87 FIND v(dout0_32) AT=880.05n

* CHECK dout0_33 Vdout0_33ck87 = 1.8 time = 880
.meas tran vdout0_33ck87 FIND v(dout0_33) AT=880.05n

* CHECK dout0_34 Vdout0_34ck87 = 1.8 time = 880
.meas tran vdout0_34ck87 FIND v(dout0_34) AT=880.05n

* CHECK dout0_35 Vdout0_35ck87 = 1.8 time = 880
.meas tran vdout0_35ck87 FIND v(dout0_35) AT=880.05n

* CHECK dout0_36 Vdout0_36ck87 = 0 time = 880
.meas tran vdout0_36ck87 FIND v(dout0_36) AT=880.05n

* CHECK dout0_37 Vdout0_37ck87 = 0 time = 880
.meas tran vdout0_37ck87 FIND v(dout0_37) AT=880.05n

* CHECK dout0_38 Vdout0_38ck87 = 0 time = 880
.meas tran vdout0_38ck87 FIND v(dout0_38) AT=880.05n

* CHECK dout0_39 Vdout0_39ck87 = 0 time = 880
.meas tran vdout0_39ck87 FIND v(dout0_39) AT=880.05n

* CHECK dout0_40 Vdout0_40ck87 = 1.8 time = 880
.meas tran vdout0_40ck87 FIND v(dout0_40) AT=880.05n

* CHECK dout0_41 Vdout0_41ck87 = 1.8 time = 880
.meas tran vdout0_41ck87 FIND v(dout0_41) AT=880.05n

* CHECK dout0_42 Vdout0_42ck87 = 1.8 time = 880
.meas tran vdout0_42ck87 FIND v(dout0_42) AT=880.05n

* CHECK dout0_43 Vdout0_43ck87 = 1.8 time = 880
.meas tran vdout0_43ck87 FIND v(dout0_43) AT=880.05n

* CHECK dout0_44 Vdout0_44ck87 = 0 time = 880
.meas tran vdout0_44ck87 FIND v(dout0_44) AT=880.05n

* CHECK dout0_45 Vdout0_45ck87 = 0 time = 880
.meas tran vdout0_45ck87 FIND v(dout0_45) AT=880.05n

* CHECK dout0_46 Vdout0_46ck87 = 0 time = 880
.meas tran vdout0_46ck87 FIND v(dout0_46) AT=880.05n

* CHECK dout0_47 Vdout0_47ck87 = 1.8 time = 880
.meas tran vdout0_47ck87 FIND v(dout0_47) AT=880.05n

* CHECK dout0_48 Vdout0_48ck87 = 1.8 time = 880
.meas tran vdout0_48ck87 FIND v(dout0_48) AT=880.05n

* CHECK dout0_49 Vdout0_49ck87 = 1.8 time = 880
.meas tran vdout0_49ck87 FIND v(dout0_49) AT=880.05n

* CHECK dout0_50 Vdout0_50ck87 = 1.8 time = 880
.meas tran vdout0_50ck87 FIND v(dout0_50) AT=880.05n

* CHECK dout0_51 Vdout0_51ck87 = 1.8 time = 880
.meas tran vdout0_51ck87 FIND v(dout0_51) AT=880.05n

* CHECK dout0_52 Vdout0_52ck87 = 0 time = 880
.meas tran vdout0_52ck87 FIND v(dout0_52) AT=880.05n

* CHECK dout0_53 Vdout0_53ck87 = 0 time = 880
.meas tran vdout0_53ck87 FIND v(dout0_53) AT=880.05n

* CHECK dout0_54 Vdout0_54ck87 = 1.8 time = 880
.meas tran vdout0_54ck87 FIND v(dout0_54) AT=880.05n

* CHECK dout0_55 Vdout0_55ck87 = 1.8 time = 880
.meas tran vdout0_55ck87 FIND v(dout0_55) AT=880.05n

* CHECK dout0_56 Vdout0_56ck87 = 1.8 time = 880
.meas tran vdout0_56ck87 FIND v(dout0_56) AT=880.05n

* CHECK dout0_57 Vdout0_57ck87 = 1.8 time = 880
.meas tran vdout0_57ck87 FIND v(dout0_57) AT=880.05n

* CHECK dout0_58 Vdout0_58ck87 = 1.8 time = 880
.meas tran vdout0_58ck87 FIND v(dout0_58) AT=880.05n

* CHECK dout0_59 Vdout0_59ck87 = 0 time = 880
.meas tran vdout0_59ck87 FIND v(dout0_59) AT=880.05n

* CHECK dout0_60 Vdout0_60ck87 = 1.8 time = 880
.meas tran vdout0_60ck87 FIND v(dout0_60) AT=880.05n

* CHECK dout0_61 Vdout0_61ck87 = 1.8 time = 880
.meas tran vdout0_61ck87 FIND v(dout0_61) AT=880.05n

* CHECK dout0_62 Vdout0_62ck87 = 1.8 time = 880
.meas tran vdout0_62ck87 FIND v(dout0_62) AT=880.05n

* CHECK dout0_63 Vdout0_63ck87 = 1.8 time = 880
.meas tran vdout0_63ck87 FIND v(dout0_63) AT=880.05n

* CHECK dout0_64 Vdout0_64ck87 = 0 time = 880
.meas tran vdout0_64ck87 FIND v(dout0_64) AT=880.05n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 900
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=900.05n

* CHECK dout0_1 Vdout0_1ck89 = 0 time = 900
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=900.05n

* CHECK dout0_2 Vdout0_2ck89 = 1.8 time = 900
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=900.05n

* CHECK dout0_3 Vdout0_3ck89 = 0 time = 900
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=900.05n

* CHECK dout0_4 Vdout0_4ck89 = 1.8 time = 900
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=900.05n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 900
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=900.05n

* CHECK dout0_6 Vdout0_6ck89 = 0 time = 900
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=900.05n

* CHECK dout0_7 Vdout0_7ck89 = 1.8 time = 900
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=900.05n

* CHECK dout0_8 Vdout0_8ck89 = 1.8 time = 900
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=900.05n

* CHECK dout0_9 Vdout0_9ck89 = 0 time = 900
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=900.05n

* CHECK dout0_10 Vdout0_10ck89 = 0 time = 900
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=900.05n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 900
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=900.05n

* CHECK dout0_12 Vdout0_12ck89 = 1.8 time = 900
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=900.05n

* CHECK dout0_13 Vdout0_13ck89 = 0 time = 900
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=900.05n

* CHECK dout0_14 Vdout0_14ck89 = 0 time = 900
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=900.05n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 900
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=900.05n

* CHECK dout0_16 Vdout0_16ck89 = 0 time = 900
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=900.05n

* CHECK dout0_17 Vdout0_17ck89 = 0 time = 900
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=900.05n

* CHECK dout0_18 Vdout0_18ck89 = 1.8 time = 900
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=900.05n

* CHECK dout0_19 Vdout0_19ck89 = 1.8 time = 900
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=900.05n

* CHECK dout0_20 Vdout0_20ck89 = 0 time = 900
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=900.05n

* CHECK dout0_21 Vdout0_21ck89 = 1.8 time = 900
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=900.05n

* CHECK dout0_22 Vdout0_22ck89 = 0 time = 900
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=900.05n

* CHECK dout0_23 Vdout0_23ck89 = 0 time = 900
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=900.05n

* CHECK dout0_24 Vdout0_24ck89 = 1.8 time = 900
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=900.05n

* CHECK dout0_25 Vdout0_25ck89 = 1.8 time = 900
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=900.05n

* CHECK dout0_26 Vdout0_26ck89 = 0 time = 900
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=900.05n

* CHECK dout0_27 Vdout0_27ck89 = 1.8 time = 900
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=900.05n

* CHECK dout0_28 Vdout0_28ck89 = 0 time = 900
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=900.05n

* CHECK dout0_29 Vdout0_29ck89 = 1.8 time = 900
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=900.05n

* CHECK dout0_30 Vdout0_30ck89 = 1.8 time = 900
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=900.05n

* CHECK dout0_31 Vdout0_31ck89 = 1.8 time = 900
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=900.05n

* CHECK dout0_32 Vdout0_32ck89 = 0 time = 900
.meas tran vdout0_32ck89 FIND v(dout0_32) AT=900.05n

* CHECK dout0_33 Vdout0_33ck89 = 0 time = 900
.meas tran vdout0_33ck89 FIND v(dout0_33) AT=900.05n

* CHECK dout0_34 Vdout0_34ck89 = 1.8 time = 900
.meas tran vdout0_34ck89 FIND v(dout0_34) AT=900.05n

* CHECK dout0_35 Vdout0_35ck89 = 1.8 time = 900
.meas tran vdout0_35ck89 FIND v(dout0_35) AT=900.05n

* CHECK dout0_36 Vdout0_36ck89 = 1.8 time = 900
.meas tran vdout0_36ck89 FIND v(dout0_36) AT=900.05n

* CHECK dout0_37 Vdout0_37ck89 = 1.8 time = 900
.meas tran vdout0_37ck89 FIND v(dout0_37) AT=900.05n

* CHECK dout0_38 Vdout0_38ck89 = 0 time = 900
.meas tran vdout0_38ck89 FIND v(dout0_38) AT=900.05n

* CHECK dout0_39 Vdout0_39ck89 = 1.8 time = 900
.meas tran vdout0_39ck89 FIND v(dout0_39) AT=900.05n

* CHECK dout0_40 Vdout0_40ck89 = 0 time = 900
.meas tran vdout0_40ck89 FIND v(dout0_40) AT=900.05n

* CHECK dout0_41 Vdout0_41ck89 = 1.8 time = 900
.meas tran vdout0_41ck89 FIND v(dout0_41) AT=900.05n

* CHECK dout0_42 Vdout0_42ck89 = 0 time = 900
.meas tran vdout0_42ck89 FIND v(dout0_42) AT=900.05n

* CHECK dout0_43 Vdout0_43ck89 = 0 time = 900
.meas tran vdout0_43ck89 FIND v(dout0_43) AT=900.05n

* CHECK dout0_44 Vdout0_44ck89 = 1.8 time = 900
.meas tran vdout0_44ck89 FIND v(dout0_44) AT=900.05n

* CHECK dout0_45 Vdout0_45ck89 = 0 time = 900
.meas tran vdout0_45ck89 FIND v(dout0_45) AT=900.05n

* CHECK dout0_46 Vdout0_46ck89 = 0 time = 900
.meas tran vdout0_46ck89 FIND v(dout0_46) AT=900.05n

* CHECK dout0_47 Vdout0_47ck89 = 1.8 time = 900
.meas tran vdout0_47ck89 FIND v(dout0_47) AT=900.05n

* CHECK dout0_48 Vdout0_48ck89 = 1.8 time = 900
.meas tran vdout0_48ck89 FIND v(dout0_48) AT=900.05n

* CHECK dout0_49 Vdout0_49ck89 = 1.8 time = 900
.meas tran vdout0_49ck89 FIND v(dout0_49) AT=900.05n

* CHECK dout0_50 Vdout0_50ck89 = 1.8 time = 900
.meas tran vdout0_50ck89 FIND v(dout0_50) AT=900.05n

* CHECK dout0_51 Vdout0_51ck89 = 1.8 time = 900
.meas tran vdout0_51ck89 FIND v(dout0_51) AT=900.05n

* CHECK dout0_52 Vdout0_52ck89 = 0 time = 900
.meas tran vdout0_52ck89 FIND v(dout0_52) AT=900.05n

* CHECK dout0_53 Vdout0_53ck89 = 1.8 time = 900
.meas tran vdout0_53ck89 FIND v(dout0_53) AT=900.05n

* CHECK dout0_54 Vdout0_54ck89 = 0 time = 900
.meas tran vdout0_54ck89 FIND v(dout0_54) AT=900.05n

* CHECK dout0_55 Vdout0_55ck89 = 0 time = 900
.meas tran vdout0_55ck89 FIND v(dout0_55) AT=900.05n

* CHECK dout0_56 Vdout0_56ck89 = 1.8 time = 900
.meas tran vdout0_56ck89 FIND v(dout0_56) AT=900.05n

* CHECK dout0_57 Vdout0_57ck89 = 1.8 time = 900
.meas tran vdout0_57ck89 FIND v(dout0_57) AT=900.05n

* CHECK dout0_58 Vdout0_58ck89 = 1.8 time = 900
.meas tran vdout0_58ck89 FIND v(dout0_58) AT=900.05n

* CHECK dout0_59 Vdout0_59ck89 = 0 time = 900
.meas tran vdout0_59ck89 FIND v(dout0_59) AT=900.05n

* CHECK dout0_60 Vdout0_60ck89 = 1.8 time = 900
.meas tran vdout0_60ck89 FIND v(dout0_60) AT=900.05n

* CHECK dout0_61 Vdout0_61ck89 = 1.8 time = 900
.meas tran vdout0_61ck89 FIND v(dout0_61) AT=900.05n

* CHECK dout0_62 Vdout0_62ck89 = 0 time = 900
.meas tran vdout0_62ck89 FIND v(dout0_62) AT=900.05n

* CHECK dout0_63 Vdout0_63ck89 = 1.8 time = 900
.meas tran vdout0_63ck89 FIND v(dout0_63) AT=900.05n

* CHECK dout0_64 Vdout0_64ck89 = 0 time = 900
.meas tran vdout0_64ck89 FIND v(dout0_64) AT=900.05n

* CHECK dout0_0 Vdout0_0ck90 = 0 time = 910
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=910.05n

* CHECK dout0_1 Vdout0_1ck90 = 0 time = 910
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=910.05n

* CHECK dout0_2 Vdout0_2ck90 = 1.8 time = 910
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=910.05n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 910
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=910.05n

* CHECK dout0_4 Vdout0_4ck90 = 1.8 time = 910
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=910.05n

* CHECK dout0_5 Vdout0_5ck90 = 1.8 time = 910
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=910.05n

* CHECK dout0_6 Vdout0_6ck90 = 1.8 time = 910
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=910.05n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 910
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=910.05n

* CHECK dout0_8 Vdout0_8ck90 = 1.8 time = 910
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=910.05n

* CHECK dout0_9 Vdout0_9ck90 = 1.8 time = 910
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=910.05n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 910
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=910.05n

* CHECK dout0_11 Vdout0_11ck90 = 1.8 time = 910
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=910.05n

* CHECK dout0_12 Vdout0_12ck90 = 1.8 time = 910
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=910.05n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 910
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=910.05n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 910
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=910.05n

* CHECK dout0_15 Vdout0_15ck90 = 0 time = 910
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=910.05n

* CHECK dout0_16 Vdout0_16ck90 = 0 time = 910
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=910.05n

* CHECK dout0_17 Vdout0_17ck90 = 1.8 time = 910
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=910.05n

* CHECK dout0_18 Vdout0_18ck90 = 1.8 time = 910
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=910.05n

* CHECK dout0_19 Vdout0_19ck90 = 0 time = 910
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=910.05n

* CHECK dout0_20 Vdout0_20ck90 = 0 time = 910
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=910.05n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 910
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=910.05n

* CHECK dout0_22 Vdout0_22ck90 = 1.8 time = 910
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=910.05n

* CHECK dout0_23 Vdout0_23ck90 = 0 time = 910
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=910.05n

* CHECK dout0_24 Vdout0_24ck90 = 0 time = 910
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=910.05n

* CHECK dout0_25 Vdout0_25ck90 = 1.8 time = 910
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=910.05n

* CHECK dout0_26 Vdout0_26ck90 = 0 time = 910
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=910.05n

* CHECK dout0_27 Vdout0_27ck90 = 1.8 time = 910
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=910.05n

* CHECK dout0_28 Vdout0_28ck90 = 0 time = 910
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=910.05n

* CHECK dout0_29 Vdout0_29ck90 = 1.8 time = 910
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=910.05n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 910
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=910.05n

* CHECK dout0_31 Vdout0_31ck90 = 1.8 time = 910
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=910.05n

* CHECK dout0_32 Vdout0_32ck90 = 1.8 time = 910
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=910.05n

* CHECK dout0_33 Vdout0_33ck90 = 1.8 time = 910
.meas tran vdout0_33ck90 FIND v(dout0_33) AT=910.05n

* CHECK dout0_34 Vdout0_34ck90 = 1.8 time = 910
.meas tran vdout0_34ck90 FIND v(dout0_34) AT=910.05n

* CHECK dout0_35 Vdout0_35ck90 = 1.8 time = 910
.meas tran vdout0_35ck90 FIND v(dout0_35) AT=910.05n

* CHECK dout0_36 Vdout0_36ck90 = 0 time = 910
.meas tran vdout0_36ck90 FIND v(dout0_36) AT=910.05n

* CHECK dout0_37 Vdout0_37ck90 = 0 time = 910
.meas tran vdout0_37ck90 FIND v(dout0_37) AT=910.05n

* CHECK dout0_38 Vdout0_38ck90 = 1.8 time = 910
.meas tran vdout0_38ck90 FIND v(dout0_38) AT=910.05n

* CHECK dout0_39 Vdout0_39ck90 = 1.8 time = 910
.meas tran vdout0_39ck90 FIND v(dout0_39) AT=910.05n

* CHECK dout0_40 Vdout0_40ck90 = 1.8 time = 910
.meas tran vdout0_40ck90 FIND v(dout0_40) AT=910.05n

* CHECK dout0_41 Vdout0_41ck90 = 1.8 time = 910
.meas tran vdout0_41ck90 FIND v(dout0_41) AT=910.05n

* CHECK dout0_42 Vdout0_42ck90 = 1.8 time = 910
.meas tran vdout0_42ck90 FIND v(dout0_42) AT=910.05n

* CHECK dout0_43 Vdout0_43ck90 = 0 time = 910
.meas tran vdout0_43ck90 FIND v(dout0_43) AT=910.05n

* CHECK dout0_44 Vdout0_44ck90 = 0 time = 910
.meas tran vdout0_44ck90 FIND v(dout0_44) AT=910.05n

* CHECK dout0_45 Vdout0_45ck90 = 1.8 time = 910
.meas tran vdout0_45ck90 FIND v(dout0_45) AT=910.05n

* CHECK dout0_46 Vdout0_46ck90 = 0 time = 910
.meas tran vdout0_46ck90 FIND v(dout0_46) AT=910.05n

* CHECK dout0_47 Vdout0_47ck90 = 1.8 time = 910
.meas tran vdout0_47ck90 FIND v(dout0_47) AT=910.05n

* CHECK dout0_48 Vdout0_48ck90 = 1.8 time = 910
.meas tran vdout0_48ck90 FIND v(dout0_48) AT=910.05n

* CHECK dout0_49 Vdout0_49ck90 = 0 time = 910
.meas tran vdout0_49ck90 FIND v(dout0_49) AT=910.05n

* CHECK dout0_50 Vdout0_50ck90 = 1.8 time = 910
.meas tran vdout0_50ck90 FIND v(dout0_50) AT=910.05n

* CHECK dout0_51 Vdout0_51ck90 = 0 time = 910
.meas tran vdout0_51ck90 FIND v(dout0_51) AT=910.05n

* CHECK dout0_52 Vdout0_52ck90 = 0 time = 910
.meas tran vdout0_52ck90 FIND v(dout0_52) AT=910.05n

* CHECK dout0_53 Vdout0_53ck90 = 0 time = 910
.meas tran vdout0_53ck90 FIND v(dout0_53) AT=910.05n

* CHECK dout0_54 Vdout0_54ck90 = 0 time = 910
.meas tran vdout0_54ck90 FIND v(dout0_54) AT=910.05n

* CHECK dout0_55 Vdout0_55ck90 = 1.8 time = 910
.meas tran vdout0_55ck90 FIND v(dout0_55) AT=910.05n

* CHECK dout0_56 Vdout0_56ck90 = 0 time = 910
.meas tran vdout0_56ck90 FIND v(dout0_56) AT=910.05n

* CHECK dout0_57 Vdout0_57ck90 = 1.8 time = 910
.meas tran vdout0_57ck90 FIND v(dout0_57) AT=910.05n

* CHECK dout0_58 Vdout0_58ck90 = 0 time = 910
.meas tran vdout0_58ck90 FIND v(dout0_58) AT=910.05n

* CHECK dout0_59 Vdout0_59ck90 = 1.8 time = 910
.meas tran vdout0_59ck90 FIND v(dout0_59) AT=910.05n

* CHECK dout0_60 Vdout0_60ck90 = 0 time = 910
.meas tran vdout0_60ck90 FIND v(dout0_60) AT=910.05n

* CHECK dout0_61 Vdout0_61ck90 = 0 time = 910
.meas tran vdout0_61ck90 FIND v(dout0_61) AT=910.05n

* CHECK dout0_62 Vdout0_62ck90 = 0 time = 910
.meas tran vdout0_62ck90 FIND v(dout0_62) AT=910.05n

* CHECK dout0_63 Vdout0_63ck90 = 1.8 time = 910
.meas tran vdout0_63ck90 FIND v(dout0_63) AT=910.05n

* CHECK dout0_64 Vdout0_64ck90 = 0 time = 910
.meas tran vdout0_64ck90 FIND v(dout0_64) AT=910.05n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 950
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=950.05n

* CHECK dout0_1 Vdout0_1ck94 = 1.8 time = 950
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=950.05n

* CHECK dout0_2 Vdout0_2ck94 = 1.8 time = 950
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=950.05n

* CHECK dout0_3 Vdout0_3ck94 = 0 time = 950
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=950.05n

* CHECK dout0_4 Vdout0_4ck94 = 0 time = 950
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=950.05n

* CHECK dout0_5 Vdout0_5ck94 = 1.8 time = 950
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=950.05n

* CHECK dout0_6 Vdout0_6ck94 = 1.8 time = 950
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=950.05n

* CHECK dout0_7 Vdout0_7ck94 = 1.8 time = 950
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=950.05n

* CHECK dout0_8 Vdout0_8ck94 = 0 time = 950
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=950.05n

* CHECK dout0_9 Vdout0_9ck94 = 1.8 time = 950
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=950.05n

* CHECK dout0_10 Vdout0_10ck94 = 1.8 time = 950
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=950.05n

* CHECK dout0_11 Vdout0_11ck94 = 1.8 time = 950
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=950.05n

* CHECK dout0_12 Vdout0_12ck94 = 1.8 time = 950
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=950.05n

* CHECK dout0_13 Vdout0_13ck94 = 0 time = 950
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=950.05n

* CHECK dout0_14 Vdout0_14ck94 = 1.8 time = 950
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=950.05n

* CHECK dout0_15 Vdout0_15ck94 = 0 time = 950
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=950.05n

* CHECK dout0_16 Vdout0_16ck94 = 0 time = 950
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=950.05n

* CHECK dout0_17 Vdout0_17ck94 = 0 time = 950
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=950.05n

* CHECK dout0_18 Vdout0_18ck94 = 0 time = 950
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=950.05n

* CHECK dout0_19 Vdout0_19ck94 = 0 time = 950
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=950.05n

* CHECK dout0_20 Vdout0_20ck94 = 0 time = 950
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=950.05n

* CHECK dout0_21 Vdout0_21ck94 = 1.8 time = 950
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=950.05n

* CHECK dout0_22 Vdout0_22ck94 = 1.8 time = 950
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=950.05n

* CHECK dout0_23 Vdout0_23ck94 = 1.8 time = 950
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=950.05n

* CHECK dout0_24 Vdout0_24ck94 = 0 time = 950
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=950.05n

* CHECK dout0_25 Vdout0_25ck94 = 1.8 time = 950
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=950.05n

* CHECK dout0_26 Vdout0_26ck94 = 0 time = 950
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=950.05n

* CHECK dout0_27 Vdout0_27ck94 = 0 time = 950
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=950.05n

* CHECK dout0_28 Vdout0_28ck94 = 0 time = 950
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=950.05n

* CHECK dout0_29 Vdout0_29ck94 = 0 time = 950
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=950.05n

* CHECK dout0_30 Vdout0_30ck94 = 1.8 time = 950
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=950.05n

* CHECK dout0_31 Vdout0_31ck94 = 1.8 time = 950
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=950.05n

* CHECK dout0_32 Vdout0_32ck94 = 1.8 time = 950
.meas tran vdout0_32ck94 FIND v(dout0_32) AT=950.05n

* CHECK dout0_33 Vdout0_33ck94 = 1.8 time = 950
.meas tran vdout0_33ck94 FIND v(dout0_33) AT=950.05n

* CHECK dout0_34 Vdout0_34ck94 = 1.8 time = 950
.meas tran vdout0_34ck94 FIND v(dout0_34) AT=950.05n

* CHECK dout0_35 Vdout0_35ck94 = 0 time = 950
.meas tran vdout0_35ck94 FIND v(dout0_35) AT=950.05n

* CHECK dout0_36 Vdout0_36ck94 = 1.8 time = 950
.meas tran vdout0_36ck94 FIND v(dout0_36) AT=950.05n

* CHECK dout0_37 Vdout0_37ck94 = 0 time = 950
.meas tran vdout0_37ck94 FIND v(dout0_37) AT=950.05n

* CHECK dout0_38 Vdout0_38ck94 = 0 time = 950
.meas tran vdout0_38ck94 FIND v(dout0_38) AT=950.05n

* CHECK dout0_39 Vdout0_39ck94 = 1.8 time = 950
.meas tran vdout0_39ck94 FIND v(dout0_39) AT=950.05n

* CHECK dout0_40 Vdout0_40ck94 = 0 time = 950
.meas tran vdout0_40ck94 FIND v(dout0_40) AT=950.05n

* CHECK dout0_41 Vdout0_41ck94 = 0 time = 950
.meas tran vdout0_41ck94 FIND v(dout0_41) AT=950.05n

* CHECK dout0_42 Vdout0_42ck94 = 0 time = 950
.meas tran vdout0_42ck94 FIND v(dout0_42) AT=950.05n

* CHECK dout0_43 Vdout0_43ck94 = 1.8 time = 950
.meas tran vdout0_43ck94 FIND v(dout0_43) AT=950.05n

* CHECK dout0_44 Vdout0_44ck94 = 0 time = 950
.meas tran vdout0_44ck94 FIND v(dout0_44) AT=950.05n

* CHECK dout0_45 Vdout0_45ck94 = 1.8 time = 950
.meas tran vdout0_45ck94 FIND v(dout0_45) AT=950.05n

* CHECK dout0_46 Vdout0_46ck94 = 0 time = 950
.meas tran vdout0_46ck94 FIND v(dout0_46) AT=950.05n

* CHECK dout0_47 Vdout0_47ck94 = 1.8 time = 950
.meas tran vdout0_47ck94 FIND v(dout0_47) AT=950.05n

* CHECK dout0_48 Vdout0_48ck94 = 1.8 time = 950
.meas tran vdout0_48ck94 FIND v(dout0_48) AT=950.05n

* CHECK dout0_49 Vdout0_49ck94 = 0 time = 950
.meas tran vdout0_49ck94 FIND v(dout0_49) AT=950.05n

* CHECK dout0_50 Vdout0_50ck94 = 1.8 time = 950
.meas tran vdout0_50ck94 FIND v(dout0_50) AT=950.05n

* CHECK dout0_51 Vdout0_51ck94 = 1.8 time = 950
.meas tran vdout0_51ck94 FIND v(dout0_51) AT=950.05n

* CHECK dout0_52 Vdout0_52ck94 = 0 time = 950
.meas tran vdout0_52ck94 FIND v(dout0_52) AT=950.05n

* CHECK dout0_53 Vdout0_53ck94 = 0 time = 950
.meas tran vdout0_53ck94 FIND v(dout0_53) AT=950.05n

* CHECK dout0_54 Vdout0_54ck94 = 1.8 time = 950
.meas tran vdout0_54ck94 FIND v(dout0_54) AT=950.05n

* CHECK dout0_55 Vdout0_55ck94 = 0 time = 950
.meas tran vdout0_55ck94 FIND v(dout0_55) AT=950.05n

* CHECK dout0_56 Vdout0_56ck94 = 1.8 time = 950
.meas tran vdout0_56ck94 FIND v(dout0_56) AT=950.05n

* CHECK dout0_57 Vdout0_57ck94 = 0 time = 950
.meas tran vdout0_57ck94 FIND v(dout0_57) AT=950.05n

* CHECK dout0_58 Vdout0_58ck94 = 1.8 time = 950
.meas tran vdout0_58ck94 FIND v(dout0_58) AT=950.05n

* CHECK dout0_59 Vdout0_59ck94 = 1.8 time = 950
.meas tran vdout0_59ck94 FIND v(dout0_59) AT=950.05n

* CHECK dout0_60 Vdout0_60ck94 = 1.8 time = 950
.meas tran vdout0_60ck94 FIND v(dout0_60) AT=950.05n

* CHECK dout0_61 Vdout0_61ck94 = 1.8 time = 950
.meas tran vdout0_61ck94 FIND v(dout0_61) AT=950.05n

* CHECK dout0_62 Vdout0_62ck94 = 0 time = 950
.meas tran vdout0_62ck94 FIND v(dout0_62) AT=950.05n

* CHECK dout0_63 Vdout0_63ck94 = 0 time = 950
.meas tran vdout0_63ck94 FIND v(dout0_63) AT=950.05n

* CHECK dout0_64 Vdout0_64ck94 = 0 time = 950
.meas tran vdout0_64ck94 FIND v(dout0_64) AT=950.05n

* CHECK dout0_0 Vdout0_0ck95 = 1.8 time = 960
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=960.05n

* CHECK dout0_1 Vdout0_1ck95 = 1.8 time = 960
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=960.05n

* CHECK dout0_2 Vdout0_2ck95 = 0 time = 960
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=960.05n

* CHECK dout0_3 Vdout0_3ck95 = 1.8 time = 960
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=960.05n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 960
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=960.05n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 960
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=960.05n

* CHECK dout0_6 Vdout0_6ck95 = 1.8 time = 960
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=960.05n

* CHECK dout0_7 Vdout0_7ck95 = 0 time = 960
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=960.05n

* CHECK dout0_8 Vdout0_8ck95 = 1.8 time = 960
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=960.05n

* CHECK dout0_9 Vdout0_9ck95 = 1.8 time = 960
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=960.05n

* CHECK dout0_10 Vdout0_10ck95 = 0 time = 960
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=960.05n

* CHECK dout0_11 Vdout0_11ck95 = 1.8 time = 960
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=960.05n

* CHECK dout0_12 Vdout0_12ck95 = 1.8 time = 960
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=960.05n

* CHECK dout0_13 Vdout0_13ck95 = 1.8 time = 960
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=960.05n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 960
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=960.05n

* CHECK dout0_15 Vdout0_15ck95 = 1.8 time = 960
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=960.05n

* CHECK dout0_16 Vdout0_16ck95 = 0 time = 960
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=960.05n

* CHECK dout0_17 Vdout0_17ck95 = 1.8 time = 960
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=960.05n

* CHECK dout0_18 Vdout0_18ck95 = 0 time = 960
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=960.05n

* CHECK dout0_19 Vdout0_19ck95 = 1.8 time = 960
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=960.05n

* CHECK dout0_20 Vdout0_20ck95 = 1.8 time = 960
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=960.05n

* CHECK dout0_21 Vdout0_21ck95 = 0 time = 960
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=960.05n

* CHECK dout0_22 Vdout0_22ck95 = 0 time = 960
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=960.05n

* CHECK dout0_23 Vdout0_23ck95 = 0 time = 960
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=960.05n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 960
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=960.05n

* CHECK dout0_25 Vdout0_25ck95 = 1.8 time = 960
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=960.05n

* CHECK dout0_26 Vdout0_26ck95 = 1.8 time = 960
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=960.05n

* CHECK dout0_27 Vdout0_27ck95 = 1.8 time = 960
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=960.05n

* CHECK dout0_28 Vdout0_28ck95 = 0 time = 960
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=960.05n

* CHECK dout0_29 Vdout0_29ck95 = 1.8 time = 960
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=960.05n

* CHECK dout0_30 Vdout0_30ck95 = 1.8 time = 960
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=960.05n

* CHECK dout0_31 Vdout0_31ck95 = 0 time = 960
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=960.05n

* CHECK dout0_32 Vdout0_32ck95 = 1.8 time = 960
.meas tran vdout0_32ck95 FIND v(dout0_32) AT=960.05n

* CHECK dout0_33 Vdout0_33ck95 = 1.8 time = 960
.meas tran vdout0_33ck95 FIND v(dout0_33) AT=960.05n

* CHECK dout0_34 Vdout0_34ck95 = 1.8 time = 960
.meas tran vdout0_34ck95 FIND v(dout0_34) AT=960.05n

* CHECK dout0_35 Vdout0_35ck95 = 0 time = 960
.meas tran vdout0_35ck95 FIND v(dout0_35) AT=960.05n

* CHECK dout0_36 Vdout0_36ck95 = 1.8 time = 960
.meas tran vdout0_36ck95 FIND v(dout0_36) AT=960.05n

* CHECK dout0_37 Vdout0_37ck95 = 1.8 time = 960
.meas tran vdout0_37ck95 FIND v(dout0_37) AT=960.05n

* CHECK dout0_38 Vdout0_38ck95 = 0 time = 960
.meas tran vdout0_38ck95 FIND v(dout0_38) AT=960.05n

* CHECK dout0_39 Vdout0_39ck95 = 0 time = 960
.meas tran vdout0_39ck95 FIND v(dout0_39) AT=960.05n

* CHECK dout0_40 Vdout0_40ck95 = 1.8 time = 960
.meas tran vdout0_40ck95 FIND v(dout0_40) AT=960.05n

* CHECK dout0_41 Vdout0_41ck95 = 1.8 time = 960
.meas tran vdout0_41ck95 FIND v(dout0_41) AT=960.05n

* CHECK dout0_42 Vdout0_42ck95 = 0 time = 960
.meas tran vdout0_42ck95 FIND v(dout0_42) AT=960.05n

* CHECK dout0_43 Vdout0_43ck95 = 1.8 time = 960
.meas tran vdout0_43ck95 FIND v(dout0_43) AT=960.05n

* CHECK dout0_44 Vdout0_44ck95 = 0 time = 960
.meas tran vdout0_44ck95 FIND v(dout0_44) AT=960.05n

* CHECK dout0_45 Vdout0_45ck95 = 0 time = 960
.meas tran vdout0_45ck95 FIND v(dout0_45) AT=960.05n

* CHECK dout0_46 Vdout0_46ck95 = 0 time = 960
.meas tran vdout0_46ck95 FIND v(dout0_46) AT=960.05n

* CHECK dout0_47 Vdout0_47ck95 = 0 time = 960
.meas tran vdout0_47ck95 FIND v(dout0_47) AT=960.05n

* CHECK dout0_48 Vdout0_48ck95 = 1.8 time = 960
.meas tran vdout0_48ck95 FIND v(dout0_48) AT=960.05n

* CHECK dout0_49 Vdout0_49ck95 = 1.8 time = 960
.meas tran vdout0_49ck95 FIND v(dout0_49) AT=960.05n

* CHECK dout0_50 Vdout0_50ck95 = 0 time = 960
.meas tran vdout0_50ck95 FIND v(dout0_50) AT=960.05n

* CHECK dout0_51 Vdout0_51ck95 = 1.8 time = 960
.meas tran vdout0_51ck95 FIND v(dout0_51) AT=960.05n

* CHECK dout0_52 Vdout0_52ck95 = 0 time = 960
.meas tran vdout0_52ck95 FIND v(dout0_52) AT=960.05n

* CHECK dout0_53 Vdout0_53ck95 = 0 time = 960
.meas tran vdout0_53ck95 FIND v(dout0_53) AT=960.05n

* CHECK dout0_54 Vdout0_54ck95 = 1.8 time = 960
.meas tran vdout0_54ck95 FIND v(dout0_54) AT=960.05n

* CHECK dout0_55 Vdout0_55ck95 = 0 time = 960
.meas tran vdout0_55ck95 FIND v(dout0_55) AT=960.05n

* CHECK dout0_56 Vdout0_56ck95 = 0 time = 960
.meas tran vdout0_56ck95 FIND v(dout0_56) AT=960.05n

* CHECK dout0_57 Vdout0_57ck95 = 1.8 time = 960
.meas tran vdout0_57ck95 FIND v(dout0_57) AT=960.05n

* CHECK dout0_58 Vdout0_58ck95 = 1.8 time = 960
.meas tran vdout0_58ck95 FIND v(dout0_58) AT=960.05n

* CHECK dout0_59 Vdout0_59ck95 = 1.8 time = 960
.meas tran vdout0_59ck95 FIND v(dout0_59) AT=960.05n

* CHECK dout0_60 Vdout0_60ck95 = 1.8 time = 960
.meas tran vdout0_60ck95 FIND v(dout0_60) AT=960.05n

* CHECK dout0_61 Vdout0_61ck95 = 1.8 time = 960
.meas tran vdout0_61ck95 FIND v(dout0_61) AT=960.05n

* CHECK dout0_62 Vdout0_62ck95 = 1.8 time = 960
.meas tran vdout0_62ck95 FIND v(dout0_62) AT=960.05n

* CHECK dout0_63 Vdout0_63ck95 = 1.8 time = 960
.meas tran vdout0_63ck95 FIND v(dout0_63) AT=960.05n

* CHECK dout0_64 Vdout0_64ck95 = 0 time = 960
.meas tran vdout0_64ck95 FIND v(dout0_64) AT=960.05n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 980
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=980.05n

* CHECK dout0_1 Vdout0_1ck97 = 1.8 time = 980
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=980.05n

* CHECK dout0_2 Vdout0_2ck97 = 1.8 time = 980
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=980.05n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 980
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=980.05n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 980
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=980.05n

* CHECK dout0_5 Vdout0_5ck97 = 1.8 time = 980
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=980.05n

* CHECK dout0_6 Vdout0_6ck97 = 1.8 time = 980
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=980.05n

* CHECK dout0_7 Vdout0_7ck97 = 1.8 time = 980
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=980.05n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 980
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=980.05n

* CHECK dout0_9 Vdout0_9ck97 = 1.8 time = 980
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=980.05n

* CHECK dout0_10 Vdout0_10ck97 = 1.8 time = 980
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=980.05n

* CHECK dout0_11 Vdout0_11ck97 = 1.8 time = 980
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=980.05n

* CHECK dout0_12 Vdout0_12ck97 = 1.8 time = 980
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=980.05n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 980
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=980.05n

* CHECK dout0_14 Vdout0_14ck97 = 1.8 time = 980
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=980.05n

* CHECK dout0_15 Vdout0_15ck97 = 0 time = 980
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=980.05n

* CHECK dout0_16 Vdout0_16ck97 = 0 time = 980
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=980.05n

* CHECK dout0_17 Vdout0_17ck97 = 0 time = 980
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=980.05n

* CHECK dout0_18 Vdout0_18ck97 = 0 time = 980
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=980.05n

* CHECK dout0_19 Vdout0_19ck97 = 0 time = 980
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=980.05n

* CHECK dout0_20 Vdout0_20ck97 = 0 time = 980
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=980.05n

* CHECK dout0_21 Vdout0_21ck97 = 1.8 time = 980
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=980.05n

* CHECK dout0_22 Vdout0_22ck97 = 1.8 time = 980
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=980.05n

* CHECK dout0_23 Vdout0_23ck97 = 1.8 time = 980
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=980.05n

* CHECK dout0_24 Vdout0_24ck97 = 0 time = 980
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=980.05n

* CHECK dout0_25 Vdout0_25ck97 = 1.8 time = 980
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=980.05n

* CHECK dout0_26 Vdout0_26ck97 = 0 time = 980
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=980.05n

* CHECK dout0_27 Vdout0_27ck97 = 0 time = 980
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=980.05n

* CHECK dout0_28 Vdout0_28ck97 = 0 time = 980
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=980.05n

* CHECK dout0_29 Vdout0_29ck97 = 0 time = 980
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=980.05n

* CHECK dout0_30 Vdout0_30ck97 = 1.8 time = 980
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=980.05n

* CHECK dout0_31 Vdout0_31ck97 = 1.8 time = 980
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=980.05n

* CHECK dout0_32 Vdout0_32ck97 = 1.8 time = 980
.meas tran vdout0_32ck97 FIND v(dout0_32) AT=980.05n

* CHECK dout0_33 Vdout0_33ck97 = 1.8 time = 980
.meas tran vdout0_33ck97 FIND v(dout0_33) AT=980.05n

* CHECK dout0_34 Vdout0_34ck97 = 1.8 time = 980
.meas tran vdout0_34ck97 FIND v(dout0_34) AT=980.05n

* CHECK dout0_35 Vdout0_35ck97 = 0 time = 980
.meas tran vdout0_35ck97 FIND v(dout0_35) AT=980.05n

* CHECK dout0_36 Vdout0_36ck97 = 1.8 time = 980
.meas tran vdout0_36ck97 FIND v(dout0_36) AT=980.05n

* CHECK dout0_37 Vdout0_37ck97 = 0 time = 980
.meas tran vdout0_37ck97 FIND v(dout0_37) AT=980.05n

* CHECK dout0_38 Vdout0_38ck97 = 0 time = 980
.meas tran vdout0_38ck97 FIND v(dout0_38) AT=980.05n

* CHECK dout0_39 Vdout0_39ck97 = 1.8 time = 980
.meas tran vdout0_39ck97 FIND v(dout0_39) AT=980.05n

* CHECK dout0_40 Vdout0_40ck97 = 0 time = 980
.meas tran vdout0_40ck97 FIND v(dout0_40) AT=980.05n

* CHECK dout0_41 Vdout0_41ck97 = 0 time = 980
.meas tran vdout0_41ck97 FIND v(dout0_41) AT=980.05n

* CHECK dout0_42 Vdout0_42ck97 = 0 time = 980
.meas tran vdout0_42ck97 FIND v(dout0_42) AT=980.05n

* CHECK dout0_43 Vdout0_43ck97 = 1.8 time = 980
.meas tran vdout0_43ck97 FIND v(dout0_43) AT=980.05n

* CHECK dout0_44 Vdout0_44ck97 = 0 time = 980
.meas tran vdout0_44ck97 FIND v(dout0_44) AT=980.05n

* CHECK dout0_45 Vdout0_45ck97 = 1.8 time = 980
.meas tran vdout0_45ck97 FIND v(dout0_45) AT=980.05n

* CHECK dout0_46 Vdout0_46ck97 = 0 time = 980
.meas tran vdout0_46ck97 FIND v(dout0_46) AT=980.05n

* CHECK dout0_47 Vdout0_47ck97 = 1.8 time = 980
.meas tran vdout0_47ck97 FIND v(dout0_47) AT=980.05n

* CHECK dout0_48 Vdout0_48ck97 = 1.8 time = 980
.meas tran vdout0_48ck97 FIND v(dout0_48) AT=980.05n

* CHECK dout0_49 Vdout0_49ck97 = 0 time = 980
.meas tran vdout0_49ck97 FIND v(dout0_49) AT=980.05n

* CHECK dout0_50 Vdout0_50ck97 = 1.8 time = 980
.meas tran vdout0_50ck97 FIND v(dout0_50) AT=980.05n

* CHECK dout0_51 Vdout0_51ck97 = 1.8 time = 980
.meas tran vdout0_51ck97 FIND v(dout0_51) AT=980.05n

* CHECK dout0_52 Vdout0_52ck97 = 0 time = 980
.meas tran vdout0_52ck97 FIND v(dout0_52) AT=980.05n

* CHECK dout0_53 Vdout0_53ck97 = 0 time = 980
.meas tran vdout0_53ck97 FIND v(dout0_53) AT=980.05n

* CHECK dout0_54 Vdout0_54ck97 = 1.8 time = 980
.meas tran vdout0_54ck97 FIND v(dout0_54) AT=980.05n

* CHECK dout0_55 Vdout0_55ck97 = 0 time = 980
.meas tran vdout0_55ck97 FIND v(dout0_55) AT=980.05n

* CHECK dout0_56 Vdout0_56ck97 = 1.8 time = 980
.meas tran vdout0_56ck97 FIND v(dout0_56) AT=980.05n

* CHECK dout0_57 Vdout0_57ck97 = 0 time = 980
.meas tran vdout0_57ck97 FIND v(dout0_57) AT=980.05n

* CHECK dout0_58 Vdout0_58ck97 = 1.8 time = 980
.meas tran vdout0_58ck97 FIND v(dout0_58) AT=980.05n

* CHECK dout0_59 Vdout0_59ck97 = 1.8 time = 980
.meas tran vdout0_59ck97 FIND v(dout0_59) AT=980.05n

* CHECK dout0_60 Vdout0_60ck97 = 1.8 time = 980
.meas tran vdout0_60ck97 FIND v(dout0_60) AT=980.05n

* CHECK dout0_61 Vdout0_61ck97 = 1.8 time = 980
.meas tran vdout0_61ck97 FIND v(dout0_61) AT=980.05n

* CHECK dout0_62 Vdout0_62ck97 = 0 time = 980
.meas tran vdout0_62ck97 FIND v(dout0_62) AT=980.05n

* CHECK dout0_63 Vdout0_63ck97 = 0 time = 980
.meas tran vdout0_63ck97 FIND v(dout0_63) AT=980.05n

* CHECK dout0_64 Vdout0_64ck97 = 0 time = 980
.meas tran vdout0_64ck97 FIND v(dout0_64) AT=980.05n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 1000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=1000.05n

* CHECK dout0_1 Vdout0_1ck99 = 1.8 time = 1000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=1000.05n

* CHECK dout0_2 Vdout0_2ck99 = 1.8 time = 1000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=1000.05n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 1000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=1000.05n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 1000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=1000.05n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 1000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=1000.05n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 1000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=1000.05n

* CHECK dout0_7 Vdout0_7ck99 = 1.8 time = 1000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=1000.05n

* CHECK dout0_8 Vdout0_8ck99 = 1.8 time = 1000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=1000.05n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 1000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=1000.05n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 1000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=1000.05n

* CHECK dout0_11 Vdout0_11ck99 = 1.8 time = 1000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=1000.05n

* CHECK dout0_12 Vdout0_12ck99 = 1.8 time = 1000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=1000.05n

* CHECK dout0_13 Vdout0_13ck99 = 1.8 time = 1000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=1000.05n

* CHECK dout0_14 Vdout0_14ck99 = 1.8 time = 1000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=1000.05n

* CHECK dout0_15 Vdout0_15ck99 = 1.8 time = 1000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=1000.05n

* CHECK dout0_16 Vdout0_16ck99 = 1.8 time = 1000
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=1000.05n

* CHECK dout0_17 Vdout0_17ck99 = 1.8 time = 1000
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=1000.05n

* CHECK dout0_18 Vdout0_18ck99 = 0 time = 1000
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=1000.05n

* CHECK dout0_19 Vdout0_19ck99 = 1.8 time = 1000
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=1000.05n

* CHECK dout0_20 Vdout0_20ck99 = 1.8 time = 1000
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=1000.05n

* CHECK dout0_21 Vdout0_21ck99 = 0 time = 1000
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=1000.05n

* CHECK dout0_22 Vdout0_22ck99 = 0 time = 1000
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=1000.05n

* CHECK dout0_23 Vdout0_23ck99 = 0 time = 1000
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=1000.05n

* CHECK dout0_24 Vdout0_24ck99 = 1.8 time = 1000
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=1000.05n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 1000
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=1000.05n

* CHECK dout0_26 Vdout0_26ck99 = 1.8 time = 1000
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=1000.05n

* CHECK dout0_27 Vdout0_27ck99 = 1.8 time = 1000
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=1000.05n

* CHECK dout0_28 Vdout0_28ck99 = 1.8 time = 1000
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=1000.05n

* CHECK dout0_29 Vdout0_29ck99 = 1.8 time = 1000
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=1000.05n

* CHECK dout0_30 Vdout0_30ck99 = 0 time = 1000
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=1000.05n

* CHECK dout0_31 Vdout0_31ck99 = 1.8 time = 1000
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=1000.05n

* CHECK dout0_32 Vdout0_32ck99 = 1.8 time = 1000
.meas tran vdout0_32ck99 FIND v(dout0_32) AT=1000.05n

* CHECK dout0_33 Vdout0_33ck99 = 1.8 time = 1000
.meas tran vdout0_33ck99 FIND v(dout0_33) AT=1000.05n

* CHECK dout0_34 Vdout0_34ck99 = 1.8 time = 1000
.meas tran vdout0_34ck99 FIND v(dout0_34) AT=1000.05n

* CHECK dout0_35 Vdout0_35ck99 = 0 time = 1000
.meas tran vdout0_35ck99 FIND v(dout0_35) AT=1000.05n

* CHECK dout0_36 Vdout0_36ck99 = 1.8 time = 1000
.meas tran vdout0_36ck99 FIND v(dout0_36) AT=1000.05n

* CHECK dout0_37 Vdout0_37ck99 = 1.8 time = 1000
.meas tran vdout0_37ck99 FIND v(dout0_37) AT=1000.05n

* CHECK dout0_38 Vdout0_38ck99 = 0 time = 1000
.meas tran vdout0_38ck99 FIND v(dout0_38) AT=1000.05n

* CHECK dout0_39 Vdout0_39ck99 = 1.8 time = 1000
.meas tran vdout0_39ck99 FIND v(dout0_39) AT=1000.05n

* CHECK dout0_40 Vdout0_40ck99 = 0 time = 1000
.meas tran vdout0_40ck99 FIND v(dout0_40) AT=1000.05n

* CHECK dout0_41 Vdout0_41ck99 = 0 time = 1000
.meas tran vdout0_41ck99 FIND v(dout0_41) AT=1000.05n

* CHECK dout0_42 Vdout0_42ck99 = 1.8 time = 1000
.meas tran vdout0_42ck99 FIND v(dout0_42) AT=1000.05n

* CHECK dout0_43 Vdout0_43ck99 = 0 time = 1000
.meas tran vdout0_43ck99 FIND v(dout0_43) AT=1000.05n

* CHECK dout0_44 Vdout0_44ck99 = 0 time = 1000
.meas tran vdout0_44ck99 FIND v(dout0_44) AT=1000.05n

* CHECK dout0_45 Vdout0_45ck99 = 1.8 time = 1000
.meas tran vdout0_45ck99 FIND v(dout0_45) AT=1000.05n

* CHECK dout0_46 Vdout0_46ck99 = 1.8 time = 1000
.meas tran vdout0_46ck99 FIND v(dout0_46) AT=1000.05n

* CHECK dout0_47 Vdout0_47ck99 = 0 time = 1000
.meas tran vdout0_47ck99 FIND v(dout0_47) AT=1000.05n

* CHECK dout0_48 Vdout0_48ck99 = 0 time = 1000
.meas tran vdout0_48ck99 FIND v(dout0_48) AT=1000.05n

* CHECK dout0_49 Vdout0_49ck99 = 0 time = 1000
.meas tran vdout0_49ck99 FIND v(dout0_49) AT=1000.05n

* CHECK dout0_50 Vdout0_50ck99 = 0 time = 1000
.meas tran vdout0_50ck99 FIND v(dout0_50) AT=1000.05n

* CHECK dout0_51 Vdout0_51ck99 = 0 time = 1000
.meas tran vdout0_51ck99 FIND v(dout0_51) AT=1000.05n

* CHECK dout0_52 Vdout0_52ck99 = 0 time = 1000
.meas tran vdout0_52ck99 FIND v(dout0_52) AT=1000.05n

* CHECK dout0_53 Vdout0_53ck99 = 1.8 time = 1000
.meas tran vdout0_53ck99 FIND v(dout0_53) AT=1000.05n

* CHECK dout0_54 Vdout0_54ck99 = 0 time = 1000
.meas tran vdout0_54ck99 FIND v(dout0_54) AT=1000.05n

* CHECK dout0_55 Vdout0_55ck99 = 0 time = 1000
.meas tran vdout0_55ck99 FIND v(dout0_55) AT=1000.05n

* CHECK dout0_56 Vdout0_56ck99 = 0 time = 1000
.meas tran vdout0_56ck99 FIND v(dout0_56) AT=1000.05n

* CHECK dout0_57 Vdout0_57ck99 = 1.8 time = 1000
.meas tran vdout0_57ck99 FIND v(dout0_57) AT=1000.05n

* CHECK dout0_58 Vdout0_58ck99 = 0 time = 1000
.meas tran vdout0_58ck99 FIND v(dout0_58) AT=1000.05n

* CHECK dout0_59 Vdout0_59ck99 = 0 time = 1000
.meas tran vdout0_59ck99 FIND v(dout0_59) AT=1000.05n

* CHECK dout0_60 Vdout0_60ck99 = 0 time = 1000
.meas tran vdout0_60ck99 FIND v(dout0_60) AT=1000.05n

* CHECK dout0_61 Vdout0_61ck99 = 1.8 time = 1000
.meas tran vdout0_61ck99 FIND v(dout0_61) AT=1000.05n

* CHECK dout0_62 Vdout0_62ck99 = 1.8 time = 1000
.meas tran vdout0_62ck99 FIND v(dout0_62) AT=1000.05n

* CHECK dout0_63 Vdout0_63ck99 = 0 time = 1000
.meas tran vdout0_63ck99 FIND v(dout0_63) AT=1000.05n

* CHECK dout0_64 Vdout0_64ck99 = 0 time = 1000
.meas tran vdout0_64ck99 FIND v(dout0_64) AT=1000.05n

* CHECK dout0_0 Vdout0_0ck101 = 1.8 time = 1020
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=1020.05n

* CHECK dout0_1 Vdout0_1ck101 = 1.8 time = 1020
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=1020.05n

* CHECK dout0_2 Vdout0_2ck101 = 1.8 time = 1020
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=1020.05n

* CHECK dout0_3 Vdout0_3ck101 = 1.8 time = 1020
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=1020.05n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 1020
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=1020.05n

* CHECK dout0_5 Vdout0_5ck101 = 1.8 time = 1020
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=1020.05n

* CHECK dout0_6 Vdout0_6ck101 = 1.8 time = 1020
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=1020.05n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 1020
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=1020.05n

* CHECK dout0_8 Vdout0_8ck101 = 1.8 time = 1020
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=1020.05n

* CHECK dout0_9 Vdout0_9ck101 = 1.8 time = 1020
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=1020.05n

* CHECK dout0_10 Vdout0_10ck101 = 1.8 time = 1020
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=1020.05n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 1020
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=1020.05n

* CHECK dout0_12 Vdout0_12ck101 = 1.8 time = 1020
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=1020.05n

* CHECK dout0_13 Vdout0_13ck101 = 0 time = 1020
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=1020.05n

* CHECK dout0_14 Vdout0_14ck101 = 1.8 time = 1020
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=1020.05n

* CHECK dout0_15 Vdout0_15ck101 = 0 time = 1020
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=1020.05n

* CHECK dout0_16 Vdout0_16ck101 = 0 time = 1020
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=1020.05n

* CHECK dout0_17 Vdout0_17ck101 = 0 time = 1020
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=1020.05n

* CHECK dout0_18 Vdout0_18ck101 = 1.8 time = 1020
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=1020.05n

* CHECK dout0_19 Vdout0_19ck101 = 1.8 time = 1020
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=1020.05n

* CHECK dout0_20 Vdout0_20ck101 = 0 time = 1020
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=1020.05n

* CHECK dout0_21 Vdout0_21ck101 = 0 time = 1020
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=1020.05n

* CHECK dout0_22 Vdout0_22ck101 = 0 time = 1020
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=1020.05n

* CHECK dout0_23 Vdout0_23ck101 = 1.8 time = 1020
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=1020.05n

* CHECK dout0_24 Vdout0_24ck101 = 1.8 time = 1020
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=1020.05n

* CHECK dout0_25 Vdout0_25ck101 = 1.8 time = 1020
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=1020.05n

* CHECK dout0_26 Vdout0_26ck101 = 0 time = 1020
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=1020.05n

* CHECK dout0_27 Vdout0_27ck101 = 1.8 time = 1020
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=1020.05n

* CHECK dout0_28 Vdout0_28ck101 = 1.8 time = 1020
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=1020.05n

* CHECK dout0_29 Vdout0_29ck101 = 1.8 time = 1020
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=1020.05n

* CHECK dout0_30 Vdout0_30ck101 = 0 time = 1020
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=1020.05n

* CHECK dout0_31 Vdout0_31ck101 = 1.8 time = 1020
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=1020.05n

* CHECK dout0_32 Vdout0_32ck101 = 1.8 time = 1020
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=1020.05n

* CHECK dout0_33 Vdout0_33ck101 = 1.8 time = 1020
.meas tran vdout0_33ck101 FIND v(dout0_33) AT=1020.05n

* CHECK dout0_34 Vdout0_34ck101 = 0 time = 1020
.meas tran vdout0_34ck101 FIND v(dout0_34) AT=1020.05n

* CHECK dout0_35 Vdout0_35ck101 = 1.8 time = 1020
.meas tran vdout0_35ck101 FIND v(dout0_35) AT=1020.05n

* CHECK dout0_36 Vdout0_36ck101 = 0 time = 1020
.meas tran vdout0_36ck101 FIND v(dout0_36) AT=1020.05n

* CHECK dout0_37 Vdout0_37ck101 = 0 time = 1020
.meas tran vdout0_37ck101 FIND v(dout0_37) AT=1020.05n

* CHECK dout0_38 Vdout0_38ck101 = 0 time = 1020
.meas tran vdout0_38ck101 FIND v(dout0_38) AT=1020.05n

* CHECK dout0_39 Vdout0_39ck101 = 0 time = 1020
.meas tran vdout0_39ck101 FIND v(dout0_39) AT=1020.05n

* CHECK dout0_40 Vdout0_40ck101 = 0 time = 1020
.meas tran vdout0_40ck101 FIND v(dout0_40) AT=1020.05n

* CHECK dout0_41 Vdout0_41ck101 = 0 time = 1020
.meas tran vdout0_41ck101 FIND v(dout0_41) AT=1020.05n

* CHECK dout0_42 Vdout0_42ck101 = 0 time = 1020
.meas tran vdout0_42ck101 FIND v(dout0_42) AT=1020.05n

* CHECK dout0_43 Vdout0_43ck101 = 1.8 time = 1020
.meas tran vdout0_43ck101 FIND v(dout0_43) AT=1020.05n

* CHECK dout0_44 Vdout0_44ck101 = 1.8 time = 1020
.meas tran vdout0_44ck101 FIND v(dout0_44) AT=1020.05n

* CHECK dout0_45 Vdout0_45ck101 = 0 time = 1020
.meas tran vdout0_45ck101 FIND v(dout0_45) AT=1020.05n

* CHECK dout0_46 Vdout0_46ck101 = 1.8 time = 1020
.meas tran vdout0_46ck101 FIND v(dout0_46) AT=1020.05n

* CHECK dout0_47 Vdout0_47ck101 = 1.8 time = 1020
.meas tran vdout0_47ck101 FIND v(dout0_47) AT=1020.05n

* CHECK dout0_48 Vdout0_48ck101 = 0 time = 1020
.meas tran vdout0_48ck101 FIND v(dout0_48) AT=1020.05n

* CHECK dout0_49 Vdout0_49ck101 = 1.8 time = 1020
.meas tran vdout0_49ck101 FIND v(dout0_49) AT=1020.05n

* CHECK dout0_50 Vdout0_50ck101 = 0 time = 1020
.meas tran vdout0_50ck101 FIND v(dout0_50) AT=1020.05n

* CHECK dout0_51 Vdout0_51ck101 = 0 time = 1020
.meas tran vdout0_51ck101 FIND v(dout0_51) AT=1020.05n

* CHECK dout0_52 Vdout0_52ck101 = 1.8 time = 1020
.meas tran vdout0_52ck101 FIND v(dout0_52) AT=1020.05n

* CHECK dout0_53 Vdout0_53ck101 = 0 time = 1020
.meas tran vdout0_53ck101 FIND v(dout0_53) AT=1020.05n

* CHECK dout0_54 Vdout0_54ck101 = 0 time = 1020
.meas tran vdout0_54ck101 FIND v(dout0_54) AT=1020.05n

* CHECK dout0_55 Vdout0_55ck101 = 1.8 time = 1020
.meas tran vdout0_55ck101 FIND v(dout0_55) AT=1020.05n

* CHECK dout0_56 Vdout0_56ck101 = 0 time = 1020
.meas tran vdout0_56ck101 FIND v(dout0_56) AT=1020.05n

* CHECK dout0_57 Vdout0_57ck101 = 0 time = 1020
.meas tran vdout0_57ck101 FIND v(dout0_57) AT=1020.05n

* CHECK dout0_58 Vdout0_58ck101 = 1.8 time = 1020
.meas tran vdout0_58ck101 FIND v(dout0_58) AT=1020.05n

* CHECK dout0_59 Vdout0_59ck101 = 0 time = 1020
.meas tran vdout0_59ck101 FIND v(dout0_59) AT=1020.05n

* CHECK dout0_60 Vdout0_60ck101 = 1.8 time = 1020
.meas tran vdout0_60ck101 FIND v(dout0_60) AT=1020.05n

* CHECK dout0_61 Vdout0_61ck101 = 1.8 time = 1020
.meas tran vdout0_61ck101 FIND v(dout0_61) AT=1020.05n

* CHECK dout0_62 Vdout0_62ck101 = 0 time = 1020
.meas tran vdout0_62ck101 FIND v(dout0_62) AT=1020.05n

* CHECK dout0_63 Vdout0_63ck101 = 0 time = 1020
.meas tran vdout0_63ck101 FIND v(dout0_63) AT=1020.05n

* CHECK dout0_64 Vdout0_64ck101 = 0 time = 1020
.meas tran vdout0_64ck101 FIND v(dout0_64) AT=1020.05n

* CHECK dout0_0 Vdout0_0ck102 = 1.8 time = 1030
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=1030.05n

* CHECK dout0_1 Vdout0_1ck102 = 1.8 time = 1030
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=1030.05n

* CHECK dout0_2 Vdout0_2ck102 = 1.8 time = 1030
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=1030.05n

* CHECK dout0_3 Vdout0_3ck102 = 1.8 time = 1030
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=1030.05n

* CHECK dout0_4 Vdout0_4ck102 = 1.8 time = 1030
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=1030.05n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 1030
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=1030.05n

* CHECK dout0_6 Vdout0_6ck102 = 1.8 time = 1030
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=1030.05n

* CHECK dout0_7 Vdout0_7ck102 = 1.8 time = 1030
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=1030.05n

* CHECK dout0_8 Vdout0_8ck102 = 1.8 time = 1030
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=1030.05n

* CHECK dout0_9 Vdout0_9ck102 = 1.8 time = 1030
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=1030.05n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 1030
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=1030.05n

* CHECK dout0_11 Vdout0_11ck102 = 0 time = 1030
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=1030.05n

* CHECK dout0_12 Vdout0_12ck102 = 1.8 time = 1030
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=1030.05n

* CHECK dout0_13 Vdout0_13ck102 = 0 time = 1030
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=1030.05n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 1030
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=1030.05n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 1030
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=1030.05n

* CHECK dout0_16 Vdout0_16ck102 = 1.8 time = 1030
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=1030.05n

* CHECK dout0_17 Vdout0_17ck102 = 0 time = 1030
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=1030.05n

* CHECK dout0_18 Vdout0_18ck102 = 1.8 time = 1030
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=1030.05n

* CHECK dout0_19 Vdout0_19ck102 = 0 time = 1030
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=1030.05n

* CHECK dout0_20 Vdout0_20ck102 = 1.8 time = 1030
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=1030.05n

* CHECK dout0_21 Vdout0_21ck102 = 1.8 time = 1030
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=1030.05n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 1030
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=1030.05n

* CHECK dout0_23 Vdout0_23ck102 = 1.8 time = 1030
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=1030.05n

* CHECK dout0_24 Vdout0_24ck102 = 1.8 time = 1030
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=1030.05n

* CHECK dout0_25 Vdout0_25ck102 = 0 time = 1030
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=1030.05n

* CHECK dout0_26 Vdout0_26ck102 = 1.8 time = 1030
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=1030.05n

* CHECK dout0_27 Vdout0_27ck102 = 1.8 time = 1030
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=1030.05n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 1030
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=1030.05n

* CHECK dout0_29 Vdout0_29ck102 = 1.8 time = 1030
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=1030.05n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 1030
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=1030.05n

* CHECK dout0_31 Vdout0_31ck102 = 1.8 time = 1030
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=1030.05n

* CHECK dout0_32 Vdout0_32ck102 = 1.8 time = 1030
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=1030.05n

* CHECK dout0_33 Vdout0_33ck102 = 1.8 time = 1030
.meas tran vdout0_33ck102 FIND v(dout0_33) AT=1030.05n

* CHECK dout0_34 Vdout0_34ck102 = 1.8 time = 1030
.meas tran vdout0_34ck102 FIND v(dout0_34) AT=1030.05n

* CHECK dout0_35 Vdout0_35ck102 = 1.8 time = 1030
.meas tran vdout0_35ck102 FIND v(dout0_35) AT=1030.05n

* CHECK dout0_36 Vdout0_36ck102 = 0 time = 1030
.meas tran vdout0_36ck102 FIND v(dout0_36) AT=1030.05n

* CHECK dout0_37 Vdout0_37ck102 = 0 time = 1030
.meas tran vdout0_37ck102 FIND v(dout0_37) AT=1030.05n

* CHECK dout0_38 Vdout0_38ck102 = 0 time = 1030
.meas tran vdout0_38ck102 FIND v(dout0_38) AT=1030.05n

* CHECK dout0_39 Vdout0_39ck102 = 0 time = 1030
.meas tran vdout0_39ck102 FIND v(dout0_39) AT=1030.05n

* CHECK dout0_40 Vdout0_40ck102 = 1.8 time = 1030
.meas tran vdout0_40ck102 FIND v(dout0_40) AT=1030.05n

* CHECK dout0_41 Vdout0_41ck102 = 1.8 time = 1030
.meas tran vdout0_41ck102 FIND v(dout0_41) AT=1030.05n

* CHECK dout0_42 Vdout0_42ck102 = 1.8 time = 1030
.meas tran vdout0_42ck102 FIND v(dout0_42) AT=1030.05n

* CHECK dout0_43 Vdout0_43ck102 = 1.8 time = 1030
.meas tran vdout0_43ck102 FIND v(dout0_43) AT=1030.05n

* CHECK dout0_44 Vdout0_44ck102 = 0 time = 1030
.meas tran vdout0_44ck102 FIND v(dout0_44) AT=1030.05n

* CHECK dout0_45 Vdout0_45ck102 = 0 time = 1030
.meas tran vdout0_45ck102 FIND v(dout0_45) AT=1030.05n

* CHECK dout0_46 Vdout0_46ck102 = 0 time = 1030
.meas tran vdout0_46ck102 FIND v(dout0_46) AT=1030.05n

* CHECK dout0_47 Vdout0_47ck102 = 1.8 time = 1030
.meas tran vdout0_47ck102 FIND v(dout0_47) AT=1030.05n

* CHECK dout0_48 Vdout0_48ck102 = 1.8 time = 1030
.meas tran vdout0_48ck102 FIND v(dout0_48) AT=1030.05n

* CHECK dout0_49 Vdout0_49ck102 = 1.8 time = 1030
.meas tran vdout0_49ck102 FIND v(dout0_49) AT=1030.05n

* CHECK dout0_50 Vdout0_50ck102 = 1.8 time = 1030
.meas tran vdout0_50ck102 FIND v(dout0_50) AT=1030.05n

* CHECK dout0_51 Vdout0_51ck102 = 1.8 time = 1030
.meas tran vdout0_51ck102 FIND v(dout0_51) AT=1030.05n

* CHECK dout0_52 Vdout0_52ck102 = 0 time = 1030
.meas tran vdout0_52ck102 FIND v(dout0_52) AT=1030.05n

* CHECK dout0_53 Vdout0_53ck102 = 0 time = 1030
.meas tran vdout0_53ck102 FIND v(dout0_53) AT=1030.05n

* CHECK dout0_54 Vdout0_54ck102 = 1.8 time = 1030
.meas tran vdout0_54ck102 FIND v(dout0_54) AT=1030.05n

* CHECK dout0_55 Vdout0_55ck102 = 1.8 time = 1030
.meas tran vdout0_55ck102 FIND v(dout0_55) AT=1030.05n

* CHECK dout0_56 Vdout0_56ck102 = 1.8 time = 1030
.meas tran vdout0_56ck102 FIND v(dout0_56) AT=1030.05n

* CHECK dout0_57 Vdout0_57ck102 = 1.8 time = 1030
.meas tran vdout0_57ck102 FIND v(dout0_57) AT=1030.05n

* CHECK dout0_58 Vdout0_58ck102 = 1.8 time = 1030
.meas tran vdout0_58ck102 FIND v(dout0_58) AT=1030.05n

* CHECK dout0_59 Vdout0_59ck102 = 0 time = 1030
.meas tran vdout0_59ck102 FIND v(dout0_59) AT=1030.05n

* CHECK dout0_60 Vdout0_60ck102 = 1.8 time = 1030
.meas tran vdout0_60ck102 FIND v(dout0_60) AT=1030.05n

* CHECK dout0_61 Vdout0_61ck102 = 1.8 time = 1030
.meas tran vdout0_61ck102 FIND v(dout0_61) AT=1030.05n

* CHECK dout0_62 Vdout0_62ck102 = 1.8 time = 1030
.meas tran vdout0_62ck102 FIND v(dout0_62) AT=1030.05n

* CHECK dout0_63 Vdout0_63ck102 = 1.8 time = 1030
.meas tran vdout0_63ck102 FIND v(dout0_63) AT=1030.05n

* CHECK dout0_64 Vdout0_64ck102 = 0 time = 1030
.meas tran vdout0_64ck102 FIND v(dout0_64) AT=1030.05n

* CHECK dout0_0 Vdout0_0ck104 = 1.8 time = 1050
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=1050.05n

* CHECK dout0_1 Vdout0_1ck104 = 1.8 time = 1050
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=1050.05n

* CHECK dout0_2 Vdout0_2ck104 = 1.8 time = 1050
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=1050.05n

* CHECK dout0_3 Vdout0_3ck104 = 0 time = 1050
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=1050.05n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 1050
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=1050.05n

* CHECK dout0_5 Vdout0_5ck104 = 0 time = 1050
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=1050.05n

* CHECK dout0_6 Vdout0_6ck104 = 0 time = 1050
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=1050.05n

* CHECK dout0_7 Vdout0_7ck104 = 1.8 time = 1050
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=1050.05n

* CHECK dout0_8 Vdout0_8ck104 = 1.8 time = 1050
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=1050.05n

* CHECK dout0_9 Vdout0_9ck104 = 0 time = 1050
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=1050.05n

* CHECK dout0_10 Vdout0_10ck104 = 0 time = 1050
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=1050.05n

* CHECK dout0_11 Vdout0_11ck104 = 1.8 time = 1050
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=1050.05n

* CHECK dout0_12 Vdout0_12ck104 = 1.8 time = 1050
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=1050.05n

* CHECK dout0_13 Vdout0_13ck104 = 1.8 time = 1050
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=1050.05n

* CHECK dout0_14 Vdout0_14ck104 = 1.8 time = 1050
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=1050.05n

* CHECK dout0_15 Vdout0_15ck104 = 1.8 time = 1050
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=1050.05n

* CHECK dout0_16 Vdout0_16ck104 = 1.8 time = 1050
.meas tran vdout0_16ck104 FIND v(dout0_16) AT=1050.05n

* CHECK dout0_17 Vdout0_17ck104 = 1.8 time = 1050
.meas tran vdout0_17ck104 FIND v(dout0_17) AT=1050.05n

* CHECK dout0_18 Vdout0_18ck104 = 0 time = 1050
.meas tran vdout0_18ck104 FIND v(dout0_18) AT=1050.05n

* CHECK dout0_19 Vdout0_19ck104 = 1.8 time = 1050
.meas tran vdout0_19ck104 FIND v(dout0_19) AT=1050.05n

* CHECK dout0_20 Vdout0_20ck104 = 1.8 time = 1050
.meas tran vdout0_20ck104 FIND v(dout0_20) AT=1050.05n

* CHECK dout0_21 Vdout0_21ck104 = 0 time = 1050
.meas tran vdout0_21ck104 FIND v(dout0_21) AT=1050.05n

* CHECK dout0_22 Vdout0_22ck104 = 0 time = 1050
.meas tran vdout0_22ck104 FIND v(dout0_22) AT=1050.05n

* CHECK dout0_23 Vdout0_23ck104 = 0 time = 1050
.meas tran vdout0_23ck104 FIND v(dout0_23) AT=1050.05n

* CHECK dout0_24 Vdout0_24ck104 = 1.8 time = 1050
.meas tran vdout0_24ck104 FIND v(dout0_24) AT=1050.05n

* CHECK dout0_25 Vdout0_25ck104 = 0 time = 1050
.meas tran vdout0_25ck104 FIND v(dout0_25) AT=1050.05n

* CHECK dout0_26 Vdout0_26ck104 = 1.8 time = 1050
.meas tran vdout0_26ck104 FIND v(dout0_26) AT=1050.05n

* CHECK dout0_27 Vdout0_27ck104 = 1.8 time = 1050
.meas tran vdout0_27ck104 FIND v(dout0_27) AT=1050.05n

* CHECK dout0_28 Vdout0_28ck104 = 1.8 time = 1050
.meas tran vdout0_28ck104 FIND v(dout0_28) AT=1050.05n

* CHECK dout0_29 Vdout0_29ck104 = 1.8 time = 1050
.meas tran vdout0_29ck104 FIND v(dout0_29) AT=1050.05n

* CHECK dout0_30 Vdout0_30ck104 = 0 time = 1050
.meas tran vdout0_30ck104 FIND v(dout0_30) AT=1050.05n

* CHECK dout0_31 Vdout0_31ck104 = 1.8 time = 1050
.meas tran vdout0_31ck104 FIND v(dout0_31) AT=1050.05n

* CHECK dout0_32 Vdout0_32ck104 = 1.8 time = 1050
.meas tran vdout0_32ck104 FIND v(dout0_32) AT=1050.05n

* CHECK dout0_33 Vdout0_33ck104 = 1.8 time = 1050
.meas tran vdout0_33ck104 FIND v(dout0_33) AT=1050.05n

* CHECK dout0_34 Vdout0_34ck104 = 1.8 time = 1050
.meas tran vdout0_34ck104 FIND v(dout0_34) AT=1050.05n

* CHECK dout0_35 Vdout0_35ck104 = 0 time = 1050
.meas tran vdout0_35ck104 FIND v(dout0_35) AT=1050.05n

* CHECK dout0_36 Vdout0_36ck104 = 1.8 time = 1050
.meas tran vdout0_36ck104 FIND v(dout0_36) AT=1050.05n

* CHECK dout0_37 Vdout0_37ck104 = 1.8 time = 1050
.meas tran vdout0_37ck104 FIND v(dout0_37) AT=1050.05n

* CHECK dout0_38 Vdout0_38ck104 = 0 time = 1050
.meas tran vdout0_38ck104 FIND v(dout0_38) AT=1050.05n

* CHECK dout0_39 Vdout0_39ck104 = 1.8 time = 1050
.meas tran vdout0_39ck104 FIND v(dout0_39) AT=1050.05n

* CHECK dout0_40 Vdout0_40ck104 = 0 time = 1050
.meas tran vdout0_40ck104 FIND v(dout0_40) AT=1050.05n

* CHECK dout0_41 Vdout0_41ck104 = 0 time = 1050
.meas tran vdout0_41ck104 FIND v(dout0_41) AT=1050.05n

* CHECK dout0_42 Vdout0_42ck104 = 1.8 time = 1050
.meas tran vdout0_42ck104 FIND v(dout0_42) AT=1050.05n

* CHECK dout0_43 Vdout0_43ck104 = 0 time = 1050
.meas tran vdout0_43ck104 FIND v(dout0_43) AT=1050.05n

* CHECK dout0_44 Vdout0_44ck104 = 0 time = 1050
.meas tran vdout0_44ck104 FIND v(dout0_44) AT=1050.05n

* CHECK dout0_45 Vdout0_45ck104 = 1.8 time = 1050
.meas tran vdout0_45ck104 FIND v(dout0_45) AT=1050.05n

* CHECK dout0_46 Vdout0_46ck104 = 1.8 time = 1050
.meas tran vdout0_46ck104 FIND v(dout0_46) AT=1050.05n

* CHECK dout0_47 Vdout0_47ck104 = 0 time = 1050
.meas tran vdout0_47ck104 FIND v(dout0_47) AT=1050.05n

* CHECK dout0_48 Vdout0_48ck104 = 0 time = 1050
.meas tran vdout0_48ck104 FIND v(dout0_48) AT=1050.05n

* CHECK dout0_49 Vdout0_49ck104 = 0 time = 1050
.meas tran vdout0_49ck104 FIND v(dout0_49) AT=1050.05n

* CHECK dout0_50 Vdout0_50ck104 = 0 time = 1050
.meas tran vdout0_50ck104 FIND v(dout0_50) AT=1050.05n

* CHECK dout0_51 Vdout0_51ck104 = 0 time = 1050
.meas tran vdout0_51ck104 FIND v(dout0_51) AT=1050.05n

* CHECK dout0_52 Vdout0_52ck104 = 0 time = 1050
.meas tran vdout0_52ck104 FIND v(dout0_52) AT=1050.05n

* CHECK dout0_53 Vdout0_53ck104 = 1.8 time = 1050
.meas tran vdout0_53ck104 FIND v(dout0_53) AT=1050.05n

* CHECK dout0_54 Vdout0_54ck104 = 0 time = 1050
.meas tran vdout0_54ck104 FIND v(dout0_54) AT=1050.05n

* CHECK dout0_55 Vdout0_55ck104 = 0 time = 1050
.meas tran vdout0_55ck104 FIND v(dout0_55) AT=1050.05n

* CHECK dout0_56 Vdout0_56ck104 = 0 time = 1050
.meas tran vdout0_56ck104 FIND v(dout0_56) AT=1050.05n

* CHECK dout0_57 Vdout0_57ck104 = 1.8 time = 1050
.meas tran vdout0_57ck104 FIND v(dout0_57) AT=1050.05n

* CHECK dout0_58 Vdout0_58ck104 = 0 time = 1050
.meas tran vdout0_58ck104 FIND v(dout0_58) AT=1050.05n

* CHECK dout0_59 Vdout0_59ck104 = 0 time = 1050
.meas tran vdout0_59ck104 FIND v(dout0_59) AT=1050.05n

* CHECK dout0_60 Vdout0_60ck104 = 0 time = 1050
.meas tran vdout0_60ck104 FIND v(dout0_60) AT=1050.05n

* CHECK dout0_61 Vdout0_61ck104 = 1.8 time = 1050
.meas tran vdout0_61ck104 FIND v(dout0_61) AT=1050.05n

* CHECK dout0_62 Vdout0_62ck104 = 1.8 time = 1050
.meas tran vdout0_62ck104 FIND v(dout0_62) AT=1050.05n

* CHECK dout0_63 Vdout0_63ck104 = 0 time = 1050
.meas tran vdout0_63ck104 FIND v(dout0_63) AT=1050.05n

* CHECK dout0_64 Vdout0_64ck104 = 0 time = 1050
.meas tran vdout0_64ck104 FIND v(dout0_64) AT=1050.05n

* CHECK dout0_0 Vdout0_0ck105 = 1.8 time = 1060
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=1060.05n

* CHECK dout0_1 Vdout0_1ck105 = 1.8 time = 1060
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=1060.05n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 1060
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=1060.05n

* CHECK dout0_3 Vdout0_3ck105 = 0 time = 1060
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=1060.05n

* CHECK dout0_4 Vdout0_4ck105 = 1.8 time = 1060
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=1060.05n

* CHECK dout0_5 Vdout0_5ck105 = 1.8 time = 1060
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=1060.05n

* CHECK dout0_6 Vdout0_6ck105 = 0 time = 1060
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=1060.05n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 1060
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=1060.05n

* CHECK dout0_8 Vdout0_8ck105 = 1.8 time = 1060
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=1060.05n

* CHECK dout0_9 Vdout0_9ck105 = 1.8 time = 1060
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=1060.05n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 1060
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=1060.05n

* CHECK dout0_11 Vdout0_11ck105 = 1.8 time = 1060
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=1060.05n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 1060
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=1060.05n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 1060
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=1060.05n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 1060
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=1060.05n

* CHECK dout0_15 Vdout0_15ck105 = 1.8 time = 1060
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=1060.05n

* CHECK dout0_16 Vdout0_16ck105 = 1.8 time = 1060
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=1060.05n

* CHECK dout0_17 Vdout0_17ck105 = 1.8 time = 1060
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=1060.05n

* CHECK dout0_18 Vdout0_18ck105 = 1.8 time = 1060
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=1060.05n

* CHECK dout0_19 Vdout0_19ck105 = 0 time = 1060
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=1060.05n

* CHECK dout0_20 Vdout0_20ck105 = 1.8 time = 1060
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=1060.05n

* CHECK dout0_21 Vdout0_21ck105 = 0 time = 1060
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=1060.05n

* CHECK dout0_22 Vdout0_22ck105 = 1.8 time = 1060
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=1060.05n

* CHECK dout0_23 Vdout0_23ck105 = 0 time = 1060
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=1060.05n

* CHECK dout0_24 Vdout0_24ck105 = 0 time = 1060
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=1060.05n

* CHECK dout0_25 Vdout0_25ck105 = 1.8 time = 1060
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=1060.05n

* CHECK dout0_26 Vdout0_26ck105 = 0 time = 1060
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=1060.05n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 1060
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=1060.05n

* CHECK dout0_28 Vdout0_28ck105 = 0 time = 1060
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=1060.05n

* CHECK dout0_29 Vdout0_29ck105 = 0 time = 1060
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=1060.05n

* CHECK dout0_30 Vdout0_30ck105 = 0 time = 1060
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=1060.05n

* CHECK dout0_31 Vdout0_31ck105 = 1.8 time = 1060
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=1060.05n

* CHECK dout0_32 Vdout0_32ck105 = 0 time = 1060
.meas tran vdout0_32ck105 FIND v(dout0_32) AT=1060.05n

* CHECK dout0_33 Vdout0_33ck105 = 1.8 time = 1060
.meas tran vdout0_33ck105 FIND v(dout0_33) AT=1060.05n

* CHECK dout0_34 Vdout0_34ck105 = 0 time = 1060
.meas tran vdout0_34ck105 FIND v(dout0_34) AT=1060.05n

* CHECK dout0_35 Vdout0_35ck105 = 0 time = 1060
.meas tran vdout0_35ck105 FIND v(dout0_35) AT=1060.05n

* CHECK dout0_36 Vdout0_36ck105 = 0 time = 1060
.meas tran vdout0_36ck105 FIND v(dout0_36) AT=1060.05n

* CHECK dout0_37 Vdout0_37ck105 = 1.8 time = 1060
.meas tran vdout0_37ck105 FIND v(dout0_37) AT=1060.05n

* CHECK dout0_38 Vdout0_38ck105 = 1.8 time = 1060
.meas tran vdout0_38ck105 FIND v(dout0_38) AT=1060.05n

* CHECK dout0_39 Vdout0_39ck105 = 0 time = 1060
.meas tran vdout0_39ck105 FIND v(dout0_39) AT=1060.05n

* CHECK dout0_40 Vdout0_40ck105 = 1.8 time = 1060
.meas tran vdout0_40ck105 FIND v(dout0_40) AT=1060.05n

* CHECK dout0_41 Vdout0_41ck105 = 0 time = 1060
.meas tran vdout0_41ck105 FIND v(dout0_41) AT=1060.05n

* CHECK dout0_42 Vdout0_42ck105 = 1.8 time = 1060
.meas tran vdout0_42ck105 FIND v(dout0_42) AT=1060.05n

* CHECK dout0_43 Vdout0_43ck105 = 1.8 time = 1060
.meas tran vdout0_43ck105 FIND v(dout0_43) AT=1060.05n

* CHECK dout0_44 Vdout0_44ck105 = 0 time = 1060
.meas tran vdout0_44ck105 FIND v(dout0_44) AT=1060.05n

* CHECK dout0_45 Vdout0_45ck105 = 0 time = 1060
.meas tran vdout0_45ck105 FIND v(dout0_45) AT=1060.05n

* CHECK dout0_46 Vdout0_46ck105 = 0 time = 1060
.meas tran vdout0_46ck105 FIND v(dout0_46) AT=1060.05n

* CHECK dout0_47 Vdout0_47ck105 = 1.8 time = 1060
.meas tran vdout0_47ck105 FIND v(dout0_47) AT=1060.05n

* CHECK dout0_48 Vdout0_48ck105 = 1.8 time = 1060
.meas tran vdout0_48ck105 FIND v(dout0_48) AT=1060.05n

* CHECK dout0_49 Vdout0_49ck105 = 1.8 time = 1060
.meas tran vdout0_49ck105 FIND v(dout0_49) AT=1060.05n

* CHECK dout0_50 Vdout0_50ck105 = 0 time = 1060
.meas tran vdout0_50ck105 FIND v(dout0_50) AT=1060.05n

* CHECK dout0_51 Vdout0_51ck105 = 0 time = 1060
.meas tran vdout0_51ck105 FIND v(dout0_51) AT=1060.05n

* CHECK dout0_52 Vdout0_52ck105 = 0 time = 1060
.meas tran vdout0_52ck105 FIND v(dout0_52) AT=1060.05n

* CHECK dout0_53 Vdout0_53ck105 = 1.8 time = 1060
.meas tran vdout0_53ck105 FIND v(dout0_53) AT=1060.05n

* CHECK dout0_54 Vdout0_54ck105 = 0 time = 1060
.meas tran vdout0_54ck105 FIND v(dout0_54) AT=1060.05n

* CHECK dout0_55 Vdout0_55ck105 = 0 time = 1060
.meas tran vdout0_55ck105 FIND v(dout0_55) AT=1060.05n

* CHECK dout0_56 Vdout0_56ck105 = 1.8 time = 1060
.meas tran vdout0_56ck105 FIND v(dout0_56) AT=1060.05n

* CHECK dout0_57 Vdout0_57ck105 = 1.8 time = 1060
.meas tran vdout0_57ck105 FIND v(dout0_57) AT=1060.05n

* CHECK dout0_58 Vdout0_58ck105 = 0 time = 1060
.meas tran vdout0_58ck105 FIND v(dout0_58) AT=1060.05n

* CHECK dout0_59 Vdout0_59ck105 = 0 time = 1060
.meas tran vdout0_59ck105 FIND v(dout0_59) AT=1060.05n

* CHECK dout0_60 Vdout0_60ck105 = 1.8 time = 1060
.meas tran vdout0_60ck105 FIND v(dout0_60) AT=1060.05n

* CHECK dout0_61 Vdout0_61ck105 = 1.8 time = 1060
.meas tran vdout0_61ck105 FIND v(dout0_61) AT=1060.05n

* CHECK dout0_62 Vdout0_62ck105 = 1.8 time = 1060
.meas tran vdout0_62ck105 FIND v(dout0_62) AT=1060.05n

* CHECK dout0_63 Vdout0_63ck105 = 0 time = 1060
.meas tran vdout0_63ck105 FIND v(dout0_63) AT=1060.05n

* CHECK dout0_64 Vdout0_64ck105 = 0 time = 1060
.meas tran vdout0_64ck105 FIND v(dout0_64) AT=1060.05n

* CHECK dout0_0 Vdout0_0ck106 = 1.8 time = 1070
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=1070.05n

* CHECK dout0_1 Vdout0_1ck106 = 1.8 time = 1070
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=1070.05n

* CHECK dout0_2 Vdout0_2ck106 = 0 time = 1070
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=1070.05n

* CHECK dout0_3 Vdout0_3ck106 = 1.8 time = 1070
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=1070.05n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 1070
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=1070.05n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 1070
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=1070.05n

* CHECK dout0_6 Vdout0_6ck106 = 1.8 time = 1070
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=1070.05n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 1070
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=1070.05n

* CHECK dout0_8 Vdout0_8ck106 = 1.8 time = 1070
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=1070.05n

* CHECK dout0_9 Vdout0_9ck106 = 1.8 time = 1070
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=1070.05n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 1070
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=1070.05n

* CHECK dout0_11 Vdout0_11ck106 = 1.8 time = 1070
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=1070.05n

* CHECK dout0_12 Vdout0_12ck106 = 1.8 time = 1070
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=1070.05n

* CHECK dout0_13 Vdout0_13ck106 = 1.8 time = 1070
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=1070.05n

* CHECK dout0_14 Vdout0_14ck106 = 0 time = 1070
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=1070.05n

* CHECK dout0_15 Vdout0_15ck106 = 1.8 time = 1070
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=1070.05n

* CHECK dout0_16 Vdout0_16ck106 = 0 time = 1070
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=1070.05n

* CHECK dout0_17 Vdout0_17ck106 = 1.8 time = 1070
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=1070.05n

* CHECK dout0_18 Vdout0_18ck106 = 0 time = 1070
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=1070.05n

* CHECK dout0_19 Vdout0_19ck106 = 1.8 time = 1070
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=1070.05n

* CHECK dout0_20 Vdout0_20ck106 = 1.8 time = 1070
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=1070.05n

* CHECK dout0_21 Vdout0_21ck106 = 0 time = 1070
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=1070.05n

* CHECK dout0_22 Vdout0_22ck106 = 0 time = 1070
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=1070.05n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 1070
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=1070.05n

* CHECK dout0_24 Vdout0_24ck106 = 0 time = 1070
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=1070.05n

* CHECK dout0_25 Vdout0_25ck106 = 1.8 time = 1070
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=1070.05n

* CHECK dout0_26 Vdout0_26ck106 = 1.8 time = 1070
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=1070.05n

* CHECK dout0_27 Vdout0_27ck106 = 1.8 time = 1070
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=1070.05n

* CHECK dout0_28 Vdout0_28ck106 = 0 time = 1070
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=1070.05n

* CHECK dout0_29 Vdout0_29ck106 = 1.8 time = 1070
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=1070.05n

* CHECK dout0_30 Vdout0_30ck106 = 1.8 time = 1070
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=1070.05n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 1070
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=1070.05n

* CHECK dout0_32 Vdout0_32ck106 = 1.8 time = 1070
.meas tran vdout0_32ck106 FIND v(dout0_32) AT=1070.05n

* CHECK dout0_33 Vdout0_33ck106 = 1.8 time = 1070
.meas tran vdout0_33ck106 FIND v(dout0_33) AT=1070.05n

* CHECK dout0_34 Vdout0_34ck106 = 1.8 time = 1070
.meas tran vdout0_34ck106 FIND v(dout0_34) AT=1070.05n

* CHECK dout0_35 Vdout0_35ck106 = 0 time = 1070
.meas tran vdout0_35ck106 FIND v(dout0_35) AT=1070.05n

* CHECK dout0_36 Vdout0_36ck106 = 1.8 time = 1070
.meas tran vdout0_36ck106 FIND v(dout0_36) AT=1070.05n

* CHECK dout0_37 Vdout0_37ck106 = 1.8 time = 1070
.meas tran vdout0_37ck106 FIND v(dout0_37) AT=1070.05n

* CHECK dout0_38 Vdout0_38ck106 = 0 time = 1070
.meas tran vdout0_38ck106 FIND v(dout0_38) AT=1070.05n

* CHECK dout0_39 Vdout0_39ck106 = 0 time = 1070
.meas tran vdout0_39ck106 FIND v(dout0_39) AT=1070.05n

* CHECK dout0_40 Vdout0_40ck106 = 1.8 time = 1070
.meas tran vdout0_40ck106 FIND v(dout0_40) AT=1070.05n

* CHECK dout0_41 Vdout0_41ck106 = 1.8 time = 1070
.meas tran vdout0_41ck106 FIND v(dout0_41) AT=1070.05n

* CHECK dout0_42 Vdout0_42ck106 = 0 time = 1070
.meas tran vdout0_42ck106 FIND v(dout0_42) AT=1070.05n

* CHECK dout0_43 Vdout0_43ck106 = 1.8 time = 1070
.meas tran vdout0_43ck106 FIND v(dout0_43) AT=1070.05n

* CHECK dout0_44 Vdout0_44ck106 = 0 time = 1070
.meas tran vdout0_44ck106 FIND v(dout0_44) AT=1070.05n

* CHECK dout0_45 Vdout0_45ck106 = 0 time = 1070
.meas tran vdout0_45ck106 FIND v(dout0_45) AT=1070.05n

* CHECK dout0_46 Vdout0_46ck106 = 0 time = 1070
.meas tran vdout0_46ck106 FIND v(dout0_46) AT=1070.05n

* CHECK dout0_47 Vdout0_47ck106 = 0 time = 1070
.meas tran vdout0_47ck106 FIND v(dout0_47) AT=1070.05n

* CHECK dout0_48 Vdout0_48ck106 = 1.8 time = 1070
.meas tran vdout0_48ck106 FIND v(dout0_48) AT=1070.05n

* CHECK dout0_49 Vdout0_49ck106 = 1.8 time = 1070
.meas tran vdout0_49ck106 FIND v(dout0_49) AT=1070.05n

* CHECK dout0_50 Vdout0_50ck106 = 0 time = 1070
.meas tran vdout0_50ck106 FIND v(dout0_50) AT=1070.05n

* CHECK dout0_51 Vdout0_51ck106 = 1.8 time = 1070
.meas tran vdout0_51ck106 FIND v(dout0_51) AT=1070.05n

* CHECK dout0_52 Vdout0_52ck106 = 0 time = 1070
.meas tran vdout0_52ck106 FIND v(dout0_52) AT=1070.05n

* CHECK dout0_53 Vdout0_53ck106 = 0 time = 1070
.meas tran vdout0_53ck106 FIND v(dout0_53) AT=1070.05n

* CHECK dout0_54 Vdout0_54ck106 = 1.8 time = 1070
.meas tran vdout0_54ck106 FIND v(dout0_54) AT=1070.05n

* CHECK dout0_55 Vdout0_55ck106 = 0 time = 1070
.meas tran vdout0_55ck106 FIND v(dout0_55) AT=1070.05n

* CHECK dout0_56 Vdout0_56ck106 = 0 time = 1070
.meas tran vdout0_56ck106 FIND v(dout0_56) AT=1070.05n

* CHECK dout0_57 Vdout0_57ck106 = 1.8 time = 1070
.meas tran vdout0_57ck106 FIND v(dout0_57) AT=1070.05n

* CHECK dout0_58 Vdout0_58ck106 = 1.8 time = 1070
.meas tran vdout0_58ck106 FIND v(dout0_58) AT=1070.05n

* CHECK dout0_59 Vdout0_59ck106 = 1.8 time = 1070
.meas tran vdout0_59ck106 FIND v(dout0_59) AT=1070.05n

* CHECK dout0_60 Vdout0_60ck106 = 1.8 time = 1070
.meas tran vdout0_60ck106 FIND v(dout0_60) AT=1070.05n

* CHECK dout0_61 Vdout0_61ck106 = 1.8 time = 1070
.meas tran vdout0_61ck106 FIND v(dout0_61) AT=1070.05n

* CHECK dout0_62 Vdout0_62ck106 = 1.8 time = 1070
.meas tran vdout0_62ck106 FIND v(dout0_62) AT=1070.05n

* CHECK dout0_63 Vdout0_63ck106 = 1.8 time = 1070
.meas tran vdout0_63ck106 FIND v(dout0_63) AT=1070.05n

* CHECK dout0_64 Vdout0_64ck106 = 0 time = 1070
.meas tran vdout0_64ck106 FIND v(dout0_64) AT=1070.05n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 1090
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=1090.05n

* CHECK dout0_1 Vdout0_1ck108 = 1.8 time = 1090
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=1090.05n

* CHECK dout0_2 Vdout0_2ck108 = 1.8 time = 1090
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=1090.05n

* CHECK dout0_3 Vdout0_3ck108 = 0 time = 1090
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=1090.05n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 1090
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=1090.05n

* CHECK dout0_5 Vdout0_5ck108 = 1.8 time = 1090
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=1090.05n

* CHECK dout0_6 Vdout0_6ck108 = 1.8 time = 1090
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=1090.05n

* CHECK dout0_7 Vdout0_7ck108 = 1.8 time = 1090
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=1090.05n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 1090
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=1090.05n

* CHECK dout0_9 Vdout0_9ck108 = 1.8 time = 1090
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=1090.05n

* CHECK dout0_10 Vdout0_10ck108 = 1.8 time = 1090
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=1090.05n

* CHECK dout0_11 Vdout0_11ck108 = 1.8 time = 1090
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=1090.05n

* CHECK dout0_12 Vdout0_12ck108 = 1.8 time = 1090
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=1090.05n

* CHECK dout0_13 Vdout0_13ck108 = 0 time = 1090
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=1090.05n

* CHECK dout0_14 Vdout0_14ck108 = 1.8 time = 1090
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=1090.05n

* CHECK dout0_15 Vdout0_15ck108 = 0 time = 1090
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=1090.05n

* CHECK dout0_16 Vdout0_16ck108 = 0 time = 1090
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=1090.05n

* CHECK dout0_17 Vdout0_17ck108 = 0 time = 1090
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=1090.05n

* CHECK dout0_18 Vdout0_18ck108 = 0 time = 1090
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=1090.05n

* CHECK dout0_19 Vdout0_19ck108 = 0 time = 1090
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=1090.05n

* CHECK dout0_20 Vdout0_20ck108 = 0 time = 1090
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=1090.05n

* CHECK dout0_21 Vdout0_21ck108 = 1.8 time = 1090
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=1090.05n

* CHECK dout0_22 Vdout0_22ck108 = 1.8 time = 1090
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=1090.05n

* CHECK dout0_23 Vdout0_23ck108 = 1.8 time = 1090
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=1090.05n

* CHECK dout0_24 Vdout0_24ck108 = 0 time = 1090
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=1090.05n

* CHECK dout0_25 Vdout0_25ck108 = 1.8 time = 1090
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=1090.05n

* CHECK dout0_26 Vdout0_26ck108 = 0 time = 1090
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=1090.05n

* CHECK dout0_27 Vdout0_27ck108 = 0 time = 1090
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=1090.05n

* CHECK dout0_28 Vdout0_28ck108 = 0 time = 1090
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=1090.05n

* CHECK dout0_29 Vdout0_29ck108 = 0 time = 1090
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=1090.05n

* CHECK dout0_30 Vdout0_30ck108 = 1.8 time = 1090
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=1090.05n

* CHECK dout0_31 Vdout0_31ck108 = 1.8 time = 1090
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=1090.05n

* CHECK dout0_32 Vdout0_32ck108 = 1.8 time = 1090
.meas tran vdout0_32ck108 FIND v(dout0_32) AT=1090.05n

* CHECK dout0_33 Vdout0_33ck108 = 1.8 time = 1090
.meas tran vdout0_33ck108 FIND v(dout0_33) AT=1090.05n

* CHECK dout0_34 Vdout0_34ck108 = 1.8 time = 1090
.meas tran vdout0_34ck108 FIND v(dout0_34) AT=1090.05n

* CHECK dout0_35 Vdout0_35ck108 = 0 time = 1090
.meas tran vdout0_35ck108 FIND v(dout0_35) AT=1090.05n

* CHECK dout0_36 Vdout0_36ck108 = 1.8 time = 1090
.meas tran vdout0_36ck108 FIND v(dout0_36) AT=1090.05n

* CHECK dout0_37 Vdout0_37ck108 = 0 time = 1090
.meas tran vdout0_37ck108 FIND v(dout0_37) AT=1090.05n

* CHECK dout0_38 Vdout0_38ck108 = 0 time = 1090
.meas tran vdout0_38ck108 FIND v(dout0_38) AT=1090.05n

* CHECK dout0_39 Vdout0_39ck108 = 1.8 time = 1090
.meas tran vdout0_39ck108 FIND v(dout0_39) AT=1090.05n

* CHECK dout0_40 Vdout0_40ck108 = 0 time = 1090
.meas tran vdout0_40ck108 FIND v(dout0_40) AT=1090.05n

* CHECK dout0_41 Vdout0_41ck108 = 0 time = 1090
.meas tran vdout0_41ck108 FIND v(dout0_41) AT=1090.05n

* CHECK dout0_42 Vdout0_42ck108 = 0 time = 1090
.meas tran vdout0_42ck108 FIND v(dout0_42) AT=1090.05n

* CHECK dout0_43 Vdout0_43ck108 = 1.8 time = 1090
.meas tran vdout0_43ck108 FIND v(dout0_43) AT=1090.05n

* CHECK dout0_44 Vdout0_44ck108 = 0 time = 1090
.meas tran vdout0_44ck108 FIND v(dout0_44) AT=1090.05n

* CHECK dout0_45 Vdout0_45ck108 = 1.8 time = 1090
.meas tran vdout0_45ck108 FIND v(dout0_45) AT=1090.05n

* CHECK dout0_46 Vdout0_46ck108 = 0 time = 1090
.meas tran vdout0_46ck108 FIND v(dout0_46) AT=1090.05n

* CHECK dout0_47 Vdout0_47ck108 = 1.8 time = 1090
.meas tran vdout0_47ck108 FIND v(dout0_47) AT=1090.05n

* CHECK dout0_48 Vdout0_48ck108 = 1.8 time = 1090
.meas tran vdout0_48ck108 FIND v(dout0_48) AT=1090.05n

* CHECK dout0_49 Vdout0_49ck108 = 0 time = 1090
.meas tran vdout0_49ck108 FIND v(dout0_49) AT=1090.05n

* CHECK dout0_50 Vdout0_50ck108 = 1.8 time = 1090
.meas tran vdout0_50ck108 FIND v(dout0_50) AT=1090.05n

* CHECK dout0_51 Vdout0_51ck108 = 1.8 time = 1090
.meas tran vdout0_51ck108 FIND v(dout0_51) AT=1090.05n

* CHECK dout0_52 Vdout0_52ck108 = 0 time = 1090
.meas tran vdout0_52ck108 FIND v(dout0_52) AT=1090.05n

* CHECK dout0_53 Vdout0_53ck108 = 0 time = 1090
.meas tran vdout0_53ck108 FIND v(dout0_53) AT=1090.05n

* CHECK dout0_54 Vdout0_54ck108 = 1.8 time = 1090
.meas tran vdout0_54ck108 FIND v(dout0_54) AT=1090.05n

* CHECK dout0_55 Vdout0_55ck108 = 0 time = 1090
.meas tran vdout0_55ck108 FIND v(dout0_55) AT=1090.05n

* CHECK dout0_56 Vdout0_56ck108 = 1.8 time = 1090
.meas tran vdout0_56ck108 FIND v(dout0_56) AT=1090.05n

* CHECK dout0_57 Vdout0_57ck108 = 0 time = 1090
.meas tran vdout0_57ck108 FIND v(dout0_57) AT=1090.05n

* CHECK dout0_58 Vdout0_58ck108 = 1.8 time = 1090
.meas tran vdout0_58ck108 FIND v(dout0_58) AT=1090.05n

* CHECK dout0_59 Vdout0_59ck108 = 1.8 time = 1090
.meas tran vdout0_59ck108 FIND v(dout0_59) AT=1090.05n

* CHECK dout0_60 Vdout0_60ck108 = 1.8 time = 1090
.meas tran vdout0_60ck108 FIND v(dout0_60) AT=1090.05n

* CHECK dout0_61 Vdout0_61ck108 = 1.8 time = 1090
.meas tran vdout0_61ck108 FIND v(dout0_61) AT=1090.05n

* CHECK dout0_62 Vdout0_62ck108 = 0 time = 1090
.meas tran vdout0_62ck108 FIND v(dout0_62) AT=1090.05n

* CHECK dout0_63 Vdout0_63ck108 = 0 time = 1090
.meas tran vdout0_63ck108 FIND v(dout0_63) AT=1090.05n

* CHECK dout0_64 Vdout0_64ck108 = 0 time = 1090
.meas tran vdout0_64ck108 FIND v(dout0_64) AT=1090.05n

* CHECK dout0_0 Vdout0_0ck110 = 1.8 time = 1110
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=1110.05n

* CHECK dout0_1 Vdout0_1ck110 = 1.8 time = 1110
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=1110.05n

* CHECK dout0_2 Vdout0_2ck110 = 1.8 time = 1110
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=1110.05n

* CHECK dout0_3 Vdout0_3ck110 = 0 time = 1110
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=1110.05n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 1110
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=1110.05n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 1110
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=1110.05n

* CHECK dout0_6 Vdout0_6ck110 = 0 time = 1110
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=1110.05n

* CHECK dout0_7 Vdout0_7ck110 = 1.8 time = 1110
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=1110.05n

* CHECK dout0_8 Vdout0_8ck110 = 1.8 time = 1110
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=1110.05n

* CHECK dout0_9 Vdout0_9ck110 = 0 time = 1110
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=1110.05n

* CHECK dout0_10 Vdout0_10ck110 = 0 time = 1110
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=1110.05n

* CHECK dout0_11 Vdout0_11ck110 = 1.8 time = 1110
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=1110.05n

* CHECK dout0_12 Vdout0_12ck110 = 1.8 time = 1110
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=1110.05n

* CHECK dout0_13 Vdout0_13ck110 = 1.8 time = 1110
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=1110.05n

* CHECK dout0_14 Vdout0_14ck110 = 1.8 time = 1110
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=1110.05n

* CHECK dout0_15 Vdout0_15ck110 = 1.8 time = 1110
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=1110.05n

* CHECK dout0_16 Vdout0_16ck110 = 1.8 time = 1110
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=1110.05n

* CHECK dout0_17 Vdout0_17ck110 = 1.8 time = 1110
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=1110.05n

* CHECK dout0_18 Vdout0_18ck110 = 0 time = 1110
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=1110.05n

* CHECK dout0_19 Vdout0_19ck110 = 1.8 time = 1110
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=1110.05n

* CHECK dout0_20 Vdout0_20ck110 = 1.8 time = 1110
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=1110.05n

* CHECK dout0_21 Vdout0_21ck110 = 0 time = 1110
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=1110.05n

* CHECK dout0_22 Vdout0_22ck110 = 0 time = 1110
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=1110.05n

* CHECK dout0_23 Vdout0_23ck110 = 0 time = 1110
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=1110.05n

* CHECK dout0_24 Vdout0_24ck110 = 1.8 time = 1110
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=1110.05n

* CHECK dout0_25 Vdout0_25ck110 = 0 time = 1110
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=1110.05n

* CHECK dout0_26 Vdout0_26ck110 = 1.8 time = 1110
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=1110.05n

* CHECK dout0_27 Vdout0_27ck110 = 1.8 time = 1110
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=1110.05n

* CHECK dout0_28 Vdout0_28ck110 = 1.8 time = 1110
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=1110.05n

* CHECK dout0_29 Vdout0_29ck110 = 1.8 time = 1110
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=1110.05n

* CHECK dout0_30 Vdout0_30ck110 = 0 time = 1110
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=1110.05n

* CHECK dout0_31 Vdout0_31ck110 = 1.8 time = 1110
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=1110.05n

* CHECK dout0_32 Vdout0_32ck110 = 1.8 time = 1110
.meas tran vdout0_32ck110 FIND v(dout0_32) AT=1110.05n

* CHECK dout0_33 Vdout0_33ck110 = 1.8 time = 1110
.meas tran vdout0_33ck110 FIND v(dout0_33) AT=1110.05n

* CHECK dout0_34 Vdout0_34ck110 = 1.8 time = 1110
.meas tran vdout0_34ck110 FIND v(dout0_34) AT=1110.05n

* CHECK dout0_35 Vdout0_35ck110 = 0 time = 1110
.meas tran vdout0_35ck110 FIND v(dout0_35) AT=1110.05n

* CHECK dout0_36 Vdout0_36ck110 = 1.8 time = 1110
.meas tran vdout0_36ck110 FIND v(dout0_36) AT=1110.05n

* CHECK dout0_37 Vdout0_37ck110 = 1.8 time = 1110
.meas tran vdout0_37ck110 FIND v(dout0_37) AT=1110.05n

* CHECK dout0_38 Vdout0_38ck110 = 0 time = 1110
.meas tran vdout0_38ck110 FIND v(dout0_38) AT=1110.05n

* CHECK dout0_39 Vdout0_39ck110 = 1.8 time = 1110
.meas tran vdout0_39ck110 FIND v(dout0_39) AT=1110.05n

* CHECK dout0_40 Vdout0_40ck110 = 0 time = 1110
.meas tran vdout0_40ck110 FIND v(dout0_40) AT=1110.05n

* CHECK dout0_41 Vdout0_41ck110 = 0 time = 1110
.meas tran vdout0_41ck110 FIND v(dout0_41) AT=1110.05n

* CHECK dout0_42 Vdout0_42ck110 = 1.8 time = 1110
.meas tran vdout0_42ck110 FIND v(dout0_42) AT=1110.05n

* CHECK dout0_43 Vdout0_43ck110 = 0 time = 1110
.meas tran vdout0_43ck110 FIND v(dout0_43) AT=1110.05n

* CHECK dout0_44 Vdout0_44ck110 = 0 time = 1110
.meas tran vdout0_44ck110 FIND v(dout0_44) AT=1110.05n

* CHECK dout0_45 Vdout0_45ck110 = 1.8 time = 1110
.meas tran vdout0_45ck110 FIND v(dout0_45) AT=1110.05n

* CHECK dout0_46 Vdout0_46ck110 = 1.8 time = 1110
.meas tran vdout0_46ck110 FIND v(dout0_46) AT=1110.05n

* CHECK dout0_47 Vdout0_47ck110 = 0 time = 1110
.meas tran vdout0_47ck110 FIND v(dout0_47) AT=1110.05n

* CHECK dout0_48 Vdout0_48ck110 = 0 time = 1110
.meas tran vdout0_48ck110 FIND v(dout0_48) AT=1110.05n

* CHECK dout0_49 Vdout0_49ck110 = 0 time = 1110
.meas tran vdout0_49ck110 FIND v(dout0_49) AT=1110.05n

* CHECK dout0_50 Vdout0_50ck110 = 0 time = 1110
.meas tran vdout0_50ck110 FIND v(dout0_50) AT=1110.05n

* CHECK dout0_51 Vdout0_51ck110 = 0 time = 1110
.meas tran vdout0_51ck110 FIND v(dout0_51) AT=1110.05n

* CHECK dout0_52 Vdout0_52ck110 = 0 time = 1110
.meas tran vdout0_52ck110 FIND v(dout0_52) AT=1110.05n

* CHECK dout0_53 Vdout0_53ck110 = 1.8 time = 1110
.meas tran vdout0_53ck110 FIND v(dout0_53) AT=1110.05n

* CHECK dout0_54 Vdout0_54ck110 = 0 time = 1110
.meas tran vdout0_54ck110 FIND v(dout0_54) AT=1110.05n

* CHECK dout0_55 Vdout0_55ck110 = 0 time = 1110
.meas tran vdout0_55ck110 FIND v(dout0_55) AT=1110.05n

* CHECK dout0_56 Vdout0_56ck110 = 0 time = 1110
.meas tran vdout0_56ck110 FIND v(dout0_56) AT=1110.05n

* CHECK dout0_57 Vdout0_57ck110 = 1.8 time = 1110
.meas tran vdout0_57ck110 FIND v(dout0_57) AT=1110.05n

* CHECK dout0_58 Vdout0_58ck110 = 0 time = 1110
.meas tran vdout0_58ck110 FIND v(dout0_58) AT=1110.05n

* CHECK dout0_59 Vdout0_59ck110 = 0 time = 1110
.meas tran vdout0_59ck110 FIND v(dout0_59) AT=1110.05n

* CHECK dout0_60 Vdout0_60ck110 = 0 time = 1110
.meas tran vdout0_60ck110 FIND v(dout0_60) AT=1110.05n

* CHECK dout0_61 Vdout0_61ck110 = 1.8 time = 1110
.meas tran vdout0_61ck110 FIND v(dout0_61) AT=1110.05n

* CHECK dout0_62 Vdout0_62ck110 = 1.8 time = 1110
.meas tran vdout0_62ck110 FIND v(dout0_62) AT=1110.05n

* CHECK dout0_63 Vdout0_63ck110 = 0 time = 1110
.meas tran vdout0_63ck110 FIND v(dout0_63) AT=1110.05n

* CHECK dout0_64 Vdout0_64ck110 = 0 time = 1110
.meas tran vdout0_64ck110 FIND v(dout0_64) AT=1110.05n

* CHECK dout0_0 Vdout0_0ck113 = 1.8 time = 1140
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=1140.05n

* CHECK dout0_1 Vdout0_1ck113 = 1.8 time = 1140
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=1140.05n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 1140
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=1140.05n

* CHECK dout0_3 Vdout0_3ck113 = 1.8 time = 1140
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=1140.05n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 1140
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=1140.05n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 1140
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=1140.05n

* CHECK dout0_6 Vdout0_6ck113 = 1.8 time = 1140
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=1140.05n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 1140
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=1140.05n

* CHECK dout0_8 Vdout0_8ck113 = 1.8 time = 1140
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=1140.05n

* CHECK dout0_9 Vdout0_9ck113 = 1.8 time = 1140
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=1140.05n

* CHECK dout0_10 Vdout0_10ck113 = 0 time = 1140
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=1140.05n

* CHECK dout0_11 Vdout0_11ck113 = 1.8 time = 1140
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=1140.05n

* CHECK dout0_12 Vdout0_12ck113 = 1.8 time = 1140
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=1140.05n

* CHECK dout0_13 Vdout0_13ck113 = 1.8 time = 1140
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=1140.05n

* CHECK dout0_14 Vdout0_14ck113 = 0 time = 1140
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=1140.05n

* CHECK dout0_15 Vdout0_15ck113 = 1.8 time = 1140
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=1140.05n

* CHECK dout0_16 Vdout0_16ck113 = 0 time = 1140
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=1140.05n

* CHECK dout0_17 Vdout0_17ck113 = 1.8 time = 1140
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=1140.05n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 1140
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=1140.05n

* CHECK dout0_19 Vdout0_19ck113 = 1.8 time = 1140
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=1140.05n

* CHECK dout0_20 Vdout0_20ck113 = 1.8 time = 1140
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=1140.05n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 1140
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=1140.05n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 1140
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=1140.05n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 1140
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=1140.05n

* CHECK dout0_24 Vdout0_24ck113 = 0 time = 1140
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=1140.05n

* CHECK dout0_25 Vdout0_25ck113 = 1.8 time = 1140
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=1140.05n

* CHECK dout0_26 Vdout0_26ck113 = 1.8 time = 1140
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=1140.05n

* CHECK dout0_27 Vdout0_27ck113 = 1.8 time = 1140
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=1140.05n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 1140
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=1140.05n

* CHECK dout0_29 Vdout0_29ck113 = 1.8 time = 1140
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=1140.05n

* CHECK dout0_30 Vdout0_30ck113 = 1.8 time = 1140
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=1140.05n

* CHECK dout0_31 Vdout0_31ck113 = 0 time = 1140
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=1140.05n

* CHECK dout0_32 Vdout0_32ck113 = 1.8 time = 1140
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=1140.05n

* CHECK dout0_33 Vdout0_33ck113 = 1.8 time = 1140
.meas tran vdout0_33ck113 FIND v(dout0_33) AT=1140.05n

* CHECK dout0_34 Vdout0_34ck113 = 1.8 time = 1140
.meas tran vdout0_34ck113 FIND v(dout0_34) AT=1140.05n

* CHECK dout0_35 Vdout0_35ck113 = 0 time = 1140
.meas tran vdout0_35ck113 FIND v(dout0_35) AT=1140.05n

* CHECK dout0_36 Vdout0_36ck113 = 1.8 time = 1140
.meas tran vdout0_36ck113 FIND v(dout0_36) AT=1140.05n

* CHECK dout0_37 Vdout0_37ck113 = 1.8 time = 1140
.meas tran vdout0_37ck113 FIND v(dout0_37) AT=1140.05n

* CHECK dout0_38 Vdout0_38ck113 = 0 time = 1140
.meas tran vdout0_38ck113 FIND v(dout0_38) AT=1140.05n

* CHECK dout0_39 Vdout0_39ck113 = 0 time = 1140
.meas tran vdout0_39ck113 FIND v(dout0_39) AT=1140.05n

* CHECK dout0_40 Vdout0_40ck113 = 1.8 time = 1140
.meas tran vdout0_40ck113 FIND v(dout0_40) AT=1140.05n

* CHECK dout0_41 Vdout0_41ck113 = 1.8 time = 1140
.meas tran vdout0_41ck113 FIND v(dout0_41) AT=1140.05n

* CHECK dout0_42 Vdout0_42ck113 = 0 time = 1140
.meas tran vdout0_42ck113 FIND v(dout0_42) AT=1140.05n

* CHECK dout0_43 Vdout0_43ck113 = 1.8 time = 1140
.meas tran vdout0_43ck113 FIND v(dout0_43) AT=1140.05n

* CHECK dout0_44 Vdout0_44ck113 = 0 time = 1140
.meas tran vdout0_44ck113 FIND v(dout0_44) AT=1140.05n

* CHECK dout0_45 Vdout0_45ck113 = 0 time = 1140
.meas tran vdout0_45ck113 FIND v(dout0_45) AT=1140.05n

* CHECK dout0_46 Vdout0_46ck113 = 0 time = 1140
.meas tran vdout0_46ck113 FIND v(dout0_46) AT=1140.05n

* CHECK dout0_47 Vdout0_47ck113 = 0 time = 1140
.meas tran vdout0_47ck113 FIND v(dout0_47) AT=1140.05n

* CHECK dout0_48 Vdout0_48ck113 = 1.8 time = 1140
.meas tran vdout0_48ck113 FIND v(dout0_48) AT=1140.05n

* CHECK dout0_49 Vdout0_49ck113 = 1.8 time = 1140
.meas tran vdout0_49ck113 FIND v(dout0_49) AT=1140.05n

* CHECK dout0_50 Vdout0_50ck113 = 0 time = 1140
.meas tran vdout0_50ck113 FIND v(dout0_50) AT=1140.05n

* CHECK dout0_51 Vdout0_51ck113 = 1.8 time = 1140
.meas tran vdout0_51ck113 FIND v(dout0_51) AT=1140.05n

* CHECK dout0_52 Vdout0_52ck113 = 0 time = 1140
.meas tran vdout0_52ck113 FIND v(dout0_52) AT=1140.05n

* CHECK dout0_53 Vdout0_53ck113 = 0 time = 1140
.meas tran vdout0_53ck113 FIND v(dout0_53) AT=1140.05n

* CHECK dout0_54 Vdout0_54ck113 = 1.8 time = 1140
.meas tran vdout0_54ck113 FIND v(dout0_54) AT=1140.05n

* CHECK dout0_55 Vdout0_55ck113 = 0 time = 1140
.meas tran vdout0_55ck113 FIND v(dout0_55) AT=1140.05n

* CHECK dout0_56 Vdout0_56ck113 = 0 time = 1140
.meas tran vdout0_56ck113 FIND v(dout0_56) AT=1140.05n

* CHECK dout0_57 Vdout0_57ck113 = 1.8 time = 1140
.meas tran vdout0_57ck113 FIND v(dout0_57) AT=1140.05n

* CHECK dout0_58 Vdout0_58ck113 = 1.8 time = 1140
.meas tran vdout0_58ck113 FIND v(dout0_58) AT=1140.05n

* CHECK dout0_59 Vdout0_59ck113 = 1.8 time = 1140
.meas tran vdout0_59ck113 FIND v(dout0_59) AT=1140.05n

* CHECK dout0_60 Vdout0_60ck113 = 1.8 time = 1140
.meas tran vdout0_60ck113 FIND v(dout0_60) AT=1140.05n

* CHECK dout0_61 Vdout0_61ck113 = 1.8 time = 1140
.meas tran vdout0_61ck113 FIND v(dout0_61) AT=1140.05n

* CHECK dout0_62 Vdout0_62ck113 = 1.8 time = 1140
.meas tran vdout0_62ck113 FIND v(dout0_62) AT=1140.05n

* CHECK dout0_63 Vdout0_63ck113 = 1.8 time = 1140
.meas tran vdout0_63ck113 FIND v(dout0_63) AT=1140.05n

* CHECK dout0_64 Vdout0_64ck113 = 0 time = 1140
.meas tran vdout0_64ck113 FIND v(dout0_64) AT=1140.05n

* CHECK dout0_0 Vdout0_0ck114 = 1.8 time = 1150
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=1150.05n

* CHECK dout0_1 Vdout0_1ck114 = 1.8 time = 1150
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=1150.05n

* CHECK dout0_2 Vdout0_2ck114 = 1.8 time = 1150
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=1150.05n

* CHECK dout0_3 Vdout0_3ck114 = 0 time = 1150
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=1150.05n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 1150
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=1150.05n

* CHECK dout0_5 Vdout0_5ck114 = 0 time = 1150
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=1150.05n

* CHECK dout0_6 Vdout0_6ck114 = 0 time = 1150
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=1150.05n

* CHECK dout0_7 Vdout0_7ck114 = 1.8 time = 1150
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=1150.05n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 1150
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=1150.05n

* CHECK dout0_9 Vdout0_9ck114 = 1.8 time = 1150
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=1150.05n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 1150
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=1150.05n

* CHECK dout0_11 Vdout0_11ck114 = 1.8 time = 1150
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=1150.05n

* CHECK dout0_12 Vdout0_12ck114 = 1.8 time = 1150
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=1150.05n

* CHECK dout0_13 Vdout0_13ck114 = 0 time = 1150
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=1150.05n

* CHECK dout0_14 Vdout0_14ck114 = 1.8 time = 1150
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=1150.05n

* CHECK dout0_15 Vdout0_15ck114 = 1.8 time = 1150
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=1150.05n

* CHECK dout0_16 Vdout0_16ck114 = 0 time = 1150
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=1150.05n

* CHECK dout0_17 Vdout0_17ck114 = 1.8 time = 1150
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=1150.05n

* CHECK dout0_18 Vdout0_18ck114 = 0 time = 1150
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=1150.05n

* CHECK dout0_19 Vdout0_19ck114 = 1.8 time = 1150
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=1150.05n

* CHECK dout0_20 Vdout0_20ck114 = 1.8 time = 1150
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=1150.05n

* CHECK dout0_21 Vdout0_21ck114 = 1.8 time = 1150
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=1150.05n

* CHECK dout0_22 Vdout0_22ck114 = 0 time = 1150
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=1150.05n

* CHECK dout0_23 Vdout0_23ck114 = 1.8 time = 1150
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=1150.05n

* CHECK dout0_24 Vdout0_24ck114 = 1.8 time = 1150
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=1150.05n

* CHECK dout0_25 Vdout0_25ck114 = 0 time = 1150
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=1150.05n

* CHECK dout0_26 Vdout0_26ck114 = 1.8 time = 1150
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=1150.05n

* CHECK dout0_27 Vdout0_27ck114 = 1.8 time = 1150
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=1150.05n

* CHECK dout0_28 Vdout0_28ck114 = 0 time = 1150
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=1150.05n

* CHECK dout0_29 Vdout0_29ck114 = 1.8 time = 1150
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=1150.05n

* CHECK dout0_30 Vdout0_30ck114 = 0 time = 1150
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=1150.05n

* CHECK dout0_31 Vdout0_31ck114 = 0 time = 1150
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=1150.05n

* CHECK dout0_32 Vdout0_32ck114 = 0 time = 1150
.meas tran vdout0_32ck114 FIND v(dout0_32) AT=1150.05n

* CHECK dout0_33 Vdout0_33ck114 = 0 time = 1150
.meas tran vdout0_33ck114 FIND v(dout0_33) AT=1150.05n

* CHECK dout0_34 Vdout0_34ck114 = 0 time = 1150
.meas tran vdout0_34ck114 FIND v(dout0_34) AT=1150.05n

* CHECK dout0_35 Vdout0_35ck114 = 1.8 time = 1150
.meas tran vdout0_35ck114 FIND v(dout0_35) AT=1150.05n

* CHECK dout0_36 Vdout0_36ck114 = 1.8 time = 1150
.meas tran vdout0_36ck114 FIND v(dout0_36) AT=1150.05n

* CHECK dout0_37 Vdout0_37ck114 = 1.8 time = 1150
.meas tran vdout0_37ck114 FIND v(dout0_37) AT=1150.05n

* CHECK dout0_38 Vdout0_38ck114 = 0 time = 1150
.meas tran vdout0_38ck114 FIND v(dout0_38) AT=1150.05n

* CHECK dout0_39 Vdout0_39ck114 = 0 time = 1150
.meas tran vdout0_39ck114 FIND v(dout0_39) AT=1150.05n

* CHECK dout0_40 Vdout0_40ck114 = 0 time = 1150
.meas tran vdout0_40ck114 FIND v(dout0_40) AT=1150.05n

* CHECK dout0_41 Vdout0_41ck114 = 0 time = 1150
.meas tran vdout0_41ck114 FIND v(dout0_41) AT=1150.05n

* CHECK dout0_42 Vdout0_42ck114 = 1.8 time = 1150
.meas tran vdout0_42ck114 FIND v(dout0_42) AT=1150.05n

* CHECK dout0_43 Vdout0_43ck114 = 0 time = 1150
.meas tran vdout0_43ck114 FIND v(dout0_43) AT=1150.05n

* CHECK dout0_44 Vdout0_44ck114 = 1.8 time = 1150
.meas tran vdout0_44ck114 FIND v(dout0_44) AT=1150.05n

* CHECK dout0_45 Vdout0_45ck114 = 0 time = 1150
.meas tran vdout0_45ck114 FIND v(dout0_45) AT=1150.05n

* CHECK dout0_46 Vdout0_46ck114 = 0 time = 1150
.meas tran vdout0_46ck114 FIND v(dout0_46) AT=1150.05n

* CHECK dout0_47 Vdout0_47ck114 = 0 time = 1150
.meas tran vdout0_47ck114 FIND v(dout0_47) AT=1150.05n

* CHECK dout0_48 Vdout0_48ck114 = 0 time = 1150
.meas tran vdout0_48ck114 FIND v(dout0_48) AT=1150.05n

* CHECK dout0_49 Vdout0_49ck114 = 0 time = 1150
.meas tran vdout0_49ck114 FIND v(dout0_49) AT=1150.05n

* CHECK dout0_50 Vdout0_50ck114 = 1.8 time = 1150
.meas tran vdout0_50ck114 FIND v(dout0_50) AT=1150.05n

* CHECK dout0_51 Vdout0_51ck114 = 0 time = 1150
.meas tran vdout0_51ck114 FIND v(dout0_51) AT=1150.05n

* CHECK dout0_52 Vdout0_52ck114 = 1.8 time = 1150
.meas tran vdout0_52ck114 FIND v(dout0_52) AT=1150.05n

* CHECK dout0_53 Vdout0_53ck114 = 0 time = 1150
.meas tran vdout0_53ck114 FIND v(dout0_53) AT=1150.05n

* CHECK dout0_54 Vdout0_54ck114 = 1.8 time = 1150
.meas tran vdout0_54ck114 FIND v(dout0_54) AT=1150.05n

* CHECK dout0_55 Vdout0_55ck114 = 0 time = 1150
.meas tran vdout0_55ck114 FIND v(dout0_55) AT=1150.05n

* CHECK dout0_56 Vdout0_56ck114 = 0 time = 1150
.meas tran vdout0_56ck114 FIND v(dout0_56) AT=1150.05n

* CHECK dout0_57 Vdout0_57ck114 = 0 time = 1150
.meas tran vdout0_57ck114 FIND v(dout0_57) AT=1150.05n

* CHECK dout0_58 Vdout0_58ck114 = 1.8 time = 1150
.meas tran vdout0_58ck114 FIND v(dout0_58) AT=1150.05n

* CHECK dout0_59 Vdout0_59ck114 = 1.8 time = 1150
.meas tran vdout0_59ck114 FIND v(dout0_59) AT=1150.05n

* CHECK dout0_60 Vdout0_60ck114 = 1.8 time = 1150
.meas tran vdout0_60ck114 FIND v(dout0_60) AT=1150.05n

* CHECK dout0_61 Vdout0_61ck114 = 0 time = 1150
.meas tran vdout0_61ck114 FIND v(dout0_61) AT=1150.05n

* CHECK dout0_62 Vdout0_62ck114 = 1.8 time = 1150
.meas tran vdout0_62ck114 FIND v(dout0_62) AT=1150.05n

* CHECK dout0_63 Vdout0_63ck114 = 1.8 time = 1150
.meas tran vdout0_63ck114 FIND v(dout0_63) AT=1150.05n

* CHECK dout0_64 Vdout0_64ck114 = 0 time = 1150
.meas tran vdout0_64ck114 FIND v(dout0_64) AT=1150.05n

* CHECK dout0_0 Vdout0_0ck116 = 1.8 time = 1170
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=1170.05n

* CHECK dout0_1 Vdout0_1ck116 = 1.8 time = 1170
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=1170.05n

* CHECK dout0_2 Vdout0_2ck116 = 0 time = 1170
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=1170.05n

* CHECK dout0_3 Vdout0_3ck116 = 0 time = 1170
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=1170.05n

* CHECK dout0_4 Vdout0_4ck116 = 1.8 time = 1170
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=1170.05n

* CHECK dout0_5 Vdout0_5ck116 = 1.8 time = 1170
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=1170.05n

* CHECK dout0_6 Vdout0_6ck116 = 0 time = 1170
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=1170.05n

* CHECK dout0_7 Vdout0_7ck116 = 1.8 time = 1170
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=1170.05n

* CHECK dout0_8 Vdout0_8ck116 = 1.8 time = 1170
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=1170.05n

* CHECK dout0_9 Vdout0_9ck116 = 1.8 time = 1170
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=1170.05n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 1170
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=1170.05n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 1170
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=1170.05n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 1170
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=1170.05n

* CHECK dout0_13 Vdout0_13ck116 = 1.8 time = 1170
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=1170.05n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 1170
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=1170.05n

* CHECK dout0_15 Vdout0_15ck116 = 1.8 time = 1170
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=1170.05n

* CHECK dout0_16 Vdout0_16ck116 = 1.8 time = 1170
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=1170.05n

* CHECK dout0_17 Vdout0_17ck116 = 1.8 time = 1170
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=1170.05n

* CHECK dout0_18 Vdout0_18ck116 = 1.8 time = 1170
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=1170.05n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 1170
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=1170.05n

* CHECK dout0_20 Vdout0_20ck116 = 1.8 time = 1170
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=1170.05n

* CHECK dout0_21 Vdout0_21ck116 = 0 time = 1170
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=1170.05n

* CHECK dout0_22 Vdout0_22ck116 = 1.8 time = 1170
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=1170.05n

* CHECK dout0_23 Vdout0_23ck116 = 0 time = 1170
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=1170.05n

* CHECK dout0_24 Vdout0_24ck116 = 0 time = 1170
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=1170.05n

* CHECK dout0_25 Vdout0_25ck116 = 1.8 time = 1170
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=1170.05n

* CHECK dout0_26 Vdout0_26ck116 = 0 time = 1170
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=1170.05n

* CHECK dout0_27 Vdout0_27ck116 = 0 time = 1170
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=1170.05n

* CHECK dout0_28 Vdout0_28ck116 = 0 time = 1170
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=1170.05n

* CHECK dout0_29 Vdout0_29ck116 = 0 time = 1170
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=1170.05n

* CHECK dout0_30 Vdout0_30ck116 = 0 time = 1170
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=1170.05n

* CHECK dout0_31 Vdout0_31ck116 = 1.8 time = 1170
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=1170.05n

* CHECK dout0_32 Vdout0_32ck116 = 0 time = 1170
.meas tran vdout0_32ck116 FIND v(dout0_32) AT=1170.05n

* CHECK dout0_33 Vdout0_33ck116 = 1.8 time = 1170
.meas tran vdout0_33ck116 FIND v(dout0_33) AT=1170.05n

* CHECK dout0_34 Vdout0_34ck116 = 0 time = 1170
.meas tran vdout0_34ck116 FIND v(dout0_34) AT=1170.05n

* CHECK dout0_35 Vdout0_35ck116 = 0 time = 1170
.meas tran vdout0_35ck116 FIND v(dout0_35) AT=1170.05n

* CHECK dout0_36 Vdout0_36ck116 = 0 time = 1170
.meas tran vdout0_36ck116 FIND v(dout0_36) AT=1170.05n

* CHECK dout0_37 Vdout0_37ck116 = 1.8 time = 1170
.meas tran vdout0_37ck116 FIND v(dout0_37) AT=1170.05n

* CHECK dout0_38 Vdout0_38ck116 = 1.8 time = 1170
.meas tran vdout0_38ck116 FIND v(dout0_38) AT=1170.05n

* CHECK dout0_39 Vdout0_39ck116 = 0 time = 1170
.meas tran vdout0_39ck116 FIND v(dout0_39) AT=1170.05n

* CHECK dout0_40 Vdout0_40ck116 = 1.8 time = 1170
.meas tran vdout0_40ck116 FIND v(dout0_40) AT=1170.05n

* CHECK dout0_41 Vdout0_41ck116 = 0 time = 1170
.meas tran vdout0_41ck116 FIND v(dout0_41) AT=1170.05n

* CHECK dout0_42 Vdout0_42ck116 = 1.8 time = 1170
.meas tran vdout0_42ck116 FIND v(dout0_42) AT=1170.05n

* CHECK dout0_43 Vdout0_43ck116 = 1.8 time = 1170
.meas tran vdout0_43ck116 FIND v(dout0_43) AT=1170.05n

* CHECK dout0_44 Vdout0_44ck116 = 0 time = 1170
.meas tran vdout0_44ck116 FIND v(dout0_44) AT=1170.05n

* CHECK dout0_45 Vdout0_45ck116 = 0 time = 1170
.meas tran vdout0_45ck116 FIND v(dout0_45) AT=1170.05n

* CHECK dout0_46 Vdout0_46ck116 = 0 time = 1170
.meas tran vdout0_46ck116 FIND v(dout0_46) AT=1170.05n

* CHECK dout0_47 Vdout0_47ck116 = 1.8 time = 1170
.meas tran vdout0_47ck116 FIND v(dout0_47) AT=1170.05n

* CHECK dout0_48 Vdout0_48ck116 = 1.8 time = 1170
.meas tran vdout0_48ck116 FIND v(dout0_48) AT=1170.05n

* CHECK dout0_49 Vdout0_49ck116 = 1.8 time = 1170
.meas tran vdout0_49ck116 FIND v(dout0_49) AT=1170.05n

* CHECK dout0_50 Vdout0_50ck116 = 0 time = 1170
.meas tran vdout0_50ck116 FIND v(dout0_50) AT=1170.05n

* CHECK dout0_51 Vdout0_51ck116 = 0 time = 1170
.meas tran vdout0_51ck116 FIND v(dout0_51) AT=1170.05n

* CHECK dout0_52 Vdout0_52ck116 = 0 time = 1170
.meas tran vdout0_52ck116 FIND v(dout0_52) AT=1170.05n

* CHECK dout0_53 Vdout0_53ck116 = 1.8 time = 1170
.meas tran vdout0_53ck116 FIND v(dout0_53) AT=1170.05n

* CHECK dout0_54 Vdout0_54ck116 = 0 time = 1170
.meas tran vdout0_54ck116 FIND v(dout0_54) AT=1170.05n

* CHECK dout0_55 Vdout0_55ck116 = 0 time = 1170
.meas tran vdout0_55ck116 FIND v(dout0_55) AT=1170.05n

* CHECK dout0_56 Vdout0_56ck116 = 1.8 time = 1170
.meas tran vdout0_56ck116 FIND v(dout0_56) AT=1170.05n

* CHECK dout0_57 Vdout0_57ck116 = 1.8 time = 1170
.meas tran vdout0_57ck116 FIND v(dout0_57) AT=1170.05n

* CHECK dout0_58 Vdout0_58ck116 = 0 time = 1170
.meas tran vdout0_58ck116 FIND v(dout0_58) AT=1170.05n

* CHECK dout0_59 Vdout0_59ck116 = 0 time = 1170
.meas tran vdout0_59ck116 FIND v(dout0_59) AT=1170.05n

* CHECK dout0_60 Vdout0_60ck116 = 1.8 time = 1170
.meas tran vdout0_60ck116 FIND v(dout0_60) AT=1170.05n

* CHECK dout0_61 Vdout0_61ck116 = 1.8 time = 1170
.meas tran vdout0_61ck116 FIND v(dout0_61) AT=1170.05n

* CHECK dout0_62 Vdout0_62ck116 = 1.8 time = 1170
.meas tran vdout0_62ck116 FIND v(dout0_62) AT=1170.05n

* CHECK dout0_63 Vdout0_63ck116 = 0 time = 1170
.meas tran vdout0_63ck116 FIND v(dout0_63) AT=1170.05n

* CHECK dout0_64 Vdout0_64ck116 = 0 time = 1170
.meas tran vdout0_64ck116 FIND v(dout0_64) AT=1170.05n

* CHECK dout0_0 Vdout0_0ck117 = 1.8 time = 1180
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=1180.05n

* CHECK dout0_1 Vdout0_1ck117 = 1.8 time = 1180
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=1180.05n

* CHECK dout0_2 Vdout0_2ck117 = 0 time = 1180
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=1180.05n

* CHECK dout0_3 Vdout0_3ck117 = 1.8 time = 1180
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=1180.05n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 1180
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=1180.05n

* CHECK dout0_5 Vdout0_5ck117 = 0 time = 1180
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=1180.05n

* CHECK dout0_6 Vdout0_6ck117 = 1.8 time = 1180
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=1180.05n

* CHECK dout0_7 Vdout0_7ck117 = 0 time = 1180
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=1180.05n

* CHECK dout0_8 Vdout0_8ck117 = 1.8 time = 1180
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=1180.05n

* CHECK dout0_9 Vdout0_9ck117 = 1.8 time = 1180
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=1180.05n

* CHECK dout0_10 Vdout0_10ck117 = 0 time = 1180
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=1180.05n

* CHECK dout0_11 Vdout0_11ck117 = 1.8 time = 1180
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=1180.05n

* CHECK dout0_12 Vdout0_12ck117 = 1.8 time = 1180
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=1180.05n

* CHECK dout0_13 Vdout0_13ck117 = 1.8 time = 1180
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=1180.05n

* CHECK dout0_14 Vdout0_14ck117 = 0 time = 1180
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=1180.05n

* CHECK dout0_15 Vdout0_15ck117 = 1.8 time = 1180
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=1180.05n

* CHECK dout0_16 Vdout0_16ck117 = 0 time = 1180
.meas tran vdout0_16ck117 FIND v(dout0_16) AT=1180.05n

* CHECK dout0_17 Vdout0_17ck117 = 1.8 time = 1180
.meas tran vdout0_17ck117 FIND v(dout0_17) AT=1180.05n

* CHECK dout0_18 Vdout0_18ck117 = 0 time = 1180
.meas tran vdout0_18ck117 FIND v(dout0_18) AT=1180.05n

* CHECK dout0_19 Vdout0_19ck117 = 1.8 time = 1180
.meas tran vdout0_19ck117 FIND v(dout0_19) AT=1180.05n

* CHECK dout0_20 Vdout0_20ck117 = 1.8 time = 1180
.meas tran vdout0_20ck117 FIND v(dout0_20) AT=1180.05n

* CHECK dout0_21 Vdout0_21ck117 = 0 time = 1180
.meas tran vdout0_21ck117 FIND v(dout0_21) AT=1180.05n

* CHECK dout0_22 Vdout0_22ck117 = 0 time = 1180
.meas tran vdout0_22ck117 FIND v(dout0_22) AT=1180.05n

* CHECK dout0_23 Vdout0_23ck117 = 0 time = 1180
.meas tran vdout0_23ck117 FIND v(dout0_23) AT=1180.05n

* CHECK dout0_24 Vdout0_24ck117 = 0 time = 1180
.meas tran vdout0_24ck117 FIND v(dout0_24) AT=1180.05n

* CHECK dout0_25 Vdout0_25ck117 = 1.8 time = 1180
.meas tran vdout0_25ck117 FIND v(dout0_25) AT=1180.05n

* CHECK dout0_26 Vdout0_26ck117 = 1.8 time = 1180
.meas tran vdout0_26ck117 FIND v(dout0_26) AT=1180.05n

* CHECK dout0_27 Vdout0_27ck117 = 1.8 time = 1180
.meas tran vdout0_27ck117 FIND v(dout0_27) AT=1180.05n

* CHECK dout0_28 Vdout0_28ck117 = 0 time = 1180
.meas tran vdout0_28ck117 FIND v(dout0_28) AT=1180.05n

* CHECK dout0_29 Vdout0_29ck117 = 1.8 time = 1180
.meas tran vdout0_29ck117 FIND v(dout0_29) AT=1180.05n

* CHECK dout0_30 Vdout0_30ck117 = 1.8 time = 1180
.meas tran vdout0_30ck117 FIND v(dout0_30) AT=1180.05n

* CHECK dout0_31 Vdout0_31ck117 = 0 time = 1180
.meas tran vdout0_31ck117 FIND v(dout0_31) AT=1180.05n

* CHECK dout0_32 Vdout0_32ck117 = 1.8 time = 1180
.meas tran vdout0_32ck117 FIND v(dout0_32) AT=1180.05n

* CHECK dout0_33 Vdout0_33ck117 = 1.8 time = 1180
.meas tran vdout0_33ck117 FIND v(dout0_33) AT=1180.05n

* CHECK dout0_34 Vdout0_34ck117 = 1.8 time = 1180
.meas tran vdout0_34ck117 FIND v(dout0_34) AT=1180.05n

* CHECK dout0_35 Vdout0_35ck117 = 0 time = 1180
.meas tran vdout0_35ck117 FIND v(dout0_35) AT=1180.05n

* CHECK dout0_36 Vdout0_36ck117 = 1.8 time = 1180
.meas tran vdout0_36ck117 FIND v(dout0_36) AT=1180.05n

* CHECK dout0_37 Vdout0_37ck117 = 1.8 time = 1180
.meas tran vdout0_37ck117 FIND v(dout0_37) AT=1180.05n

* CHECK dout0_38 Vdout0_38ck117 = 0 time = 1180
.meas tran vdout0_38ck117 FIND v(dout0_38) AT=1180.05n

* CHECK dout0_39 Vdout0_39ck117 = 0 time = 1180
.meas tran vdout0_39ck117 FIND v(dout0_39) AT=1180.05n

* CHECK dout0_40 Vdout0_40ck117 = 1.8 time = 1180
.meas tran vdout0_40ck117 FIND v(dout0_40) AT=1180.05n

* CHECK dout0_41 Vdout0_41ck117 = 1.8 time = 1180
.meas tran vdout0_41ck117 FIND v(dout0_41) AT=1180.05n

* CHECK dout0_42 Vdout0_42ck117 = 0 time = 1180
.meas tran vdout0_42ck117 FIND v(dout0_42) AT=1180.05n

* CHECK dout0_43 Vdout0_43ck117 = 1.8 time = 1180
.meas tran vdout0_43ck117 FIND v(dout0_43) AT=1180.05n

* CHECK dout0_44 Vdout0_44ck117 = 0 time = 1180
.meas tran vdout0_44ck117 FIND v(dout0_44) AT=1180.05n

* CHECK dout0_45 Vdout0_45ck117 = 0 time = 1180
.meas tran vdout0_45ck117 FIND v(dout0_45) AT=1180.05n

* CHECK dout0_46 Vdout0_46ck117 = 0 time = 1180
.meas tran vdout0_46ck117 FIND v(dout0_46) AT=1180.05n

* CHECK dout0_47 Vdout0_47ck117 = 0 time = 1180
.meas tran vdout0_47ck117 FIND v(dout0_47) AT=1180.05n

* CHECK dout0_48 Vdout0_48ck117 = 1.8 time = 1180
.meas tran vdout0_48ck117 FIND v(dout0_48) AT=1180.05n

* CHECK dout0_49 Vdout0_49ck117 = 1.8 time = 1180
.meas tran vdout0_49ck117 FIND v(dout0_49) AT=1180.05n

* CHECK dout0_50 Vdout0_50ck117 = 0 time = 1180
.meas tran vdout0_50ck117 FIND v(dout0_50) AT=1180.05n

* CHECK dout0_51 Vdout0_51ck117 = 1.8 time = 1180
.meas tran vdout0_51ck117 FIND v(dout0_51) AT=1180.05n

* CHECK dout0_52 Vdout0_52ck117 = 0 time = 1180
.meas tran vdout0_52ck117 FIND v(dout0_52) AT=1180.05n

* CHECK dout0_53 Vdout0_53ck117 = 0 time = 1180
.meas tran vdout0_53ck117 FIND v(dout0_53) AT=1180.05n

* CHECK dout0_54 Vdout0_54ck117 = 1.8 time = 1180
.meas tran vdout0_54ck117 FIND v(dout0_54) AT=1180.05n

* CHECK dout0_55 Vdout0_55ck117 = 0 time = 1180
.meas tran vdout0_55ck117 FIND v(dout0_55) AT=1180.05n

* CHECK dout0_56 Vdout0_56ck117 = 0 time = 1180
.meas tran vdout0_56ck117 FIND v(dout0_56) AT=1180.05n

* CHECK dout0_57 Vdout0_57ck117 = 1.8 time = 1180
.meas tran vdout0_57ck117 FIND v(dout0_57) AT=1180.05n

* CHECK dout0_58 Vdout0_58ck117 = 1.8 time = 1180
.meas tran vdout0_58ck117 FIND v(dout0_58) AT=1180.05n

* CHECK dout0_59 Vdout0_59ck117 = 1.8 time = 1180
.meas tran vdout0_59ck117 FIND v(dout0_59) AT=1180.05n

* CHECK dout0_60 Vdout0_60ck117 = 1.8 time = 1180
.meas tran vdout0_60ck117 FIND v(dout0_60) AT=1180.05n

* CHECK dout0_61 Vdout0_61ck117 = 1.8 time = 1180
.meas tran vdout0_61ck117 FIND v(dout0_61) AT=1180.05n

* CHECK dout0_62 Vdout0_62ck117 = 1.8 time = 1180
.meas tran vdout0_62ck117 FIND v(dout0_62) AT=1180.05n

* CHECK dout0_63 Vdout0_63ck117 = 1.8 time = 1180
.meas tran vdout0_63ck117 FIND v(dout0_63) AT=1180.05n

* CHECK dout0_64 Vdout0_64ck117 = 0 time = 1180
.meas tran vdout0_64ck117 FIND v(dout0_64) AT=1180.05n

* CHECK dout0_0 Vdout0_0ck119 = 1.8 time = 1200
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=1200.05n

* CHECK dout0_1 Vdout0_1ck119 = 1.8 time = 1200
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=1200.05n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 1200
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=1200.05n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 1200
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=1200.05n

* CHECK dout0_4 Vdout0_4ck119 = 1.8 time = 1200
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=1200.05n

* CHECK dout0_5 Vdout0_5ck119 = 1.8 time = 1200
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=1200.05n

* CHECK dout0_6 Vdout0_6ck119 = 0 time = 1200
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=1200.05n

* CHECK dout0_7 Vdout0_7ck119 = 1.8 time = 1200
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=1200.05n

* CHECK dout0_8 Vdout0_8ck119 = 1.8 time = 1200
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=1200.05n

* CHECK dout0_9 Vdout0_9ck119 = 1.8 time = 1200
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=1200.05n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 1200
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=1200.05n

* CHECK dout0_11 Vdout0_11ck119 = 1.8 time = 1200
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=1200.05n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 1200
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=1200.05n

* CHECK dout0_13 Vdout0_13ck119 = 1.8 time = 1200
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=1200.05n

* CHECK dout0_14 Vdout0_14ck119 = 0 time = 1200
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=1200.05n

* CHECK dout0_15 Vdout0_15ck119 = 1.8 time = 1200
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=1200.05n

* CHECK dout0_16 Vdout0_16ck119 = 1.8 time = 1200
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=1200.05n

* CHECK dout0_17 Vdout0_17ck119 = 1.8 time = 1200
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=1200.05n

* CHECK dout0_18 Vdout0_18ck119 = 1.8 time = 1200
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=1200.05n

* CHECK dout0_19 Vdout0_19ck119 = 0 time = 1200
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=1200.05n

* CHECK dout0_20 Vdout0_20ck119 = 1.8 time = 1200
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=1200.05n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 1200
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=1200.05n

* CHECK dout0_22 Vdout0_22ck119 = 1.8 time = 1200
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=1200.05n

* CHECK dout0_23 Vdout0_23ck119 = 0 time = 1200
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=1200.05n

* CHECK dout0_24 Vdout0_24ck119 = 0 time = 1200
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=1200.05n

* CHECK dout0_25 Vdout0_25ck119 = 1.8 time = 1200
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=1200.05n

* CHECK dout0_26 Vdout0_26ck119 = 0 time = 1200
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=1200.05n

* CHECK dout0_27 Vdout0_27ck119 = 0 time = 1200
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=1200.05n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 1200
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=1200.05n

* CHECK dout0_29 Vdout0_29ck119 = 0 time = 1200
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=1200.05n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 1200
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=1200.05n

* CHECK dout0_31 Vdout0_31ck119 = 1.8 time = 1200
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=1200.05n

* CHECK dout0_32 Vdout0_32ck119 = 0 time = 1200
.meas tran vdout0_32ck119 FIND v(dout0_32) AT=1200.05n

* CHECK dout0_33 Vdout0_33ck119 = 1.8 time = 1200
.meas tran vdout0_33ck119 FIND v(dout0_33) AT=1200.05n

* CHECK dout0_34 Vdout0_34ck119 = 0 time = 1200
.meas tran vdout0_34ck119 FIND v(dout0_34) AT=1200.05n

* CHECK dout0_35 Vdout0_35ck119 = 0 time = 1200
.meas tran vdout0_35ck119 FIND v(dout0_35) AT=1200.05n

* CHECK dout0_36 Vdout0_36ck119 = 0 time = 1200
.meas tran vdout0_36ck119 FIND v(dout0_36) AT=1200.05n

* CHECK dout0_37 Vdout0_37ck119 = 1.8 time = 1200
.meas tran vdout0_37ck119 FIND v(dout0_37) AT=1200.05n

* CHECK dout0_38 Vdout0_38ck119 = 1.8 time = 1200
.meas tran vdout0_38ck119 FIND v(dout0_38) AT=1200.05n

* CHECK dout0_39 Vdout0_39ck119 = 0 time = 1200
.meas tran vdout0_39ck119 FIND v(dout0_39) AT=1200.05n

* CHECK dout0_40 Vdout0_40ck119 = 1.8 time = 1200
.meas tran vdout0_40ck119 FIND v(dout0_40) AT=1200.05n

* CHECK dout0_41 Vdout0_41ck119 = 0 time = 1200
.meas tran vdout0_41ck119 FIND v(dout0_41) AT=1200.05n

* CHECK dout0_42 Vdout0_42ck119 = 1.8 time = 1200
.meas tran vdout0_42ck119 FIND v(dout0_42) AT=1200.05n

* CHECK dout0_43 Vdout0_43ck119 = 1.8 time = 1200
.meas tran vdout0_43ck119 FIND v(dout0_43) AT=1200.05n

* CHECK dout0_44 Vdout0_44ck119 = 0 time = 1200
.meas tran vdout0_44ck119 FIND v(dout0_44) AT=1200.05n

* CHECK dout0_45 Vdout0_45ck119 = 0 time = 1200
.meas tran vdout0_45ck119 FIND v(dout0_45) AT=1200.05n

* CHECK dout0_46 Vdout0_46ck119 = 0 time = 1200
.meas tran vdout0_46ck119 FIND v(dout0_46) AT=1200.05n

* CHECK dout0_47 Vdout0_47ck119 = 1.8 time = 1200
.meas tran vdout0_47ck119 FIND v(dout0_47) AT=1200.05n

* CHECK dout0_48 Vdout0_48ck119 = 1.8 time = 1200
.meas tran vdout0_48ck119 FIND v(dout0_48) AT=1200.05n

* CHECK dout0_49 Vdout0_49ck119 = 1.8 time = 1200
.meas tran vdout0_49ck119 FIND v(dout0_49) AT=1200.05n

* CHECK dout0_50 Vdout0_50ck119 = 0 time = 1200
.meas tran vdout0_50ck119 FIND v(dout0_50) AT=1200.05n

* CHECK dout0_51 Vdout0_51ck119 = 0 time = 1200
.meas tran vdout0_51ck119 FIND v(dout0_51) AT=1200.05n

* CHECK dout0_52 Vdout0_52ck119 = 0 time = 1200
.meas tran vdout0_52ck119 FIND v(dout0_52) AT=1200.05n

* CHECK dout0_53 Vdout0_53ck119 = 1.8 time = 1200
.meas tran vdout0_53ck119 FIND v(dout0_53) AT=1200.05n

* CHECK dout0_54 Vdout0_54ck119 = 0 time = 1200
.meas tran vdout0_54ck119 FIND v(dout0_54) AT=1200.05n

* CHECK dout0_55 Vdout0_55ck119 = 0 time = 1200
.meas tran vdout0_55ck119 FIND v(dout0_55) AT=1200.05n

* CHECK dout0_56 Vdout0_56ck119 = 1.8 time = 1200
.meas tran vdout0_56ck119 FIND v(dout0_56) AT=1200.05n

* CHECK dout0_57 Vdout0_57ck119 = 1.8 time = 1200
.meas tran vdout0_57ck119 FIND v(dout0_57) AT=1200.05n

* CHECK dout0_58 Vdout0_58ck119 = 0 time = 1200
.meas tran vdout0_58ck119 FIND v(dout0_58) AT=1200.05n

* CHECK dout0_59 Vdout0_59ck119 = 0 time = 1200
.meas tran vdout0_59ck119 FIND v(dout0_59) AT=1200.05n

* CHECK dout0_60 Vdout0_60ck119 = 1.8 time = 1200
.meas tran vdout0_60ck119 FIND v(dout0_60) AT=1200.05n

* CHECK dout0_61 Vdout0_61ck119 = 1.8 time = 1200
.meas tran vdout0_61ck119 FIND v(dout0_61) AT=1200.05n

* CHECK dout0_62 Vdout0_62ck119 = 1.8 time = 1200
.meas tran vdout0_62ck119 FIND v(dout0_62) AT=1200.05n

* CHECK dout0_63 Vdout0_63ck119 = 0 time = 1200
.meas tran vdout0_63ck119 FIND v(dout0_63) AT=1200.05n

* CHECK dout0_64 Vdout0_64ck119 = 0 time = 1200
.meas tran vdout0_64ck119 FIND v(dout0_64) AT=1200.05n

* CHECK dout0_0 Vdout0_0ck120 = 1.8 time = 1210
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=1210.05n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 1210
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=1210.05n

* CHECK dout0_2 Vdout0_2ck120 = 1.8 time = 1210
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=1210.05n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 1210
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=1210.05n

* CHECK dout0_4 Vdout0_4ck120 = 0 time = 1210
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=1210.05n

* CHECK dout0_5 Vdout0_5ck120 = 0 time = 1210
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=1210.05n

* CHECK dout0_6 Vdout0_6ck120 = 1.8 time = 1210
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=1210.05n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 1210
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=1210.05n

* CHECK dout0_8 Vdout0_8ck120 = 0 time = 1210
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=1210.05n

* CHECK dout0_9 Vdout0_9ck120 = 1.8 time = 1210
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=1210.05n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 1210
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=1210.05n

* CHECK dout0_11 Vdout0_11ck120 = 1.8 time = 1210
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=1210.05n

* CHECK dout0_12 Vdout0_12ck120 = 1.8 time = 1210
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=1210.05n

* CHECK dout0_13 Vdout0_13ck120 = 1.8 time = 1210
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=1210.05n

* CHECK dout0_14 Vdout0_14ck120 = 1.8 time = 1210
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=1210.05n

* CHECK dout0_15 Vdout0_15ck120 = 1.8 time = 1210
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=1210.05n

* CHECK dout0_16 Vdout0_16ck120 = 1.8 time = 1210
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=1210.05n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 1210
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=1210.05n

* CHECK dout0_18 Vdout0_18ck120 = 0 time = 1210
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=1210.05n

* CHECK dout0_19 Vdout0_19ck120 = 1.8 time = 1210
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=1210.05n

* CHECK dout0_20 Vdout0_20ck120 = 1.8 time = 1210
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=1210.05n

* CHECK dout0_21 Vdout0_21ck120 = 0 time = 1210
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=1210.05n

* CHECK dout0_22 Vdout0_22ck120 = 0 time = 1210
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=1210.05n

* CHECK dout0_23 Vdout0_23ck120 = 1.8 time = 1210
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=1210.05n

* CHECK dout0_24 Vdout0_24ck120 = 1.8 time = 1210
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=1210.05n

* CHECK dout0_25 Vdout0_25ck120 = 0 time = 1210
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=1210.05n

* CHECK dout0_26 Vdout0_26ck120 = 1.8 time = 1210
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=1210.05n

* CHECK dout0_27 Vdout0_27ck120 = 0 time = 1210
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=1210.05n

* CHECK dout0_28 Vdout0_28ck120 = 1.8 time = 1210
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=1210.05n

* CHECK dout0_29 Vdout0_29ck120 = 0 time = 1210
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=1210.05n

* CHECK dout0_30 Vdout0_30ck120 = 1.8 time = 1210
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=1210.05n

* CHECK dout0_31 Vdout0_31ck120 = 1.8 time = 1210
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=1210.05n

* CHECK dout0_32 Vdout0_32ck120 = 1.8 time = 1210
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=1210.05n

* CHECK dout0_33 Vdout0_33ck120 = 1.8 time = 1210
.meas tran vdout0_33ck120 FIND v(dout0_33) AT=1210.05n

* CHECK dout0_34 Vdout0_34ck120 = 0 time = 1210
.meas tran vdout0_34ck120 FIND v(dout0_34) AT=1210.05n

* CHECK dout0_35 Vdout0_35ck120 = 1.8 time = 1210
.meas tran vdout0_35ck120 FIND v(dout0_35) AT=1210.05n

* CHECK dout0_36 Vdout0_36ck120 = 1.8 time = 1210
.meas tran vdout0_36ck120 FIND v(dout0_36) AT=1210.05n

* CHECK dout0_37 Vdout0_37ck120 = 1.8 time = 1210
.meas tran vdout0_37ck120 FIND v(dout0_37) AT=1210.05n

* CHECK dout0_38 Vdout0_38ck120 = 0 time = 1210
.meas tran vdout0_38ck120 FIND v(dout0_38) AT=1210.05n

* CHECK dout0_39 Vdout0_39ck120 = 1.8 time = 1210
.meas tran vdout0_39ck120 FIND v(dout0_39) AT=1210.05n

* CHECK dout0_40 Vdout0_40ck120 = 0 time = 1210
.meas tran vdout0_40ck120 FIND v(dout0_40) AT=1210.05n

* CHECK dout0_41 Vdout0_41ck120 = 1.8 time = 1210
.meas tran vdout0_41ck120 FIND v(dout0_41) AT=1210.05n

* CHECK dout0_42 Vdout0_42ck120 = 1.8 time = 1210
.meas tran vdout0_42ck120 FIND v(dout0_42) AT=1210.05n

* CHECK dout0_43 Vdout0_43ck120 = 1.8 time = 1210
.meas tran vdout0_43ck120 FIND v(dout0_43) AT=1210.05n

* CHECK dout0_44 Vdout0_44ck120 = 1.8 time = 1210
.meas tran vdout0_44ck120 FIND v(dout0_44) AT=1210.05n

* CHECK dout0_45 Vdout0_45ck120 = 1.8 time = 1210
.meas tran vdout0_45ck120 FIND v(dout0_45) AT=1210.05n

* CHECK dout0_46 Vdout0_46ck120 = 0 time = 1210
.meas tran vdout0_46ck120 FIND v(dout0_46) AT=1210.05n

* CHECK dout0_47 Vdout0_47ck120 = 0 time = 1210
.meas tran vdout0_47ck120 FIND v(dout0_47) AT=1210.05n

* CHECK dout0_48 Vdout0_48ck120 = 0 time = 1210
.meas tran vdout0_48ck120 FIND v(dout0_48) AT=1210.05n

* CHECK dout0_49 Vdout0_49ck120 = 0 time = 1210
.meas tran vdout0_49ck120 FIND v(dout0_49) AT=1210.05n

* CHECK dout0_50 Vdout0_50ck120 = 1.8 time = 1210
.meas tran vdout0_50ck120 FIND v(dout0_50) AT=1210.05n

* CHECK dout0_51 Vdout0_51ck120 = 1.8 time = 1210
.meas tran vdout0_51ck120 FIND v(dout0_51) AT=1210.05n

* CHECK dout0_52 Vdout0_52ck120 = 0 time = 1210
.meas tran vdout0_52ck120 FIND v(dout0_52) AT=1210.05n

* CHECK dout0_53 Vdout0_53ck120 = 0 time = 1210
.meas tran vdout0_53ck120 FIND v(dout0_53) AT=1210.05n

* CHECK dout0_54 Vdout0_54ck120 = 1.8 time = 1210
.meas tran vdout0_54ck120 FIND v(dout0_54) AT=1210.05n

* CHECK dout0_55 Vdout0_55ck120 = 1.8 time = 1210
.meas tran vdout0_55ck120 FIND v(dout0_55) AT=1210.05n

* CHECK dout0_56 Vdout0_56ck120 = 1.8 time = 1210
.meas tran vdout0_56ck120 FIND v(dout0_56) AT=1210.05n

* CHECK dout0_57 Vdout0_57ck120 = 1.8 time = 1210
.meas tran vdout0_57ck120 FIND v(dout0_57) AT=1210.05n

* CHECK dout0_58 Vdout0_58ck120 = 0 time = 1210
.meas tran vdout0_58ck120 FIND v(dout0_58) AT=1210.05n

* CHECK dout0_59 Vdout0_59ck120 = 0 time = 1210
.meas tran vdout0_59ck120 FIND v(dout0_59) AT=1210.05n

* CHECK dout0_60 Vdout0_60ck120 = 0 time = 1210
.meas tran vdout0_60ck120 FIND v(dout0_60) AT=1210.05n

* CHECK dout0_61 Vdout0_61ck120 = 0 time = 1210
.meas tran vdout0_61ck120 FIND v(dout0_61) AT=1210.05n

* CHECK dout0_62 Vdout0_62ck120 = 1.8 time = 1210
.meas tran vdout0_62ck120 FIND v(dout0_62) AT=1210.05n

* CHECK dout0_63 Vdout0_63ck120 = 0 time = 1210
.meas tran vdout0_63ck120 FIND v(dout0_63) AT=1210.05n

* CHECK dout0_64 Vdout0_64ck120 = 0 time = 1210
.meas tran vdout0_64ck120 FIND v(dout0_64) AT=1210.05n

* CHECK dout0_0 Vdout0_0ck123 = 1.8 time = 1240
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=1240.05n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 1240
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=1240.05n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 1240
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=1240.05n

* CHECK dout0_3 Vdout0_3ck123 = 1.8 time = 1240
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=1240.05n

* CHECK dout0_4 Vdout0_4ck123 = 1.8 time = 1240
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=1240.05n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 1240
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=1240.05n

* CHECK dout0_6 Vdout0_6ck123 = 1.8 time = 1240
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=1240.05n

* CHECK dout0_7 Vdout0_7ck123 = 1.8 time = 1240
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=1240.05n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 1240
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=1240.05n

* CHECK dout0_9 Vdout0_9ck123 = 1.8 time = 1240
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=1240.05n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 1240
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=1240.05n

* CHECK dout0_11 Vdout0_11ck123 = 1.8 time = 1240
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=1240.05n

* CHECK dout0_12 Vdout0_12ck123 = 1.8 time = 1240
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=1240.05n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 1240
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=1240.05n

* CHECK dout0_14 Vdout0_14ck123 = 1.8 time = 1240
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=1240.05n

* CHECK dout0_15 Vdout0_15ck123 = 1.8 time = 1240
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=1240.05n

* CHECK dout0_16 Vdout0_16ck123 = 0 time = 1240
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=1240.05n

* CHECK dout0_17 Vdout0_17ck123 = 1.8 time = 1240
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=1240.05n

* CHECK dout0_18 Vdout0_18ck123 = 0 time = 1240
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=1240.05n

* CHECK dout0_19 Vdout0_19ck123 = 1.8 time = 1240
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=1240.05n

* CHECK dout0_20 Vdout0_20ck123 = 1.8 time = 1240
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=1240.05n

* CHECK dout0_21 Vdout0_21ck123 = 1.8 time = 1240
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=1240.05n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 1240
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=1240.05n

* CHECK dout0_23 Vdout0_23ck123 = 1.8 time = 1240
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=1240.05n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 1240
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=1240.05n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 1240
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=1240.05n

* CHECK dout0_26 Vdout0_26ck123 = 1.8 time = 1240
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=1240.05n

* CHECK dout0_27 Vdout0_27ck123 = 0 time = 1240
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=1240.05n

* CHECK dout0_28 Vdout0_28ck123 = 1.8 time = 1240
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=1240.05n

* CHECK dout0_29 Vdout0_29ck123 = 0 time = 1240
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=1240.05n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 1240
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=1240.05n

* CHECK dout0_31 Vdout0_31ck123 = 1.8 time = 1240
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=1240.05n

* CHECK dout0_32 Vdout0_32ck123 = 0 time = 1240
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=1240.05n

* CHECK dout0_33 Vdout0_33ck123 = 0 time = 1240
.meas tran vdout0_33ck123 FIND v(dout0_33) AT=1240.05n

* CHECK dout0_34 Vdout0_34ck123 = 0 time = 1240
.meas tran vdout0_34ck123 FIND v(dout0_34) AT=1240.05n

* CHECK dout0_35 Vdout0_35ck123 = 1.8 time = 1240
.meas tran vdout0_35ck123 FIND v(dout0_35) AT=1240.05n

* CHECK dout0_36 Vdout0_36ck123 = 1.8 time = 1240
.meas tran vdout0_36ck123 FIND v(dout0_36) AT=1240.05n

* CHECK dout0_37 Vdout0_37ck123 = 1.8 time = 1240
.meas tran vdout0_37ck123 FIND v(dout0_37) AT=1240.05n

* CHECK dout0_38 Vdout0_38ck123 = 0 time = 1240
.meas tran vdout0_38ck123 FIND v(dout0_38) AT=1240.05n

* CHECK dout0_39 Vdout0_39ck123 = 0 time = 1240
.meas tran vdout0_39ck123 FIND v(dout0_39) AT=1240.05n

* CHECK dout0_40 Vdout0_40ck123 = 0 time = 1240
.meas tran vdout0_40ck123 FIND v(dout0_40) AT=1240.05n

* CHECK dout0_41 Vdout0_41ck123 = 1.8 time = 1240
.meas tran vdout0_41ck123 FIND v(dout0_41) AT=1240.05n

* CHECK dout0_42 Vdout0_42ck123 = 0 time = 1240
.meas tran vdout0_42ck123 FIND v(dout0_42) AT=1240.05n

* CHECK dout0_43 Vdout0_43ck123 = 0 time = 1240
.meas tran vdout0_43ck123 FIND v(dout0_43) AT=1240.05n

* CHECK dout0_44 Vdout0_44ck123 = 0 time = 1240
.meas tran vdout0_44ck123 FIND v(dout0_44) AT=1240.05n

* CHECK dout0_45 Vdout0_45ck123 = 1.8 time = 1240
.meas tran vdout0_45ck123 FIND v(dout0_45) AT=1240.05n

* CHECK dout0_46 Vdout0_46ck123 = 1.8 time = 1240
.meas tran vdout0_46ck123 FIND v(dout0_46) AT=1240.05n

* CHECK dout0_47 Vdout0_47ck123 = 0 time = 1240
.meas tran vdout0_47ck123 FIND v(dout0_47) AT=1240.05n

* CHECK dout0_48 Vdout0_48ck123 = 1.8 time = 1240
.meas tran vdout0_48ck123 FIND v(dout0_48) AT=1240.05n

* CHECK dout0_49 Vdout0_49ck123 = 1.8 time = 1240
.meas tran vdout0_49ck123 FIND v(dout0_49) AT=1240.05n

* CHECK dout0_50 Vdout0_50ck123 = 1.8 time = 1240
.meas tran vdout0_50ck123 FIND v(dout0_50) AT=1240.05n

* CHECK dout0_51 Vdout0_51ck123 = 0 time = 1240
.meas tran vdout0_51ck123 FIND v(dout0_51) AT=1240.05n

* CHECK dout0_52 Vdout0_52ck123 = 0 time = 1240
.meas tran vdout0_52ck123 FIND v(dout0_52) AT=1240.05n

* CHECK dout0_53 Vdout0_53ck123 = 1.8 time = 1240
.meas tran vdout0_53ck123 FIND v(dout0_53) AT=1240.05n

* CHECK dout0_54 Vdout0_54ck123 = 1.8 time = 1240
.meas tran vdout0_54ck123 FIND v(dout0_54) AT=1240.05n

* CHECK dout0_55 Vdout0_55ck123 = 1.8 time = 1240
.meas tran vdout0_55ck123 FIND v(dout0_55) AT=1240.05n

* CHECK dout0_56 Vdout0_56ck123 = 0 time = 1240
.meas tran vdout0_56ck123 FIND v(dout0_56) AT=1240.05n

* CHECK dout0_57 Vdout0_57ck123 = 0 time = 1240
.meas tran vdout0_57ck123 FIND v(dout0_57) AT=1240.05n

* CHECK dout0_58 Vdout0_58ck123 = 1.8 time = 1240
.meas tran vdout0_58ck123 FIND v(dout0_58) AT=1240.05n

* CHECK dout0_59 Vdout0_59ck123 = 1.8 time = 1240
.meas tran vdout0_59ck123 FIND v(dout0_59) AT=1240.05n

* CHECK dout0_60 Vdout0_60ck123 = 1.8 time = 1240
.meas tran vdout0_60ck123 FIND v(dout0_60) AT=1240.05n

* CHECK dout0_61 Vdout0_61ck123 = 0 time = 1240
.meas tran vdout0_61ck123 FIND v(dout0_61) AT=1240.05n

* CHECK dout0_62 Vdout0_62ck123 = 1.8 time = 1240
.meas tran vdout0_62ck123 FIND v(dout0_62) AT=1240.05n

* CHECK dout0_63 Vdout0_63ck123 = 1.8 time = 1240
.meas tran vdout0_63ck123 FIND v(dout0_63) AT=1240.05n

* CHECK dout0_64 Vdout0_64ck123 = 0 time = 1240
.meas tran vdout0_64ck123 FIND v(dout0_64) AT=1240.05n

* CHECK dout0_0 Vdout0_0ck124 = 1.8 time = 1250
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=1250.05n

* CHECK dout0_1 Vdout0_1ck124 = 1.8 time = 1250
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=1250.05n

* CHECK dout0_2 Vdout0_2ck124 = 0 time = 1250
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=1250.05n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 1250
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=1250.05n

* CHECK dout0_4 Vdout0_4ck124 = 1.8 time = 1250
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=1250.05n

* CHECK dout0_5 Vdout0_5ck124 = 1.8 time = 1250
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=1250.05n

* CHECK dout0_6 Vdout0_6ck124 = 0 time = 1250
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=1250.05n

* CHECK dout0_7 Vdout0_7ck124 = 1.8 time = 1250
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=1250.05n

* CHECK dout0_8 Vdout0_8ck124 = 1.8 time = 1250
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=1250.05n

* CHECK dout0_9 Vdout0_9ck124 = 1.8 time = 1250
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=1250.05n

* CHECK dout0_10 Vdout0_10ck124 = 0 time = 1250
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=1250.05n

* CHECK dout0_11 Vdout0_11ck124 = 1.8 time = 1250
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=1250.05n

* CHECK dout0_12 Vdout0_12ck124 = 0 time = 1250
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=1250.05n

* CHECK dout0_13 Vdout0_13ck124 = 1.8 time = 1250
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=1250.05n

* CHECK dout0_14 Vdout0_14ck124 = 0 time = 1250
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=1250.05n

* CHECK dout0_15 Vdout0_15ck124 = 1.8 time = 1250
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=1250.05n

* CHECK dout0_16 Vdout0_16ck124 = 1.8 time = 1250
.meas tran vdout0_16ck124 FIND v(dout0_16) AT=1250.05n

* CHECK dout0_17 Vdout0_17ck124 = 1.8 time = 1250
.meas tran vdout0_17ck124 FIND v(dout0_17) AT=1250.05n

* CHECK dout0_18 Vdout0_18ck124 = 1.8 time = 1250
.meas tran vdout0_18ck124 FIND v(dout0_18) AT=1250.05n

* CHECK dout0_19 Vdout0_19ck124 = 0 time = 1250
.meas tran vdout0_19ck124 FIND v(dout0_19) AT=1250.05n

* CHECK dout0_20 Vdout0_20ck124 = 1.8 time = 1250
.meas tran vdout0_20ck124 FIND v(dout0_20) AT=1250.05n

* CHECK dout0_21 Vdout0_21ck124 = 0 time = 1250
.meas tran vdout0_21ck124 FIND v(dout0_21) AT=1250.05n

* CHECK dout0_22 Vdout0_22ck124 = 1.8 time = 1250
.meas tran vdout0_22ck124 FIND v(dout0_22) AT=1250.05n

* CHECK dout0_23 Vdout0_23ck124 = 0 time = 1250
.meas tran vdout0_23ck124 FIND v(dout0_23) AT=1250.05n

* CHECK dout0_24 Vdout0_24ck124 = 0 time = 1250
.meas tran vdout0_24ck124 FIND v(dout0_24) AT=1250.05n

* CHECK dout0_25 Vdout0_25ck124 = 1.8 time = 1250
.meas tran vdout0_25ck124 FIND v(dout0_25) AT=1250.05n

* CHECK dout0_26 Vdout0_26ck124 = 0 time = 1250
.meas tran vdout0_26ck124 FIND v(dout0_26) AT=1250.05n

* CHECK dout0_27 Vdout0_27ck124 = 0 time = 1250
.meas tran vdout0_27ck124 FIND v(dout0_27) AT=1250.05n

* CHECK dout0_28 Vdout0_28ck124 = 0 time = 1250
.meas tran vdout0_28ck124 FIND v(dout0_28) AT=1250.05n

* CHECK dout0_29 Vdout0_29ck124 = 0 time = 1250
.meas tran vdout0_29ck124 FIND v(dout0_29) AT=1250.05n

* CHECK dout0_30 Vdout0_30ck124 = 0 time = 1250
.meas tran vdout0_30ck124 FIND v(dout0_30) AT=1250.05n

* CHECK dout0_31 Vdout0_31ck124 = 1.8 time = 1250
.meas tran vdout0_31ck124 FIND v(dout0_31) AT=1250.05n

* CHECK dout0_32 Vdout0_32ck124 = 0 time = 1250
.meas tran vdout0_32ck124 FIND v(dout0_32) AT=1250.05n

* CHECK dout0_33 Vdout0_33ck124 = 1.8 time = 1250
.meas tran vdout0_33ck124 FIND v(dout0_33) AT=1250.05n

* CHECK dout0_34 Vdout0_34ck124 = 0 time = 1250
.meas tran vdout0_34ck124 FIND v(dout0_34) AT=1250.05n

* CHECK dout0_35 Vdout0_35ck124 = 0 time = 1250
.meas tran vdout0_35ck124 FIND v(dout0_35) AT=1250.05n

* CHECK dout0_36 Vdout0_36ck124 = 0 time = 1250
.meas tran vdout0_36ck124 FIND v(dout0_36) AT=1250.05n

* CHECK dout0_37 Vdout0_37ck124 = 1.8 time = 1250
.meas tran vdout0_37ck124 FIND v(dout0_37) AT=1250.05n

* CHECK dout0_38 Vdout0_38ck124 = 1.8 time = 1250
.meas tran vdout0_38ck124 FIND v(dout0_38) AT=1250.05n

* CHECK dout0_39 Vdout0_39ck124 = 0 time = 1250
.meas tran vdout0_39ck124 FIND v(dout0_39) AT=1250.05n

* CHECK dout0_40 Vdout0_40ck124 = 1.8 time = 1250
.meas tran vdout0_40ck124 FIND v(dout0_40) AT=1250.05n

* CHECK dout0_41 Vdout0_41ck124 = 0 time = 1250
.meas tran vdout0_41ck124 FIND v(dout0_41) AT=1250.05n

* CHECK dout0_42 Vdout0_42ck124 = 1.8 time = 1250
.meas tran vdout0_42ck124 FIND v(dout0_42) AT=1250.05n

* CHECK dout0_43 Vdout0_43ck124 = 1.8 time = 1250
.meas tran vdout0_43ck124 FIND v(dout0_43) AT=1250.05n

* CHECK dout0_44 Vdout0_44ck124 = 0 time = 1250
.meas tran vdout0_44ck124 FIND v(dout0_44) AT=1250.05n

* CHECK dout0_45 Vdout0_45ck124 = 0 time = 1250
.meas tran vdout0_45ck124 FIND v(dout0_45) AT=1250.05n

* CHECK dout0_46 Vdout0_46ck124 = 0 time = 1250
.meas tran vdout0_46ck124 FIND v(dout0_46) AT=1250.05n

* CHECK dout0_47 Vdout0_47ck124 = 1.8 time = 1250
.meas tran vdout0_47ck124 FIND v(dout0_47) AT=1250.05n

* CHECK dout0_48 Vdout0_48ck124 = 1.8 time = 1250
.meas tran vdout0_48ck124 FIND v(dout0_48) AT=1250.05n

* CHECK dout0_49 Vdout0_49ck124 = 1.8 time = 1250
.meas tran vdout0_49ck124 FIND v(dout0_49) AT=1250.05n

* CHECK dout0_50 Vdout0_50ck124 = 0 time = 1250
.meas tran vdout0_50ck124 FIND v(dout0_50) AT=1250.05n

* CHECK dout0_51 Vdout0_51ck124 = 0 time = 1250
.meas tran vdout0_51ck124 FIND v(dout0_51) AT=1250.05n

* CHECK dout0_52 Vdout0_52ck124 = 0 time = 1250
.meas tran vdout0_52ck124 FIND v(dout0_52) AT=1250.05n

* CHECK dout0_53 Vdout0_53ck124 = 1.8 time = 1250
.meas tran vdout0_53ck124 FIND v(dout0_53) AT=1250.05n

* CHECK dout0_54 Vdout0_54ck124 = 0 time = 1250
.meas tran vdout0_54ck124 FIND v(dout0_54) AT=1250.05n

* CHECK dout0_55 Vdout0_55ck124 = 0 time = 1250
.meas tran vdout0_55ck124 FIND v(dout0_55) AT=1250.05n

* CHECK dout0_56 Vdout0_56ck124 = 1.8 time = 1250
.meas tran vdout0_56ck124 FIND v(dout0_56) AT=1250.05n

* CHECK dout0_57 Vdout0_57ck124 = 1.8 time = 1250
.meas tran vdout0_57ck124 FIND v(dout0_57) AT=1250.05n

* CHECK dout0_58 Vdout0_58ck124 = 0 time = 1250
.meas tran vdout0_58ck124 FIND v(dout0_58) AT=1250.05n

* CHECK dout0_59 Vdout0_59ck124 = 0 time = 1250
.meas tran vdout0_59ck124 FIND v(dout0_59) AT=1250.05n

* CHECK dout0_60 Vdout0_60ck124 = 1.8 time = 1250
.meas tran vdout0_60ck124 FIND v(dout0_60) AT=1250.05n

* CHECK dout0_61 Vdout0_61ck124 = 1.8 time = 1250
.meas tran vdout0_61ck124 FIND v(dout0_61) AT=1250.05n

* CHECK dout0_62 Vdout0_62ck124 = 1.8 time = 1250
.meas tran vdout0_62ck124 FIND v(dout0_62) AT=1250.05n

* CHECK dout0_63 Vdout0_63ck124 = 0 time = 1250
.meas tran vdout0_63ck124 FIND v(dout0_63) AT=1250.05n

* CHECK dout0_64 Vdout0_64ck124 = 0 time = 1250
.meas tran vdout0_64ck124 FIND v(dout0_64) AT=1250.05n

* CHECK dout0_0 Vdout0_0ck125 = 1.8 time = 1260
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=1260.05n

* CHECK dout0_1 Vdout0_1ck125 = 1.8 time = 1260
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=1260.05n

* CHECK dout0_2 Vdout0_2ck125 = 0 time = 1260
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=1260.05n

* CHECK dout0_3 Vdout0_3ck125 = 1.8 time = 1260
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=1260.05n

* CHECK dout0_4 Vdout0_4ck125 = 1.8 time = 1260
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=1260.05n

* CHECK dout0_5 Vdout0_5ck125 = 1.8 time = 1260
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=1260.05n

* CHECK dout0_6 Vdout0_6ck125 = 1.8 time = 1260
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=1260.05n

* CHECK dout0_7 Vdout0_7ck125 = 1.8 time = 1260
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=1260.05n

* CHECK dout0_8 Vdout0_8ck125 = 1.8 time = 1260
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=1260.05n

* CHECK dout0_9 Vdout0_9ck125 = 0 time = 1260
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=1260.05n

* CHECK dout0_10 Vdout0_10ck125 = 1.8 time = 1260
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=1260.05n

* CHECK dout0_11 Vdout0_11ck125 = 1.8 time = 1260
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=1260.05n

* CHECK dout0_12 Vdout0_12ck125 = 0 time = 1260
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=1260.05n

* CHECK dout0_13 Vdout0_13ck125 = 0 time = 1260
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=1260.05n

* CHECK dout0_14 Vdout0_14ck125 = 1.8 time = 1260
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=1260.05n

* CHECK dout0_15 Vdout0_15ck125 = 1.8 time = 1260
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=1260.05n

* CHECK dout0_16 Vdout0_16ck125 = 0 time = 1260
.meas tran vdout0_16ck125 FIND v(dout0_16) AT=1260.05n

* CHECK dout0_17 Vdout0_17ck125 = 0 time = 1260
.meas tran vdout0_17ck125 FIND v(dout0_17) AT=1260.05n

* CHECK dout0_18 Vdout0_18ck125 = 1.8 time = 1260
.meas tran vdout0_18ck125 FIND v(dout0_18) AT=1260.05n

* CHECK dout0_19 Vdout0_19ck125 = 1.8 time = 1260
.meas tran vdout0_19ck125 FIND v(dout0_19) AT=1260.05n

* CHECK dout0_20 Vdout0_20ck125 = 0 time = 1260
.meas tran vdout0_20ck125 FIND v(dout0_20) AT=1260.05n

* CHECK dout0_21 Vdout0_21ck125 = 0 time = 1260
.meas tran vdout0_21ck125 FIND v(dout0_21) AT=1260.05n

* CHECK dout0_22 Vdout0_22ck125 = 1.8 time = 1260
.meas tran vdout0_22ck125 FIND v(dout0_22) AT=1260.05n

* CHECK dout0_23 Vdout0_23ck125 = 0 time = 1260
.meas tran vdout0_23ck125 FIND v(dout0_23) AT=1260.05n

* CHECK dout0_24 Vdout0_24ck125 = 0 time = 1260
.meas tran vdout0_24ck125 FIND v(dout0_24) AT=1260.05n

* CHECK dout0_25 Vdout0_25ck125 = 0 time = 1260
.meas tran vdout0_25ck125 FIND v(dout0_25) AT=1260.05n

* CHECK dout0_26 Vdout0_26ck125 = 1.8 time = 1260
.meas tran vdout0_26ck125 FIND v(dout0_26) AT=1260.05n

* CHECK dout0_27 Vdout0_27ck125 = 0 time = 1260
.meas tran vdout0_27ck125 FIND v(dout0_27) AT=1260.05n

* CHECK dout0_28 Vdout0_28ck125 = 1.8 time = 1260
.meas tran vdout0_28ck125 FIND v(dout0_28) AT=1260.05n

* CHECK dout0_29 Vdout0_29ck125 = 0 time = 1260
.meas tran vdout0_29ck125 FIND v(dout0_29) AT=1260.05n

* CHECK dout0_30 Vdout0_30ck125 = 0 time = 1260
.meas tran vdout0_30ck125 FIND v(dout0_30) AT=1260.05n

* CHECK dout0_31 Vdout0_31ck125 = 1.8 time = 1260
.meas tran vdout0_31ck125 FIND v(dout0_31) AT=1260.05n

* CHECK dout0_32 Vdout0_32ck125 = 1.8 time = 1260
.meas tran vdout0_32ck125 FIND v(dout0_32) AT=1260.05n

* CHECK dout0_33 Vdout0_33ck125 = 1.8 time = 1260
.meas tran vdout0_33ck125 FIND v(dout0_33) AT=1260.05n

* CHECK dout0_34 Vdout0_34ck125 = 1.8 time = 1260
.meas tran vdout0_34ck125 FIND v(dout0_34) AT=1260.05n

* CHECK dout0_35 Vdout0_35ck125 = 0 time = 1260
.meas tran vdout0_35ck125 FIND v(dout0_35) AT=1260.05n

* CHECK dout0_36 Vdout0_36ck125 = 0 time = 1260
.meas tran vdout0_36ck125 FIND v(dout0_36) AT=1260.05n

* CHECK dout0_37 Vdout0_37ck125 = 1.8 time = 1260
.meas tran vdout0_37ck125 FIND v(dout0_37) AT=1260.05n

* CHECK dout0_38 Vdout0_38ck125 = 0 time = 1260
.meas tran vdout0_38ck125 FIND v(dout0_38) AT=1260.05n

* CHECK dout0_39 Vdout0_39ck125 = 0 time = 1260
.meas tran vdout0_39ck125 FIND v(dout0_39) AT=1260.05n

* CHECK dout0_40 Vdout0_40ck125 = 0 time = 1260
.meas tran vdout0_40ck125 FIND v(dout0_40) AT=1260.05n

* CHECK dout0_41 Vdout0_41ck125 = 0 time = 1260
.meas tran vdout0_41ck125 FIND v(dout0_41) AT=1260.05n

* CHECK dout0_42 Vdout0_42ck125 = 1.8 time = 1260
.meas tran vdout0_42ck125 FIND v(dout0_42) AT=1260.05n

* CHECK dout0_43 Vdout0_43ck125 = 1.8 time = 1260
.meas tran vdout0_43ck125 FIND v(dout0_43) AT=1260.05n

* CHECK dout0_44 Vdout0_44ck125 = 0 time = 1260
.meas tran vdout0_44ck125 FIND v(dout0_44) AT=1260.05n

* CHECK dout0_45 Vdout0_45ck125 = 1.8 time = 1260
.meas tran vdout0_45ck125 FIND v(dout0_45) AT=1260.05n

* CHECK dout0_46 Vdout0_46ck125 = 1.8 time = 1260
.meas tran vdout0_46ck125 FIND v(dout0_46) AT=1260.05n

* CHECK dout0_47 Vdout0_47ck125 = 1.8 time = 1260
.meas tran vdout0_47ck125 FIND v(dout0_47) AT=1260.05n

* CHECK dout0_48 Vdout0_48ck125 = 1.8 time = 1260
.meas tran vdout0_48ck125 FIND v(dout0_48) AT=1260.05n

* CHECK dout0_49 Vdout0_49ck125 = 1.8 time = 1260
.meas tran vdout0_49ck125 FIND v(dout0_49) AT=1260.05n

* CHECK dout0_50 Vdout0_50ck125 = 1.8 time = 1260
.meas tran vdout0_50ck125 FIND v(dout0_50) AT=1260.05n

* CHECK dout0_51 Vdout0_51ck125 = 1.8 time = 1260
.meas tran vdout0_51ck125 FIND v(dout0_51) AT=1260.05n

* CHECK dout0_52 Vdout0_52ck125 = 0 time = 1260
.meas tran vdout0_52ck125 FIND v(dout0_52) AT=1260.05n

* CHECK dout0_53 Vdout0_53ck125 = 0 time = 1260
.meas tran vdout0_53ck125 FIND v(dout0_53) AT=1260.05n

* CHECK dout0_54 Vdout0_54ck125 = 1.8 time = 1260
.meas tran vdout0_54ck125 FIND v(dout0_54) AT=1260.05n

* CHECK dout0_55 Vdout0_55ck125 = 1.8 time = 1260
.meas tran vdout0_55ck125 FIND v(dout0_55) AT=1260.05n

* CHECK dout0_56 Vdout0_56ck125 = 1.8 time = 1260
.meas tran vdout0_56ck125 FIND v(dout0_56) AT=1260.05n

* CHECK dout0_57 Vdout0_57ck125 = 1.8 time = 1260
.meas tran vdout0_57ck125 FIND v(dout0_57) AT=1260.05n

* CHECK dout0_58 Vdout0_58ck125 = 0 time = 1260
.meas tran vdout0_58ck125 FIND v(dout0_58) AT=1260.05n

* CHECK dout0_59 Vdout0_59ck125 = 1.8 time = 1260
.meas tran vdout0_59ck125 FIND v(dout0_59) AT=1260.05n

* CHECK dout0_60 Vdout0_60ck125 = 1.8 time = 1260
.meas tran vdout0_60ck125 FIND v(dout0_60) AT=1260.05n

* CHECK dout0_61 Vdout0_61ck125 = 0 time = 1260
.meas tran vdout0_61ck125 FIND v(dout0_61) AT=1260.05n

* CHECK dout0_62 Vdout0_62ck125 = 1.8 time = 1260
.meas tran vdout0_62ck125 FIND v(dout0_62) AT=1260.05n

* CHECK dout0_63 Vdout0_63ck125 = 1.8 time = 1260
.meas tran vdout0_63ck125 FIND v(dout0_63) AT=1260.05n

* CHECK dout0_64 Vdout0_64ck125 = 0 time = 1260
.meas tran vdout0_64ck125 FIND v(dout0_64) AT=1260.05n

* CHECK dout0_0 Vdout0_0ck129 = 0 time = 1300
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=1300.05n

* CHECK dout0_1 Vdout0_1ck129 = 0 time = 1300
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=1300.05n

* CHECK dout0_2 Vdout0_2ck129 = 0 time = 1300
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=1300.05n

* CHECK dout0_3 Vdout0_3ck129 = 0 time = 1300
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=1300.05n

* CHECK dout0_4 Vdout0_4ck129 = 1.8 time = 1300
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=1300.05n

* CHECK dout0_5 Vdout0_5ck129 = 1.8 time = 1300
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=1300.05n

* CHECK dout0_6 Vdout0_6ck129 = 1.8 time = 1300
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=1300.05n

* CHECK dout0_7 Vdout0_7ck129 = 1.8 time = 1300
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=1300.05n

* CHECK dout0_8 Vdout0_8ck129 = 0 time = 1300
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=1300.05n

* CHECK dout0_9 Vdout0_9ck129 = 1.8 time = 1300
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=1300.05n

* CHECK dout0_10 Vdout0_10ck129 = 1.8 time = 1300
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=1300.05n

* CHECK dout0_11 Vdout0_11ck129 = 1.8 time = 1300
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=1300.05n

* CHECK dout0_12 Vdout0_12ck129 = 0 time = 1300
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=1300.05n

* CHECK dout0_13 Vdout0_13ck129 = 0 time = 1300
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=1300.05n

* CHECK dout0_14 Vdout0_14ck129 = 1.8 time = 1300
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=1300.05n

* CHECK dout0_15 Vdout0_15ck129 = 0 time = 1300
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=1300.05n

* CHECK dout0_16 Vdout0_16ck129 = 0 time = 1300
.meas tran vdout0_16ck129 FIND v(dout0_16) AT=1300.05n

* CHECK dout0_17 Vdout0_17ck129 = 0 time = 1300
.meas tran vdout0_17ck129 FIND v(dout0_17) AT=1300.05n

* CHECK dout0_18 Vdout0_18ck129 = 0 time = 1300
.meas tran vdout0_18ck129 FIND v(dout0_18) AT=1300.05n

* CHECK dout0_19 Vdout0_19ck129 = 0 time = 1300
.meas tran vdout0_19ck129 FIND v(dout0_19) AT=1300.05n

* CHECK dout0_20 Vdout0_20ck129 = 0 time = 1300
.meas tran vdout0_20ck129 FIND v(dout0_20) AT=1300.05n

* CHECK dout0_21 Vdout0_21ck129 = 1.8 time = 1300
.meas tran vdout0_21ck129 FIND v(dout0_21) AT=1300.05n

* CHECK dout0_22 Vdout0_22ck129 = 1.8 time = 1300
.meas tran vdout0_22ck129 FIND v(dout0_22) AT=1300.05n

* CHECK dout0_23 Vdout0_23ck129 = 0 time = 1300
.meas tran vdout0_23ck129 FIND v(dout0_23) AT=1300.05n

* CHECK dout0_24 Vdout0_24ck129 = 0 time = 1300
.meas tran vdout0_24ck129 FIND v(dout0_24) AT=1300.05n

* CHECK dout0_25 Vdout0_25ck129 = 0 time = 1300
.meas tran vdout0_25ck129 FIND v(dout0_25) AT=1300.05n

* CHECK dout0_26 Vdout0_26ck129 = 0 time = 1300
.meas tran vdout0_26ck129 FIND v(dout0_26) AT=1300.05n

* CHECK dout0_27 Vdout0_27ck129 = 1.8 time = 1300
.meas tran vdout0_27ck129 FIND v(dout0_27) AT=1300.05n

* CHECK dout0_28 Vdout0_28ck129 = 1.8 time = 1300
.meas tran vdout0_28ck129 FIND v(dout0_28) AT=1300.05n

* CHECK dout0_29 Vdout0_29ck129 = 1.8 time = 1300
.meas tran vdout0_29ck129 FIND v(dout0_29) AT=1300.05n

* CHECK dout0_30 Vdout0_30ck129 = 0 time = 1300
.meas tran vdout0_30ck129 FIND v(dout0_30) AT=1300.05n

* CHECK dout0_31 Vdout0_31ck129 = 0 time = 1300
.meas tran vdout0_31ck129 FIND v(dout0_31) AT=1300.05n

* CHECK dout0_32 Vdout0_32ck129 = 0 time = 1300
.meas tran vdout0_32ck129 FIND v(dout0_32) AT=1300.05n

* CHECK dout0_33 Vdout0_33ck129 = 1.8 time = 1300
.meas tran vdout0_33ck129 FIND v(dout0_33) AT=1300.05n

* CHECK dout0_34 Vdout0_34ck129 = 1.8 time = 1300
.meas tran vdout0_34ck129 FIND v(dout0_34) AT=1300.05n

* CHECK dout0_35 Vdout0_35ck129 = 0 time = 1300
.meas tran vdout0_35ck129 FIND v(dout0_35) AT=1300.05n

* CHECK dout0_36 Vdout0_36ck129 = 0 time = 1300
.meas tran vdout0_36ck129 FIND v(dout0_36) AT=1300.05n

* CHECK dout0_37 Vdout0_37ck129 = 1.8 time = 1300
.meas tran vdout0_37ck129 FIND v(dout0_37) AT=1300.05n

* CHECK dout0_38 Vdout0_38ck129 = 0 time = 1300
.meas tran vdout0_38ck129 FIND v(dout0_38) AT=1300.05n

* CHECK dout0_39 Vdout0_39ck129 = 1.8 time = 1300
.meas tran vdout0_39ck129 FIND v(dout0_39) AT=1300.05n

* CHECK dout0_40 Vdout0_40ck129 = 1.8 time = 1300
.meas tran vdout0_40ck129 FIND v(dout0_40) AT=1300.05n

* CHECK dout0_41 Vdout0_41ck129 = 0 time = 1300
.meas tran vdout0_41ck129 FIND v(dout0_41) AT=1300.05n

* CHECK dout0_42 Vdout0_42ck129 = 0 time = 1300
.meas tran vdout0_42ck129 FIND v(dout0_42) AT=1300.05n

* CHECK dout0_43 Vdout0_43ck129 = 0 time = 1300
.meas tran vdout0_43ck129 FIND v(dout0_43) AT=1300.05n

* CHECK dout0_44 Vdout0_44ck129 = 0 time = 1300
.meas tran vdout0_44ck129 FIND v(dout0_44) AT=1300.05n

* CHECK dout0_45 Vdout0_45ck129 = 0 time = 1300
.meas tran vdout0_45ck129 FIND v(dout0_45) AT=1300.05n

* CHECK dout0_46 Vdout0_46ck129 = 0 time = 1300
.meas tran vdout0_46ck129 FIND v(dout0_46) AT=1300.05n

* CHECK dout0_47 Vdout0_47ck129 = 1.8 time = 1300
.meas tran vdout0_47ck129 FIND v(dout0_47) AT=1300.05n

* CHECK dout0_48 Vdout0_48ck129 = 1.8 time = 1300
.meas tran vdout0_48ck129 FIND v(dout0_48) AT=1300.05n

* CHECK dout0_49 Vdout0_49ck129 = 0 time = 1300
.meas tran vdout0_49ck129 FIND v(dout0_49) AT=1300.05n

* CHECK dout0_50 Vdout0_50ck129 = 1.8 time = 1300
.meas tran vdout0_50ck129 FIND v(dout0_50) AT=1300.05n

* CHECK dout0_51 Vdout0_51ck129 = 0 time = 1300
.meas tran vdout0_51ck129 FIND v(dout0_51) AT=1300.05n

* CHECK dout0_52 Vdout0_52ck129 = 0 time = 1300
.meas tran vdout0_52ck129 FIND v(dout0_52) AT=1300.05n

* CHECK dout0_53 Vdout0_53ck129 = 1.8 time = 1300
.meas tran vdout0_53ck129 FIND v(dout0_53) AT=1300.05n

* CHECK dout0_54 Vdout0_54ck129 = 1.8 time = 1300
.meas tran vdout0_54ck129 FIND v(dout0_54) AT=1300.05n

* CHECK dout0_55 Vdout0_55ck129 = 1.8 time = 1300
.meas tran vdout0_55ck129 FIND v(dout0_55) AT=1300.05n

* CHECK dout0_56 Vdout0_56ck129 = 0 time = 1300
.meas tran vdout0_56ck129 FIND v(dout0_56) AT=1300.05n

* CHECK dout0_57 Vdout0_57ck129 = 0 time = 1300
.meas tran vdout0_57ck129 FIND v(dout0_57) AT=1300.05n

* CHECK dout0_58 Vdout0_58ck129 = 0 time = 1300
.meas tran vdout0_58ck129 FIND v(dout0_58) AT=1300.05n

* CHECK dout0_59 Vdout0_59ck129 = 0 time = 1300
.meas tran vdout0_59ck129 FIND v(dout0_59) AT=1300.05n

* CHECK dout0_60 Vdout0_60ck129 = 0 time = 1300
.meas tran vdout0_60ck129 FIND v(dout0_60) AT=1300.05n

* CHECK dout0_61 Vdout0_61ck129 = 0 time = 1300
.meas tran vdout0_61ck129 FIND v(dout0_61) AT=1300.05n

* CHECK dout0_62 Vdout0_62ck129 = 1.8 time = 1300
.meas tran vdout0_62ck129 FIND v(dout0_62) AT=1300.05n

* CHECK dout0_63 Vdout0_63ck129 = 0 time = 1300
.meas tran vdout0_63ck129 FIND v(dout0_63) AT=1300.05n

* CHECK dout0_64 Vdout0_64ck129 = 0 time = 1300
.meas tran vdout0_64ck129 FIND v(dout0_64) AT=1300.05n

* CHECK dout0_0 Vdout0_0ck130 = 1.8 time = 1310
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=1310.05n

* CHECK dout0_1 Vdout0_1ck130 = 0 time = 1310
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=1310.05n

* CHECK dout0_2 Vdout0_2ck130 = 1.8 time = 1310
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=1310.05n

* CHECK dout0_3 Vdout0_3ck130 = 0 time = 1310
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=1310.05n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 1310
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=1310.05n

* CHECK dout0_5 Vdout0_5ck130 = 0 time = 1310
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=1310.05n

* CHECK dout0_6 Vdout0_6ck130 = 1.8 time = 1310
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=1310.05n

* CHECK dout0_7 Vdout0_7ck130 = 0 time = 1310
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=1310.05n

* CHECK dout0_8 Vdout0_8ck130 = 0 time = 1310
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=1310.05n

* CHECK dout0_9 Vdout0_9ck130 = 0 time = 1310
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=1310.05n

* CHECK dout0_10 Vdout0_10ck130 = 1.8 time = 1310
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=1310.05n

* CHECK dout0_11 Vdout0_11ck130 = 0 time = 1310
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=1310.05n

* CHECK dout0_12 Vdout0_12ck130 = 1.8 time = 1310
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=1310.05n

* CHECK dout0_13 Vdout0_13ck130 = 1.8 time = 1310
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=1310.05n

* CHECK dout0_14 Vdout0_14ck130 = 1.8 time = 1310
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=1310.05n

* CHECK dout0_15 Vdout0_15ck130 = 0 time = 1310
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=1310.05n

* CHECK dout0_16 Vdout0_16ck130 = 0 time = 1310
.meas tran vdout0_16ck130 FIND v(dout0_16) AT=1310.05n

* CHECK dout0_17 Vdout0_17ck130 = 0 time = 1310
.meas tran vdout0_17ck130 FIND v(dout0_17) AT=1310.05n

* CHECK dout0_18 Vdout0_18ck130 = 0 time = 1310
.meas tran vdout0_18ck130 FIND v(dout0_18) AT=1310.05n

* CHECK dout0_19 Vdout0_19ck130 = 0 time = 1310
.meas tran vdout0_19ck130 FIND v(dout0_19) AT=1310.05n

* CHECK dout0_20 Vdout0_20ck130 = 0 time = 1310
.meas tran vdout0_20ck130 FIND v(dout0_20) AT=1310.05n

* CHECK dout0_21 Vdout0_21ck130 = 1.8 time = 1310
.meas tran vdout0_21ck130 FIND v(dout0_21) AT=1310.05n

* CHECK dout0_22 Vdout0_22ck130 = 0 time = 1310
.meas tran vdout0_22ck130 FIND v(dout0_22) AT=1310.05n

* CHECK dout0_23 Vdout0_23ck130 = 1.8 time = 1310
.meas tran vdout0_23ck130 FIND v(dout0_23) AT=1310.05n

* CHECK dout0_24 Vdout0_24ck130 = 0 time = 1310
.meas tran vdout0_24ck130 FIND v(dout0_24) AT=1310.05n

* CHECK dout0_25 Vdout0_25ck130 = 1.8 time = 1310
.meas tran vdout0_25ck130 FIND v(dout0_25) AT=1310.05n

* CHECK dout0_26 Vdout0_26ck130 = 1.8 time = 1310
.meas tran vdout0_26ck130 FIND v(dout0_26) AT=1310.05n

* CHECK dout0_27 Vdout0_27ck130 = 0 time = 1310
.meas tran vdout0_27ck130 FIND v(dout0_27) AT=1310.05n

* CHECK dout0_28 Vdout0_28ck130 = 0 time = 1310
.meas tran vdout0_28ck130 FIND v(dout0_28) AT=1310.05n

* CHECK dout0_29 Vdout0_29ck130 = 1.8 time = 1310
.meas tran vdout0_29ck130 FIND v(dout0_29) AT=1310.05n

* CHECK dout0_30 Vdout0_30ck130 = 0 time = 1310
.meas tran vdout0_30ck130 FIND v(dout0_30) AT=1310.05n

* CHECK dout0_31 Vdout0_31ck130 = 1.8 time = 1310
.meas tran vdout0_31ck130 FIND v(dout0_31) AT=1310.05n

* CHECK dout0_32 Vdout0_32ck130 = 1.8 time = 1310
.meas tran vdout0_32ck130 FIND v(dout0_32) AT=1310.05n

* CHECK dout0_33 Vdout0_33ck130 = 0 time = 1310
.meas tran vdout0_33ck130 FIND v(dout0_33) AT=1310.05n

* CHECK dout0_34 Vdout0_34ck130 = 0 time = 1310
.meas tran vdout0_34ck130 FIND v(dout0_34) AT=1310.05n

* CHECK dout0_35 Vdout0_35ck130 = 0 time = 1310
.meas tran vdout0_35ck130 FIND v(dout0_35) AT=1310.05n

* CHECK dout0_36 Vdout0_36ck130 = 1.8 time = 1310
.meas tran vdout0_36ck130 FIND v(dout0_36) AT=1310.05n

* CHECK dout0_37 Vdout0_37ck130 = 0 time = 1310
.meas tran vdout0_37ck130 FIND v(dout0_37) AT=1310.05n

* CHECK dout0_38 Vdout0_38ck130 = 1.8 time = 1310
.meas tran vdout0_38ck130 FIND v(dout0_38) AT=1310.05n

* CHECK dout0_39 Vdout0_39ck130 = 0 time = 1310
.meas tran vdout0_39ck130 FIND v(dout0_39) AT=1310.05n

* CHECK dout0_40 Vdout0_40ck130 = 1.8 time = 1310
.meas tran vdout0_40ck130 FIND v(dout0_40) AT=1310.05n

* CHECK dout0_41 Vdout0_41ck130 = 0 time = 1310
.meas tran vdout0_41ck130 FIND v(dout0_41) AT=1310.05n

* CHECK dout0_42 Vdout0_42ck130 = 1.8 time = 1310
.meas tran vdout0_42ck130 FIND v(dout0_42) AT=1310.05n

* CHECK dout0_43 Vdout0_43ck130 = 1.8 time = 1310
.meas tran vdout0_43ck130 FIND v(dout0_43) AT=1310.05n

* CHECK dout0_44 Vdout0_44ck130 = 0 time = 1310
.meas tran vdout0_44ck130 FIND v(dout0_44) AT=1310.05n

* CHECK dout0_45 Vdout0_45ck130 = 1.8 time = 1310
.meas tran vdout0_45ck130 FIND v(dout0_45) AT=1310.05n

* CHECK dout0_46 Vdout0_46ck130 = 0 time = 1310
.meas tran vdout0_46ck130 FIND v(dout0_46) AT=1310.05n

* CHECK dout0_47 Vdout0_47ck130 = 0 time = 1310
.meas tran vdout0_47ck130 FIND v(dout0_47) AT=1310.05n

* CHECK dout0_48 Vdout0_48ck130 = 1.8 time = 1310
.meas tran vdout0_48ck130 FIND v(dout0_48) AT=1310.05n

* CHECK dout0_49 Vdout0_49ck130 = 1.8 time = 1310
.meas tran vdout0_49ck130 FIND v(dout0_49) AT=1310.05n

* CHECK dout0_50 Vdout0_50ck130 = 0 time = 1310
.meas tran vdout0_50ck130 FIND v(dout0_50) AT=1310.05n

* CHECK dout0_51 Vdout0_51ck130 = 0 time = 1310
.meas tran vdout0_51ck130 FIND v(dout0_51) AT=1310.05n

* CHECK dout0_52 Vdout0_52ck130 = 1.8 time = 1310
.meas tran vdout0_52ck130 FIND v(dout0_52) AT=1310.05n

* CHECK dout0_53 Vdout0_53ck130 = 1.8 time = 1310
.meas tran vdout0_53ck130 FIND v(dout0_53) AT=1310.05n

* CHECK dout0_54 Vdout0_54ck130 = 1.8 time = 1310
.meas tran vdout0_54ck130 FIND v(dout0_54) AT=1310.05n

* CHECK dout0_55 Vdout0_55ck130 = 1.8 time = 1310
.meas tran vdout0_55ck130 FIND v(dout0_55) AT=1310.05n

* CHECK dout0_56 Vdout0_56ck130 = 1.8 time = 1310
.meas tran vdout0_56ck130 FIND v(dout0_56) AT=1310.05n

* CHECK dout0_57 Vdout0_57ck130 = 0 time = 1310
.meas tran vdout0_57ck130 FIND v(dout0_57) AT=1310.05n

* CHECK dout0_58 Vdout0_58ck130 = 0 time = 1310
.meas tran vdout0_58ck130 FIND v(dout0_58) AT=1310.05n

* CHECK dout0_59 Vdout0_59ck130 = 0 time = 1310
.meas tran vdout0_59ck130 FIND v(dout0_59) AT=1310.05n

* CHECK dout0_60 Vdout0_60ck130 = 0 time = 1310
.meas tran vdout0_60ck130 FIND v(dout0_60) AT=1310.05n

* CHECK dout0_61 Vdout0_61ck130 = 1.8 time = 1310
.meas tran vdout0_61ck130 FIND v(dout0_61) AT=1310.05n

* CHECK dout0_62 Vdout0_62ck130 = 0 time = 1310
.meas tran vdout0_62ck130 FIND v(dout0_62) AT=1310.05n

* CHECK dout0_63 Vdout0_63ck130 = 1.8 time = 1310
.meas tran vdout0_63ck130 FIND v(dout0_63) AT=1310.05n

* CHECK dout0_64 Vdout0_64ck130 = 0 time = 1310
.meas tran vdout0_64ck130 FIND v(dout0_64) AT=1310.05n

* CHECK dout0_0 Vdout0_0ck131 = 1.8 time = 1320
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=1320.05n

* CHECK dout0_1 Vdout0_1ck131 = 1.8 time = 1320
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=1320.05n

* CHECK dout0_2 Vdout0_2ck131 = 0 time = 1320
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=1320.05n

* CHECK dout0_3 Vdout0_3ck131 = 1.8 time = 1320
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=1320.05n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 1320
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=1320.05n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 1320
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=1320.05n

* CHECK dout0_6 Vdout0_6ck131 = 1.8 time = 1320
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=1320.05n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 1320
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=1320.05n

* CHECK dout0_8 Vdout0_8ck131 = 1.8 time = 1320
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=1320.05n

* CHECK dout0_9 Vdout0_9ck131 = 1.8 time = 1320
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=1320.05n

* CHECK dout0_10 Vdout0_10ck131 = 0 time = 1320
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=1320.05n

* CHECK dout0_11 Vdout0_11ck131 = 1.8 time = 1320
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=1320.05n

* CHECK dout0_12 Vdout0_12ck131 = 1.8 time = 1320
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=1320.05n

* CHECK dout0_13 Vdout0_13ck131 = 1.8 time = 1320
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=1320.05n

* CHECK dout0_14 Vdout0_14ck131 = 0 time = 1320
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=1320.05n

* CHECK dout0_15 Vdout0_15ck131 = 1.8 time = 1320
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=1320.05n

* CHECK dout0_16 Vdout0_16ck131 = 0 time = 1320
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=1320.05n

* CHECK dout0_17 Vdout0_17ck131 = 1.8 time = 1320
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=1320.05n

* CHECK dout0_18 Vdout0_18ck131 = 0 time = 1320
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=1320.05n

* CHECK dout0_19 Vdout0_19ck131 = 1.8 time = 1320
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=1320.05n

* CHECK dout0_20 Vdout0_20ck131 = 1.8 time = 1320
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=1320.05n

* CHECK dout0_21 Vdout0_21ck131 = 0 time = 1320
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=1320.05n

* CHECK dout0_22 Vdout0_22ck131 = 0 time = 1320
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=1320.05n

* CHECK dout0_23 Vdout0_23ck131 = 0 time = 1320
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=1320.05n

* CHECK dout0_24 Vdout0_24ck131 = 0 time = 1320
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=1320.05n

* CHECK dout0_25 Vdout0_25ck131 = 1.8 time = 1320
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=1320.05n

* CHECK dout0_26 Vdout0_26ck131 = 1.8 time = 1320
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=1320.05n

* CHECK dout0_27 Vdout0_27ck131 = 1.8 time = 1320
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=1320.05n

* CHECK dout0_28 Vdout0_28ck131 = 0 time = 1320
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=1320.05n

* CHECK dout0_29 Vdout0_29ck131 = 1.8 time = 1320
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=1320.05n

* CHECK dout0_30 Vdout0_30ck131 = 1.8 time = 1320
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=1320.05n

* CHECK dout0_31 Vdout0_31ck131 = 0 time = 1320
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=1320.05n

* CHECK dout0_32 Vdout0_32ck131 = 1.8 time = 1320
.meas tran vdout0_32ck131 FIND v(dout0_32) AT=1320.05n

* CHECK dout0_33 Vdout0_33ck131 = 1.8 time = 1320
.meas tran vdout0_33ck131 FIND v(dout0_33) AT=1320.05n

* CHECK dout0_34 Vdout0_34ck131 = 1.8 time = 1320
.meas tran vdout0_34ck131 FIND v(dout0_34) AT=1320.05n

* CHECK dout0_35 Vdout0_35ck131 = 0 time = 1320
.meas tran vdout0_35ck131 FIND v(dout0_35) AT=1320.05n

* CHECK dout0_36 Vdout0_36ck131 = 1.8 time = 1320
.meas tran vdout0_36ck131 FIND v(dout0_36) AT=1320.05n

* CHECK dout0_37 Vdout0_37ck131 = 1.8 time = 1320
.meas tran vdout0_37ck131 FIND v(dout0_37) AT=1320.05n

* CHECK dout0_38 Vdout0_38ck131 = 0 time = 1320
.meas tran vdout0_38ck131 FIND v(dout0_38) AT=1320.05n

* CHECK dout0_39 Vdout0_39ck131 = 0 time = 1320
.meas tran vdout0_39ck131 FIND v(dout0_39) AT=1320.05n

* CHECK dout0_40 Vdout0_40ck131 = 1.8 time = 1320
.meas tran vdout0_40ck131 FIND v(dout0_40) AT=1320.05n

* CHECK dout0_41 Vdout0_41ck131 = 1.8 time = 1320
.meas tran vdout0_41ck131 FIND v(dout0_41) AT=1320.05n

* CHECK dout0_42 Vdout0_42ck131 = 0 time = 1320
.meas tran vdout0_42ck131 FIND v(dout0_42) AT=1320.05n

* CHECK dout0_43 Vdout0_43ck131 = 1.8 time = 1320
.meas tran vdout0_43ck131 FIND v(dout0_43) AT=1320.05n

* CHECK dout0_44 Vdout0_44ck131 = 0 time = 1320
.meas tran vdout0_44ck131 FIND v(dout0_44) AT=1320.05n

* CHECK dout0_45 Vdout0_45ck131 = 0 time = 1320
.meas tran vdout0_45ck131 FIND v(dout0_45) AT=1320.05n

* CHECK dout0_46 Vdout0_46ck131 = 0 time = 1320
.meas tran vdout0_46ck131 FIND v(dout0_46) AT=1320.05n

* CHECK dout0_47 Vdout0_47ck131 = 0 time = 1320
.meas tran vdout0_47ck131 FIND v(dout0_47) AT=1320.05n

* CHECK dout0_48 Vdout0_48ck131 = 1.8 time = 1320
.meas tran vdout0_48ck131 FIND v(dout0_48) AT=1320.05n

* CHECK dout0_49 Vdout0_49ck131 = 1.8 time = 1320
.meas tran vdout0_49ck131 FIND v(dout0_49) AT=1320.05n

* CHECK dout0_50 Vdout0_50ck131 = 0 time = 1320
.meas tran vdout0_50ck131 FIND v(dout0_50) AT=1320.05n

* CHECK dout0_51 Vdout0_51ck131 = 1.8 time = 1320
.meas tran vdout0_51ck131 FIND v(dout0_51) AT=1320.05n

* CHECK dout0_52 Vdout0_52ck131 = 0 time = 1320
.meas tran vdout0_52ck131 FIND v(dout0_52) AT=1320.05n

* CHECK dout0_53 Vdout0_53ck131 = 0 time = 1320
.meas tran vdout0_53ck131 FIND v(dout0_53) AT=1320.05n

* CHECK dout0_54 Vdout0_54ck131 = 1.8 time = 1320
.meas tran vdout0_54ck131 FIND v(dout0_54) AT=1320.05n

* CHECK dout0_55 Vdout0_55ck131 = 0 time = 1320
.meas tran vdout0_55ck131 FIND v(dout0_55) AT=1320.05n

* CHECK dout0_56 Vdout0_56ck131 = 0 time = 1320
.meas tran vdout0_56ck131 FIND v(dout0_56) AT=1320.05n

* CHECK dout0_57 Vdout0_57ck131 = 1.8 time = 1320
.meas tran vdout0_57ck131 FIND v(dout0_57) AT=1320.05n

* CHECK dout0_58 Vdout0_58ck131 = 1.8 time = 1320
.meas tran vdout0_58ck131 FIND v(dout0_58) AT=1320.05n

* CHECK dout0_59 Vdout0_59ck131 = 1.8 time = 1320
.meas tran vdout0_59ck131 FIND v(dout0_59) AT=1320.05n

* CHECK dout0_60 Vdout0_60ck131 = 1.8 time = 1320
.meas tran vdout0_60ck131 FIND v(dout0_60) AT=1320.05n

* CHECK dout0_61 Vdout0_61ck131 = 1.8 time = 1320
.meas tran vdout0_61ck131 FIND v(dout0_61) AT=1320.05n

* CHECK dout0_62 Vdout0_62ck131 = 1.8 time = 1320
.meas tran vdout0_62ck131 FIND v(dout0_62) AT=1320.05n

* CHECK dout0_63 Vdout0_63ck131 = 1.8 time = 1320
.meas tran vdout0_63ck131 FIND v(dout0_63) AT=1320.05n

* CHECK dout0_64 Vdout0_64ck131 = 0 time = 1320
.meas tran vdout0_64ck131 FIND v(dout0_64) AT=1320.05n

* CHECK dout0_0 Vdout0_0ck134 = 1.8 time = 1350
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=1350.05n

* CHECK dout0_1 Vdout0_1ck134 = 0 time = 1350
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=1350.05n

* CHECK dout0_2 Vdout0_2ck134 = 1.8 time = 1350
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=1350.05n

* CHECK dout0_3 Vdout0_3ck134 = 0 time = 1350
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=1350.05n

* CHECK dout0_4 Vdout0_4ck134 = 0 time = 1350
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=1350.05n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 1350
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=1350.05n

* CHECK dout0_6 Vdout0_6ck134 = 1.8 time = 1350
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=1350.05n

* CHECK dout0_7 Vdout0_7ck134 = 0 time = 1350
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=1350.05n

* CHECK dout0_8 Vdout0_8ck134 = 0 time = 1350
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=1350.05n

* CHECK dout0_9 Vdout0_9ck134 = 0 time = 1350
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=1350.05n

* CHECK dout0_10 Vdout0_10ck134 = 1.8 time = 1350
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=1350.05n

* CHECK dout0_11 Vdout0_11ck134 = 0 time = 1350
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=1350.05n

* CHECK dout0_12 Vdout0_12ck134 = 1.8 time = 1350
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=1350.05n

* CHECK dout0_13 Vdout0_13ck134 = 1.8 time = 1350
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=1350.05n

* CHECK dout0_14 Vdout0_14ck134 = 1.8 time = 1350
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=1350.05n

* CHECK dout0_15 Vdout0_15ck134 = 0 time = 1350
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=1350.05n

* CHECK dout0_16 Vdout0_16ck134 = 0 time = 1350
.meas tran vdout0_16ck134 FIND v(dout0_16) AT=1350.05n

* CHECK dout0_17 Vdout0_17ck134 = 0 time = 1350
.meas tran vdout0_17ck134 FIND v(dout0_17) AT=1350.05n

* CHECK dout0_18 Vdout0_18ck134 = 0 time = 1350
.meas tran vdout0_18ck134 FIND v(dout0_18) AT=1350.05n

* CHECK dout0_19 Vdout0_19ck134 = 0 time = 1350
.meas tran vdout0_19ck134 FIND v(dout0_19) AT=1350.05n

* CHECK dout0_20 Vdout0_20ck134 = 0 time = 1350
.meas tran vdout0_20ck134 FIND v(dout0_20) AT=1350.05n

* CHECK dout0_21 Vdout0_21ck134 = 1.8 time = 1350
.meas tran vdout0_21ck134 FIND v(dout0_21) AT=1350.05n

* CHECK dout0_22 Vdout0_22ck134 = 0 time = 1350
.meas tran vdout0_22ck134 FIND v(dout0_22) AT=1350.05n

* CHECK dout0_23 Vdout0_23ck134 = 1.8 time = 1350
.meas tran vdout0_23ck134 FIND v(dout0_23) AT=1350.05n

* CHECK dout0_24 Vdout0_24ck134 = 0 time = 1350
.meas tran vdout0_24ck134 FIND v(dout0_24) AT=1350.05n

* CHECK dout0_25 Vdout0_25ck134 = 1.8 time = 1350
.meas tran vdout0_25ck134 FIND v(dout0_25) AT=1350.05n

* CHECK dout0_26 Vdout0_26ck134 = 1.8 time = 1350
.meas tran vdout0_26ck134 FIND v(dout0_26) AT=1350.05n

* CHECK dout0_27 Vdout0_27ck134 = 0 time = 1350
.meas tran vdout0_27ck134 FIND v(dout0_27) AT=1350.05n

* CHECK dout0_28 Vdout0_28ck134 = 0 time = 1350
.meas tran vdout0_28ck134 FIND v(dout0_28) AT=1350.05n

* CHECK dout0_29 Vdout0_29ck134 = 1.8 time = 1350
.meas tran vdout0_29ck134 FIND v(dout0_29) AT=1350.05n

* CHECK dout0_30 Vdout0_30ck134 = 0 time = 1350
.meas tran vdout0_30ck134 FIND v(dout0_30) AT=1350.05n

* CHECK dout0_31 Vdout0_31ck134 = 1.8 time = 1350
.meas tran vdout0_31ck134 FIND v(dout0_31) AT=1350.05n

* CHECK dout0_32 Vdout0_32ck134 = 1.8 time = 1350
.meas tran vdout0_32ck134 FIND v(dout0_32) AT=1350.05n

* CHECK dout0_33 Vdout0_33ck134 = 0 time = 1350
.meas tran vdout0_33ck134 FIND v(dout0_33) AT=1350.05n

* CHECK dout0_34 Vdout0_34ck134 = 0 time = 1350
.meas tran vdout0_34ck134 FIND v(dout0_34) AT=1350.05n

* CHECK dout0_35 Vdout0_35ck134 = 0 time = 1350
.meas tran vdout0_35ck134 FIND v(dout0_35) AT=1350.05n

* CHECK dout0_36 Vdout0_36ck134 = 1.8 time = 1350
.meas tran vdout0_36ck134 FIND v(dout0_36) AT=1350.05n

* CHECK dout0_37 Vdout0_37ck134 = 0 time = 1350
.meas tran vdout0_37ck134 FIND v(dout0_37) AT=1350.05n

* CHECK dout0_38 Vdout0_38ck134 = 1.8 time = 1350
.meas tran vdout0_38ck134 FIND v(dout0_38) AT=1350.05n

* CHECK dout0_39 Vdout0_39ck134 = 0 time = 1350
.meas tran vdout0_39ck134 FIND v(dout0_39) AT=1350.05n

* CHECK dout0_40 Vdout0_40ck134 = 1.8 time = 1350
.meas tran vdout0_40ck134 FIND v(dout0_40) AT=1350.05n

* CHECK dout0_41 Vdout0_41ck134 = 0 time = 1350
.meas tran vdout0_41ck134 FIND v(dout0_41) AT=1350.05n

* CHECK dout0_42 Vdout0_42ck134 = 1.8 time = 1350
.meas tran vdout0_42ck134 FIND v(dout0_42) AT=1350.05n

* CHECK dout0_43 Vdout0_43ck134 = 1.8 time = 1350
.meas tran vdout0_43ck134 FIND v(dout0_43) AT=1350.05n

* CHECK dout0_44 Vdout0_44ck134 = 0 time = 1350
.meas tran vdout0_44ck134 FIND v(dout0_44) AT=1350.05n

* CHECK dout0_45 Vdout0_45ck134 = 1.8 time = 1350
.meas tran vdout0_45ck134 FIND v(dout0_45) AT=1350.05n

* CHECK dout0_46 Vdout0_46ck134 = 0 time = 1350
.meas tran vdout0_46ck134 FIND v(dout0_46) AT=1350.05n

* CHECK dout0_47 Vdout0_47ck134 = 0 time = 1350
.meas tran vdout0_47ck134 FIND v(dout0_47) AT=1350.05n

* CHECK dout0_48 Vdout0_48ck134 = 1.8 time = 1350
.meas tran vdout0_48ck134 FIND v(dout0_48) AT=1350.05n

* CHECK dout0_49 Vdout0_49ck134 = 1.8 time = 1350
.meas tran vdout0_49ck134 FIND v(dout0_49) AT=1350.05n

* CHECK dout0_50 Vdout0_50ck134 = 0 time = 1350
.meas tran vdout0_50ck134 FIND v(dout0_50) AT=1350.05n

* CHECK dout0_51 Vdout0_51ck134 = 0 time = 1350
.meas tran vdout0_51ck134 FIND v(dout0_51) AT=1350.05n

* CHECK dout0_52 Vdout0_52ck134 = 1.8 time = 1350
.meas tran vdout0_52ck134 FIND v(dout0_52) AT=1350.05n

* CHECK dout0_53 Vdout0_53ck134 = 1.8 time = 1350
.meas tran vdout0_53ck134 FIND v(dout0_53) AT=1350.05n

* CHECK dout0_54 Vdout0_54ck134 = 1.8 time = 1350
.meas tran vdout0_54ck134 FIND v(dout0_54) AT=1350.05n

* CHECK dout0_55 Vdout0_55ck134 = 1.8 time = 1350
.meas tran vdout0_55ck134 FIND v(dout0_55) AT=1350.05n

* CHECK dout0_56 Vdout0_56ck134 = 1.8 time = 1350
.meas tran vdout0_56ck134 FIND v(dout0_56) AT=1350.05n

* CHECK dout0_57 Vdout0_57ck134 = 0 time = 1350
.meas tran vdout0_57ck134 FIND v(dout0_57) AT=1350.05n

* CHECK dout0_58 Vdout0_58ck134 = 0 time = 1350
.meas tran vdout0_58ck134 FIND v(dout0_58) AT=1350.05n

* CHECK dout0_59 Vdout0_59ck134 = 0 time = 1350
.meas tran vdout0_59ck134 FIND v(dout0_59) AT=1350.05n

* CHECK dout0_60 Vdout0_60ck134 = 0 time = 1350
.meas tran vdout0_60ck134 FIND v(dout0_60) AT=1350.05n

* CHECK dout0_61 Vdout0_61ck134 = 1.8 time = 1350
.meas tran vdout0_61ck134 FIND v(dout0_61) AT=1350.05n

* CHECK dout0_62 Vdout0_62ck134 = 0 time = 1350
.meas tran vdout0_62ck134 FIND v(dout0_62) AT=1350.05n

* CHECK dout0_63 Vdout0_63ck134 = 1.8 time = 1350
.meas tran vdout0_63ck134 FIND v(dout0_63) AT=1350.05n

* CHECK dout0_64 Vdout0_64ck134 = 0 time = 1350
.meas tran vdout0_64ck134 FIND v(dout0_64) AT=1350.05n

* CHECK dout0_0 Vdout0_0ck137 = 0 time = 1380
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=1380.05n

* CHECK dout0_1 Vdout0_1ck137 = 1.8 time = 1380
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=1380.05n

* CHECK dout0_2 Vdout0_2ck137 = 1.8 time = 1380
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=1380.05n

* CHECK dout0_3 Vdout0_3ck137 = 1.8 time = 1380
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=1380.05n

* CHECK dout0_4 Vdout0_4ck137 = 1.8 time = 1380
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=1380.05n

* CHECK dout0_5 Vdout0_5ck137 = 1.8 time = 1380
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=1380.05n

* CHECK dout0_6 Vdout0_6ck137 = 0 time = 1380
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=1380.05n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 1380
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=1380.05n

* CHECK dout0_8 Vdout0_8ck137 = 0 time = 1380
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=1380.05n

* CHECK dout0_9 Vdout0_9ck137 = 0 time = 1380
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=1380.05n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 1380
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=1380.05n

* CHECK dout0_11 Vdout0_11ck137 = 1.8 time = 1380
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=1380.05n

* CHECK dout0_12 Vdout0_12ck137 = 0 time = 1380
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=1380.05n

* CHECK dout0_13 Vdout0_13ck137 = 0 time = 1380
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=1380.05n

* CHECK dout0_14 Vdout0_14ck137 = 1.8 time = 1380
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=1380.05n

* CHECK dout0_15 Vdout0_15ck137 = 1.8 time = 1380
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=1380.05n

* CHECK dout0_16 Vdout0_16ck137 = 0 time = 1380
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=1380.05n

* CHECK dout0_17 Vdout0_17ck137 = 1.8 time = 1380
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=1380.05n

* CHECK dout0_18 Vdout0_18ck137 = 1.8 time = 1380
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=1380.05n

* CHECK dout0_19 Vdout0_19ck137 = 1.8 time = 1380
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=1380.05n

* CHECK dout0_20 Vdout0_20ck137 = 0 time = 1380
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=1380.05n

* CHECK dout0_21 Vdout0_21ck137 = 1.8 time = 1380
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=1380.05n

* CHECK dout0_22 Vdout0_22ck137 = 1.8 time = 1380
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=1380.05n

* CHECK dout0_23 Vdout0_23ck137 = 1.8 time = 1380
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=1380.05n

* CHECK dout0_24 Vdout0_24ck137 = 1.8 time = 1380
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=1380.05n

* CHECK dout0_25 Vdout0_25ck137 = 0 time = 1380
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=1380.05n

* CHECK dout0_26 Vdout0_26ck137 = 0 time = 1380
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=1380.05n

* CHECK dout0_27 Vdout0_27ck137 = 1.8 time = 1380
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=1380.05n

* CHECK dout0_28 Vdout0_28ck137 = 1.8 time = 1380
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=1380.05n

* CHECK dout0_29 Vdout0_29ck137 = 1.8 time = 1380
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=1380.05n

* CHECK dout0_30 Vdout0_30ck137 = 0 time = 1380
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=1380.05n

* CHECK dout0_31 Vdout0_31ck137 = 0 time = 1380
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=1380.05n

* CHECK dout0_32 Vdout0_32ck137 = 1.8 time = 1380
.meas tran vdout0_32ck137 FIND v(dout0_32) AT=1380.05n

* CHECK dout0_33 Vdout0_33ck137 = 1.8 time = 1380
.meas tran vdout0_33ck137 FIND v(dout0_33) AT=1380.05n

* CHECK dout0_34 Vdout0_34ck137 = 1.8 time = 1380
.meas tran vdout0_34ck137 FIND v(dout0_34) AT=1380.05n

* CHECK dout0_35 Vdout0_35ck137 = 0 time = 1380
.meas tran vdout0_35ck137 FIND v(dout0_35) AT=1380.05n

* CHECK dout0_36 Vdout0_36ck137 = 1.8 time = 1380
.meas tran vdout0_36ck137 FIND v(dout0_36) AT=1380.05n

* CHECK dout0_37 Vdout0_37ck137 = 1.8 time = 1380
.meas tran vdout0_37ck137 FIND v(dout0_37) AT=1380.05n

* CHECK dout0_38 Vdout0_38ck137 = 1.8 time = 1380
.meas tran vdout0_38ck137 FIND v(dout0_38) AT=1380.05n

* CHECK dout0_39 Vdout0_39ck137 = 1.8 time = 1380
.meas tran vdout0_39ck137 FIND v(dout0_39) AT=1380.05n

* CHECK dout0_40 Vdout0_40ck137 = 0 time = 1380
.meas tran vdout0_40ck137 FIND v(dout0_40) AT=1380.05n

* CHECK dout0_41 Vdout0_41ck137 = 1.8 time = 1380
.meas tran vdout0_41ck137 FIND v(dout0_41) AT=1380.05n

* CHECK dout0_42 Vdout0_42ck137 = 1.8 time = 1380
.meas tran vdout0_42ck137 FIND v(dout0_42) AT=1380.05n

* CHECK dout0_43 Vdout0_43ck137 = 1.8 time = 1380
.meas tran vdout0_43ck137 FIND v(dout0_43) AT=1380.05n

* CHECK dout0_44 Vdout0_44ck137 = 1.8 time = 1380
.meas tran vdout0_44ck137 FIND v(dout0_44) AT=1380.05n

* CHECK dout0_45 Vdout0_45ck137 = 0 time = 1380
.meas tran vdout0_45ck137 FIND v(dout0_45) AT=1380.05n

* CHECK dout0_46 Vdout0_46ck137 = 0 time = 1380
.meas tran vdout0_46ck137 FIND v(dout0_46) AT=1380.05n

* CHECK dout0_47 Vdout0_47ck137 = 1.8 time = 1380
.meas tran vdout0_47ck137 FIND v(dout0_47) AT=1380.05n

* CHECK dout0_48 Vdout0_48ck137 = 1.8 time = 1380
.meas tran vdout0_48ck137 FIND v(dout0_48) AT=1380.05n

* CHECK dout0_49 Vdout0_49ck137 = 1.8 time = 1380
.meas tran vdout0_49ck137 FIND v(dout0_49) AT=1380.05n

* CHECK dout0_50 Vdout0_50ck137 = 1.8 time = 1380
.meas tran vdout0_50ck137 FIND v(dout0_50) AT=1380.05n

* CHECK dout0_51 Vdout0_51ck137 = 0 time = 1380
.meas tran vdout0_51ck137 FIND v(dout0_51) AT=1380.05n

* CHECK dout0_52 Vdout0_52ck137 = 0 time = 1380
.meas tran vdout0_52ck137 FIND v(dout0_52) AT=1380.05n

* CHECK dout0_53 Vdout0_53ck137 = 1.8 time = 1380
.meas tran vdout0_53ck137 FIND v(dout0_53) AT=1380.05n

* CHECK dout0_54 Vdout0_54ck137 = 1.8 time = 1380
.meas tran vdout0_54ck137 FIND v(dout0_54) AT=1380.05n

* CHECK dout0_55 Vdout0_55ck137 = 0 time = 1380
.meas tran vdout0_55ck137 FIND v(dout0_55) AT=1380.05n

* CHECK dout0_56 Vdout0_56ck137 = 1.8 time = 1380
.meas tran vdout0_56ck137 FIND v(dout0_56) AT=1380.05n

* CHECK dout0_57 Vdout0_57ck137 = 0 time = 1380
.meas tran vdout0_57ck137 FIND v(dout0_57) AT=1380.05n

* CHECK dout0_58 Vdout0_58ck137 = 1.8 time = 1380
.meas tran vdout0_58ck137 FIND v(dout0_58) AT=1380.05n

* CHECK dout0_59 Vdout0_59ck137 = 0 time = 1380
.meas tran vdout0_59ck137 FIND v(dout0_59) AT=1380.05n

* CHECK dout0_60 Vdout0_60ck137 = 0 time = 1380
.meas tran vdout0_60ck137 FIND v(dout0_60) AT=1380.05n

* CHECK dout0_61 Vdout0_61ck137 = 1.8 time = 1380
.meas tran vdout0_61ck137 FIND v(dout0_61) AT=1380.05n

* CHECK dout0_62 Vdout0_62ck137 = 1.8 time = 1380
.meas tran vdout0_62ck137 FIND v(dout0_62) AT=1380.05n

* CHECK dout0_63 Vdout0_63ck137 = 0 time = 1380
.meas tran vdout0_63ck137 FIND v(dout0_63) AT=1380.05n

* CHECK dout0_64 Vdout0_64ck137 = 0 time = 1380
.meas tran vdout0_64ck137 FIND v(dout0_64) AT=1380.05n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 1400
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=1400.05n

* CHECK dout0_1 Vdout0_1ck139 = 1.8 time = 1400
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=1400.05n

* CHECK dout0_2 Vdout0_2ck139 = 1.8 time = 1400
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=1400.05n

* CHECK dout0_3 Vdout0_3ck139 = 1.8 time = 1400
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=1400.05n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 1400
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=1400.05n

* CHECK dout0_5 Vdout0_5ck139 = 1.8 time = 1400
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=1400.05n

* CHECK dout0_6 Vdout0_6ck139 = 0 time = 1400
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=1400.05n

* CHECK dout0_7 Vdout0_7ck139 = 1.8 time = 1400
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=1400.05n

* CHECK dout0_8 Vdout0_8ck139 = 0 time = 1400
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=1400.05n

* CHECK dout0_9 Vdout0_9ck139 = 1.8 time = 1400
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=1400.05n

* CHECK dout0_10 Vdout0_10ck139 = 1.8 time = 1400
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=1400.05n

* CHECK dout0_11 Vdout0_11ck139 = 1.8 time = 1400
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=1400.05n

* CHECK dout0_12 Vdout0_12ck139 = 0 time = 1400
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=1400.05n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 1400
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=1400.05n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 1400
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=1400.05n

* CHECK dout0_15 Vdout0_15ck139 = 1.8 time = 1400
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=1400.05n

* CHECK dout0_16 Vdout0_16ck139 = 0 time = 1400
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=1400.05n

* CHECK dout0_17 Vdout0_17ck139 = 1.8 time = 1400
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=1400.05n

* CHECK dout0_18 Vdout0_18ck139 = 1.8 time = 1400
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=1400.05n

* CHECK dout0_19 Vdout0_19ck139 = 0 time = 1400
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=1400.05n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 1400
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=1400.05n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 1400
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=1400.05n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 1400
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=1400.05n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 1400
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=1400.05n

* CHECK dout0_24 Vdout0_24ck139 = 1.8 time = 1400
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=1400.05n

* CHECK dout0_25 Vdout0_25ck139 = 0 time = 1400
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=1400.05n

* CHECK dout0_26 Vdout0_26ck139 = 1.8 time = 1400
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=1400.05n

* CHECK dout0_27 Vdout0_27ck139 = 1.8 time = 1400
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=1400.05n

* CHECK dout0_28 Vdout0_28ck139 = 1.8 time = 1400
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=1400.05n

* CHECK dout0_29 Vdout0_29ck139 = 0 time = 1400
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=1400.05n

* CHECK dout0_30 Vdout0_30ck139 = 0 time = 1400
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=1400.05n

* CHECK dout0_31 Vdout0_31ck139 = 1.8 time = 1400
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=1400.05n

* CHECK dout0_32 Vdout0_32ck139 = 1.8 time = 1400
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=1400.05n

* CHECK dout0_33 Vdout0_33ck139 = 1.8 time = 1400
.meas tran vdout0_33ck139 FIND v(dout0_33) AT=1400.05n

* CHECK dout0_34 Vdout0_34ck139 = 0 time = 1400
.meas tran vdout0_34ck139 FIND v(dout0_34) AT=1400.05n

* CHECK dout0_35 Vdout0_35ck139 = 1.8 time = 1400
.meas tran vdout0_35ck139 FIND v(dout0_35) AT=1400.05n

* CHECK dout0_36 Vdout0_36ck139 = 1.8 time = 1400
.meas tran vdout0_36ck139 FIND v(dout0_36) AT=1400.05n

* CHECK dout0_37 Vdout0_37ck139 = 0 time = 1400
.meas tran vdout0_37ck139 FIND v(dout0_37) AT=1400.05n

* CHECK dout0_38 Vdout0_38ck139 = 0 time = 1400
.meas tran vdout0_38ck139 FIND v(dout0_38) AT=1400.05n

* CHECK dout0_39 Vdout0_39ck139 = 1.8 time = 1400
.meas tran vdout0_39ck139 FIND v(dout0_39) AT=1400.05n

* CHECK dout0_40 Vdout0_40ck139 = 1.8 time = 1400
.meas tran vdout0_40ck139 FIND v(dout0_40) AT=1400.05n

* CHECK dout0_41 Vdout0_41ck139 = 0 time = 1400
.meas tran vdout0_41ck139 FIND v(dout0_41) AT=1400.05n

* CHECK dout0_42 Vdout0_42ck139 = 1.8 time = 1400
.meas tran vdout0_42ck139 FIND v(dout0_42) AT=1400.05n

* CHECK dout0_43 Vdout0_43ck139 = 0 time = 1400
.meas tran vdout0_43ck139 FIND v(dout0_43) AT=1400.05n

* CHECK dout0_44 Vdout0_44ck139 = 0 time = 1400
.meas tran vdout0_44ck139 FIND v(dout0_44) AT=1400.05n

* CHECK dout0_45 Vdout0_45ck139 = 0 time = 1400
.meas tran vdout0_45ck139 FIND v(dout0_45) AT=1400.05n

* CHECK dout0_46 Vdout0_46ck139 = 0 time = 1400
.meas tran vdout0_46ck139 FIND v(dout0_46) AT=1400.05n

* CHECK dout0_47 Vdout0_47ck139 = 1.8 time = 1400
.meas tran vdout0_47ck139 FIND v(dout0_47) AT=1400.05n

* CHECK dout0_48 Vdout0_48ck139 = 0 time = 1400
.meas tran vdout0_48ck139 FIND v(dout0_48) AT=1400.05n

* CHECK dout0_49 Vdout0_49ck139 = 1.8 time = 1400
.meas tran vdout0_49ck139 FIND v(dout0_49) AT=1400.05n

* CHECK dout0_50 Vdout0_50ck139 = 0 time = 1400
.meas tran vdout0_50ck139 FIND v(dout0_50) AT=1400.05n

* CHECK dout0_51 Vdout0_51ck139 = 0 time = 1400
.meas tran vdout0_51ck139 FIND v(dout0_51) AT=1400.05n

* CHECK dout0_52 Vdout0_52ck139 = 0 time = 1400
.meas tran vdout0_52ck139 FIND v(dout0_52) AT=1400.05n

* CHECK dout0_53 Vdout0_53ck139 = 1.8 time = 1400
.meas tran vdout0_53ck139 FIND v(dout0_53) AT=1400.05n

* CHECK dout0_54 Vdout0_54ck139 = 1.8 time = 1400
.meas tran vdout0_54ck139 FIND v(dout0_54) AT=1400.05n

* CHECK dout0_55 Vdout0_55ck139 = 1.8 time = 1400
.meas tran vdout0_55ck139 FIND v(dout0_55) AT=1400.05n

* CHECK dout0_56 Vdout0_56ck139 = 1.8 time = 1400
.meas tran vdout0_56ck139 FIND v(dout0_56) AT=1400.05n

* CHECK dout0_57 Vdout0_57ck139 = 1.8 time = 1400
.meas tran vdout0_57ck139 FIND v(dout0_57) AT=1400.05n

* CHECK dout0_58 Vdout0_58ck139 = 0 time = 1400
.meas tran vdout0_58ck139 FIND v(dout0_58) AT=1400.05n

* CHECK dout0_59 Vdout0_59ck139 = 1.8 time = 1400
.meas tran vdout0_59ck139 FIND v(dout0_59) AT=1400.05n

* CHECK dout0_60 Vdout0_60ck139 = 1.8 time = 1400
.meas tran vdout0_60ck139 FIND v(dout0_60) AT=1400.05n

* CHECK dout0_61 Vdout0_61ck139 = 1.8 time = 1400
.meas tran vdout0_61ck139 FIND v(dout0_61) AT=1400.05n

* CHECK dout0_62 Vdout0_62ck139 = 0 time = 1400
.meas tran vdout0_62ck139 FIND v(dout0_62) AT=1400.05n

* CHECK dout0_63 Vdout0_63ck139 = 1.8 time = 1400
.meas tran vdout0_63ck139 FIND v(dout0_63) AT=1400.05n

* CHECK dout0_64 Vdout0_64ck139 = 0 time = 1400
.meas tran vdout0_64ck139 FIND v(dout0_64) AT=1400.05n

* CHECK dout0_0 Vdout0_0ck143 = 1.8 time = 1440
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=1440.05n

* CHECK dout0_1 Vdout0_1ck143 = 1.8 time = 1440
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=1440.05n

* CHECK dout0_2 Vdout0_2ck143 = 0 time = 1440
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=1440.05n

* CHECK dout0_3 Vdout0_3ck143 = 1.8 time = 1440
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=1440.05n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 1440
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=1440.05n

* CHECK dout0_5 Vdout0_5ck143 = 0 time = 1440
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=1440.05n

* CHECK dout0_6 Vdout0_6ck143 = 1.8 time = 1440
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=1440.05n

* CHECK dout0_7 Vdout0_7ck143 = 0 time = 1440
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=1440.05n

* CHECK dout0_8 Vdout0_8ck143 = 1.8 time = 1440
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=1440.05n

* CHECK dout0_9 Vdout0_9ck143 = 1.8 time = 1440
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=1440.05n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 1440
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=1440.05n

* CHECK dout0_11 Vdout0_11ck143 = 1.8 time = 1440
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=1440.05n

* CHECK dout0_12 Vdout0_12ck143 = 1.8 time = 1440
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=1440.05n

* CHECK dout0_13 Vdout0_13ck143 = 1.8 time = 1440
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=1440.05n

* CHECK dout0_14 Vdout0_14ck143 = 0 time = 1440
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=1440.05n

* CHECK dout0_15 Vdout0_15ck143 = 1.8 time = 1440
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=1440.05n

* CHECK dout0_16 Vdout0_16ck143 = 0 time = 1440
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=1440.05n

* CHECK dout0_17 Vdout0_17ck143 = 1.8 time = 1440
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=1440.05n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 1440
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=1440.05n

* CHECK dout0_19 Vdout0_19ck143 = 1.8 time = 1440
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=1440.05n

* CHECK dout0_20 Vdout0_20ck143 = 1.8 time = 1440
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=1440.05n

* CHECK dout0_21 Vdout0_21ck143 = 0 time = 1440
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=1440.05n

* CHECK dout0_22 Vdout0_22ck143 = 0 time = 1440
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=1440.05n

* CHECK dout0_23 Vdout0_23ck143 = 0 time = 1440
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=1440.05n

* CHECK dout0_24 Vdout0_24ck143 = 0 time = 1440
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=1440.05n

* CHECK dout0_25 Vdout0_25ck143 = 1.8 time = 1440
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=1440.05n

* CHECK dout0_26 Vdout0_26ck143 = 1.8 time = 1440
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=1440.05n

* CHECK dout0_27 Vdout0_27ck143 = 1.8 time = 1440
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=1440.05n

* CHECK dout0_28 Vdout0_28ck143 = 0 time = 1440
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=1440.05n

* CHECK dout0_29 Vdout0_29ck143 = 1.8 time = 1440
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=1440.05n

* CHECK dout0_30 Vdout0_30ck143 = 1.8 time = 1440
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=1440.05n

* CHECK dout0_31 Vdout0_31ck143 = 0 time = 1440
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=1440.05n

* CHECK dout0_32 Vdout0_32ck143 = 1.8 time = 1440
.meas tran vdout0_32ck143 FIND v(dout0_32) AT=1440.05n

* CHECK dout0_33 Vdout0_33ck143 = 1.8 time = 1440
.meas tran vdout0_33ck143 FIND v(dout0_33) AT=1440.05n

* CHECK dout0_34 Vdout0_34ck143 = 1.8 time = 1440
.meas tran vdout0_34ck143 FIND v(dout0_34) AT=1440.05n

* CHECK dout0_35 Vdout0_35ck143 = 0 time = 1440
.meas tran vdout0_35ck143 FIND v(dout0_35) AT=1440.05n

* CHECK dout0_36 Vdout0_36ck143 = 1.8 time = 1440
.meas tran vdout0_36ck143 FIND v(dout0_36) AT=1440.05n

* CHECK dout0_37 Vdout0_37ck143 = 1.8 time = 1440
.meas tran vdout0_37ck143 FIND v(dout0_37) AT=1440.05n

* CHECK dout0_38 Vdout0_38ck143 = 0 time = 1440
.meas tran vdout0_38ck143 FIND v(dout0_38) AT=1440.05n

* CHECK dout0_39 Vdout0_39ck143 = 0 time = 1440
.meas tran vdout0_39ck143 FIND v(dout0_39) AT=1440.05n

* CHECK dout0_40 Vdout0_40ck143 = 1.8 time = 1440
.meas tran vdout0_40ck143 FIND v(dout0_40) AT=1440.05n

* CHECK dout0_41 Vdout0_41ck143 = 1.8 time = 1440
.meas tran vdout0_41ck143 FIND v(dout0_41) AT=1440.05n

* CHECK dout0_42 Vdout0_42ck143 = 0 time = 1440
.meas tran vdout0_42ck143 FIND v(dout0_42) AT=1440.05n

* CHECK dout0_43 Vdout0_43ck143 = 1.8 time = 1440
.meas tran vdout0_43ck143 FIND v(dout0_43) AT=1440.05n

* CHECK dout0_44 Vdout0_44ck143 = 0 time = 1440
.meas tran vdout0_44ck143 FIND v(dout0_44) AT=1440.05n

* CHECK dout0_45 Vdout0_45ck143 = 0 time = 1440
.meas tran vdout0_45ck143 FIND v(dout0_45) AT=1440.05n

* CHECK dout0_46 Vdout0_46ck143 = 0 time = 1440
.meas tran vdout0_46ck143 FIND v(dout0_46) AT=1440.05n

* CHECK dout0_47 Vdout0_47ck143 = 0 time = 1440
.meas tran vdout0_47ck143 FIND v(dout0_47) AT=1440.05n

* CHECK dout0_48 Vdout0_48ck143 = 1.8 time = 1440
.meas tran vdout0_48ck143 FIND v(dout0_48) AT=1440.05n

* CHECK dout0_49 Vdout0_49ck143 = 1.8 time = 1440
.meas tran vdout0_49ck143 FIND v(dout0_49) AT=1440.05n

* CHECK dout0_50 Vdout0_50ck143 = 0 time = 1440
.meas tran vdout0_50ck143 FIND v(dout0_50) AT=1440.05n

* CHECK dout0_51 Vdout0_51ck143 = 1.8 time = 1440
.meas tran vdout0_51ck143 FIND v(dout0_51) AT=1440.05n

* CHECK dout0_52 Vdout0_52ck143 = 0 time = 1440
.meas tran vdout0_52ck143 FIND v(dout0_52) AT=1440.05n

* CHECK dout0_53 Vdout0_53ck143 = 0 time = 1440
.meas tran vdout0_53ck143 FIND v(dout0_53) AT=1440.05n

* CHECK dout0_54 Vdout0_54ck143 = 1.8 time = 1440
.meas tran vdout0_54ck143 FIND v(dout0_54) AT=1440.05n

* CHECK dout0_55 Vdout0_55ck143 = 0 time = 1440
.meas tran vdout0_55ck143 FIND v(dout0_55) AT=1440.05n

* CHECK dout0_56 Vdout0_56ck143 = 0 time = 1440
.meas tran vdout0_56ck143 FIND v(dout0_56) AT=1440.05n

* CHECK dout0_57 Vdout0_57ck143 = 1.8 time = 1440
.meas tran vdout0_57ck143 FIND v(dout0_57) AT=1440.05n

* CHECK dout0_58 Vdout0_58ck143 = 1.8 time = 1440
.meas tran vdout0_58ck143 FIND v(dout0_58) AT=1440.05n

* CHECK dout0_59 Vdout0_59ck143 = 1.8 time = 1440
.meas tran vdout0_59ck143 FIND v(dout0_59) AT=1440.05n

* CHECK dout0_60 Vdout0_60ck143 = 1.8 time = 1440
.meas tran vdout0_60ck143 FIND v(dout0_60) AT=1440.05n

* CHECK dout0_61 Vdout0_61ck143 = 1.8 time = 1440
.meas tran vdout0_61ck143 FIND v(dout0_61) AT=1440.05n

* CHECK dout0_62 Vdout0_62ck143 = 1.8 time = 1440
.meas tran vdout0_62ck143 FIND v(dout0_62) AT=1440.05n

* CHECK dout0_63 Vdout0_63ck143 = 1.8 time = 1440
.meas tran vdout0_63ck143 FIND v(dout0_63) AT=1440.05n

* CHECK dout0_64 Vdout0_64ck143 = 0 time = 1440
.meas tran vdout0_64ck143 FIND v(dout0_64) AT=1440.05n

* CHECK dout0_0 Vdout0_0ck149 = 1.8 time = 1500
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=1500.05n

* CHECK dout0_1 Vdout0_1ck149 = 1.8 time = 1500
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=1500.05n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 1500
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=1500.05n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 1500
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=1500.05n

* CHECK dout0_4 Vdout0_4ck149 = 0 time = 1500
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=1500.05n

* CHECK dout0_5 Vdout0_5ck149 = 0 time = 1500
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=1500.05n

* CHECK dout0_6 Vdout0_6ck149 = 0 time = 1500
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=1500.05n

* CHECK dout0_7 Vdout0_7ck149 = 1.8 time = 1500
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=1500.05n

* CHECK dout0_8 Vdout0_8ck149 = 0 time = 1500
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=1500.05n

* CHECK dout0_9 Vdout0_9ck149 = 0 time = 1500
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=1500.05n

* CHECK dout0_10 Vdout0_10ck149 = 0 time = 1500
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=1500.05n

* CHECK dout0_11 Vdout0_11ck149 = 0 time = 1500
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=1500.05n

* CHECK dout0_12 Vdout0_12ck149 = 1.8 time = 1500
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=1500.05n

* CHECK dout0_13 Vdout0_13ck149 = 1.8 time = 1500
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=1500.05n

* CHECK dout0_14 Vdout0_14ck149 = 0 time = 1500
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=1500.05n

* CHECK dout0_15 Vdout0_15ck149 = 1.8 time = 1500
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=1500.05n

* CHECK dout0_16 Vdout0_16ck149 = 0 time = 1500
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=1500.05n

* CHECK dout0_17 Vdout0_17ck149 = 1.8 time = 1500
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=1500.05n

* CHECK dout0_18 Vdout0_18ck149 = 0 time = 1500
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=1500.05n

* CHECK dout0_19 Vdout0_19ck149 = 1.8 time = 1500
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=1500.05n

* CHECK dout0_20 Vdout0_20ck149 = 1.8 time = 1500
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=1500.05n

* CHECK dout0_21 Vdout0_21ck149 = 1.8 time = 1500
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=1500.05n

* CHECK dout0_22 Vdout0_22ck149 = 0 time = 1500
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=1500.05n

* CHECK dout0_23 Vdout0_23ck149 = 0 time = 1500
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=1500.05n

* CHECK dout0_24 Vdout0_24ck149 = 1.8 time = 1500
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=1500.05n

* CHECK dout0_25 Vdout0_25ck149 = 0 time = 1500
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=1500.05n

* CHECK dout0_26 Vdout0_26ck149 = 1.8 time = 1500
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=1500.05n

* CHECK dout0_27 Vdout0_27ck149 = 0 time = 1500
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=1500.05n

* CHECK dout0_28 Vdout0_28ck149 = 0 time = 1500
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=1500.05n

* CHECK dout0_29 Vdout0_29ck149 = 1.8 time = 1500
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=1500.05n

* CHECK dout0_30 Vdout0_30ck149 = 0 time = 1500
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=1500.05n

* CHECK dout0_31 Vdout0_31ck149 = 0 time = 1500
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=1500.05n

* CHECK dout0_32 Vdout0_32ck149 = 1.8 time = 1500
.meas tran vdout0_32ck149 FIND v(dout0_32) AT=1500.05n

* CHECK dout0_33 Vdout0_33ck149 = 0 time = 1500
.meas tran vdout0_33ck149 FIND v(dout0_33) AT=1500.05n

* CHECK dout0_34 Vdout0_34ck149 = 0 time = 1500
.meas tran vdout0_34ck149 FIND v(dout0_34) AT=1500.05n

* CHECK dout0_35 Vdout0_35ck149 = 1.8 time = 1500
.meas tran vdout0_35ck149 FIND v(dout0_35) AT=1500.05n

* CHECK dout0_36 Vdout0_36ck149 = 0 time = 1500
.meas tran vdout0_36ck149 FIND v(dout0_36) AT=1500.05n

* CHECK dout0_37 Vdout0_37ck149 = 1.8 time = 1500
.meas tran vdout0_37ck149 FIND v(dout0_37) AT=1500.05n

* CHECK dout0_38 Vdout0_38ck149 = 0 time = 1500
.meas tran vdout0_38ck149 FIND v(dout0_38) AT=1500.05n

* CHECK dout0_39 Vdout0_39ck149 = 1.8 time = 1500
.meas tran vdout0_39ck149 FIND v(dout0_39) AT=1500.05n

* CHECK dout0_40 Vdout0_40ck149 = 1.8 time = 1500
.meas tran vdout0_40ck149 FIND v(dout0_40) AT=1500.05n

* CHECK dout0_41 Vdout0_41ck149 = 0 time = 1500
.meas tran vdout0_41ck149 FIND v(dout0_41) AT=1500.05n

* CHECK dout0_42 Vdout0_42ck149 = 0 time = 1500
.meas tran vdout0_42ck149 FIND v(dout0_42) AT=1500.05n

* CHECK dout0_43 Vdout0_43ck149 = 1.8 time = 1500
.meas tran vdout0_43ck149 FIND v(dout0_43) AT=1500.05n

* CHECK dout0_44 Vdout0_44ck149 = 1.8 time = 1500
.meas tran vdout0_44ck149 FIND v(dout0_44) AT=1500.05n

* CHECK dout0_45 Vdout0_45ck149 = 0 time = 1500
.meas tran vdout0_45ck149 FIND v(dout0_45) AT=1500.05n

* CHECK dout0_46 Vdout0_46ck149 = 0 time = 1500
.meas tran vdout0_46ck149 FIND v(dout0_46) AT=1500.05n

* CHECK dout0_47 Vdout0_47ck149 = 0 time = 1500
.meas tran vdout0_47ck149 FIND v(dout0_47) AT=1500.05n

* CHECK dout0_48 Vdout0_48ck149 = 0 time = 1500
.meas tran vdout0_48ck149 FIND v(dout0_48) AT=1500.05n

* CHECK dout0_49 Vdout0_49ck149 = 1.8 time = 1500
.meas tran vdout0_49ck149 FIND v(dout0_49) AT=1500.05n

* CHECK dout0_50 Vdout0_50ck149 = 1.8 time = 1500
.meas tran vdout0_50ck149 FIND v(dout0_50) AT=1500.05n

* CHECK dout0_51 Vdout0_51ck149 = 1.8 time = 1500
.meas tran vdout0_51ck149 FIND v(dout0_51) AT=1500.05n

* CHECK dout0_52 Vdout0_52ck149 = 1.8 time = 1500
.meas tran vdout0_52ck149 FIND v(dout0_52) AT=1500.05n

* CHECK dout0_53 Vdout0_53ck149 = 0 time = 1500
.meas tran vdout0_53ck149 FIND v(dout0_53) AT=1500.05n

* CHECK dout0_54 Vdout0_54ck149 = 0 time = 1500
.meas tran vdout0_54ck149 FIND v(dout0_54) AT=1500.05n

* CHECK dout0_55 Vdout0_55ck149 = 1.8 time = 1500
.meas tran vdout0_55ck149 FIND v(dout0_55) AT=1500.05n

* CHECK dout0_56 Vdout0_56ck149 = 1.8 time = 1500
.meas tran vdout0_56ck149 FIND v(dout0_56) AT=1500.05n

* CHECK dout0_57 Vdout0_57ck149 = 0 time = 1500
.meas tran vdout0_57ck149 FIND v(dout0_57) AT=1500.05n

* CHECK dout0_58 Vdout0_58ck149 = 1.8 time = 1500
.meas tran vdout0_58ck149 FIND v(dout0_58) AT=1500.05n

* CHECK dout0_59 Vdout0_59ck149 = 0 time = 1500
.meas tran vdout0_59ck149 FIND v(dout0_59) AT=1500.05n

* CHECK dout0_60 Vdout0_60ck149 = 1.8 time = 1500
.meas tran vdout0_60ck149 FIND v(dout0_60) AT=1500.05n

* CHECK dout0_61 Vdout0_61ck149 = 0 time = 1500
.meas tran vdout0_61ck149 FIND v(dout0_61) AT=1500.05n

* CHECK dout0_62 Vdout0_62ck149 = 1.8 time = 1500
.meas tran vdout0_62ck149 FIND v(dout0_62) AT=1500.05n

* CHECK dout0_63 Vdout0_63ck149 = 1.8 time = 1500
.meas tran vdout0_63ck149 FIND v(dout0_63) AT=1500.05n

* CHECK dout0_64 Vdout0_64ck149 = 0 time = 1500
.meas tran vdout0_64ck149 FIND v(dout0_64) AT=1500.05n

* CHECK dout0_0 Vdout0_0ck150 = 0 time = 1510
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=1510.05n

* CHECK dout0_1 Vdout0_1ck150 = 0 time = 1510
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=1510.05n

* CHECK dout0_2 Vdout0_2ck150 = 1.8 time = 1510
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=1510.05n

* CHECK dout0_3 Vdout0_3ck150 = 0 time = 1510
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=1510.05n

* CHECK dout0_4 Vdout0_4ck150 = 0 time = 1510
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=1510.05n

* CHECK dout0_5 Vdout0_5ck150 = 0 time = 1510
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=1510.05n

* CHECK dout0_6 Vdout0_6ck150 = 0 time = 1510
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=1510.05n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 1510
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=1510.05n

* CHECK dout0_8 Vdout0_8ck150 = 0 time = 1510
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=1510.05n

* CHECK dout0_9 Vdout0_9ck150 = 0 time = 1510
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=1510.05n

* CHECK dout0_10 Vdout0_10ck150 = 0 time = 1510
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=1510.05n

* CHECK dout0_11 Vdout0_11ck150 = 1.8 time = 1510
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=1510.05n

* CHECK dout0_12 Vdout0_12ck150 = 1.8 time = 1510
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=1510.05n

* CHECK dout0_13 Vdout0_13ck150 = 1.8 time = 1510
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=1510.05n

* CHECK dout0_14 Vdout0_14ck150 = 1.8 time = 1510
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=1510.05n

* CHECK dout0_15 Vdout0_15ck150 = 1.8 time = 1510
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=1510.05n

* CHECK dout0_16 Vdout0_16ck150 = 1.8 time = 1510
.meas tran vdout0_16ck150 FIND v(dout0_16) AT=1510.05n

* CHECK dout0_17 Vdout0_17ck150 = 1.8 time = 1510
.meas tran vdout0_17ck150 FIND v(dout0_17) AT=1510.05n

* CHECK dout0_18 Vdout0_18ck150 = 1.8 time = 1510
.meas tran vdout0_18ck150 FIND v(dout0_18) AT=1510.05n

* CHECK dout0_19 Vdout0_19ck150 = 0 time = 1510
.meas tran vdout0_19ck150 FIND v(dout0_19) AT=1510.05n

* CHECK dout0_20 Vdout0_20ck150 = 1.8 time = 1510
.meas tran vdout0_20ck150 FIND v(dout0_20) AT=1510.05n

* CHECK dout0_21 Vdout0_21ck150 = 1.8 time = 1510
.meas tran vdout0_21ck150 FIND v(dout0_21) AT=1510.05n

* CHECK dout0_22 Vdout0_22ck150 = 1.8 time = 1510
.meas tran vdout0_22ck150 FIND v(dout0_22) AT=1510.05n

* CHECK dout0_23 Vdout0_23ck150 = 0 time = 1510
.meas tran vdout0_23ck150 FIND v(dout0_23) AT=1510.05n

* CHECK dout0_24 Vdout0_24ck150 = 0 time = 1510
.meas tran vdout0_24ck150 FIND v(dout0_24) AT=1510.05n

* CHECK dout0_25 Vdout0_25ck150 = 1.8 time = 1510
.meas tran vdout0_25ck150 FIND v(dout0_25) AT=1510.05n

* CHECK dout0_26 Vdout0_26ck150 = 1.8 time = 1510
.meas tran vdout0_26ck150 FIND v(dout0_26) AT=1510.05n

* CHECK dout0_27 Vdout0_27ck150 = 0 time = 1510
.meas tran vdout0_27ck150 FIND v(dout0_27) AT=1510.05n

* CHECK dout0_28 Vdout0_28ck150 = 0 time = 1510
.meas tran vdout0_28ck150 FIND v(dout0_28) AT=1510.05n

* CHECK dout0_29 Vdout0_29ck150 = 1.8 time = 1510
.meas tran vdout0_29ck150 FIND v(dout0_29) AT=1510.05n

* CHECK dout0_30 Vdout0_30ck150 = 0 time = 1510
.meas tran vdout0_30ck150 FIND v(dout0_30) AT=1510.05n

* CHECK dout0_31 Vdout0_31ck150 = 1.8 time = 1510
.meas tran vdout0_31ck150 FIND v(dout0_31) AT=1510.05n

* CHECK dout0_32 Vdout0_32ck150 = 0 time = 1510
.meas tran vdout0_32ck150 FIND v(dout0_32) AT=1510.05n

* CHECK dout0_33 Vdout0_33ck150 = 1.8 time = 1510
.meas tran vdout0_33ck150 FIND v(dout0_33) AT=1510.05n

* CHECK dout0_34 Vdout0_34ck150 = 0 time = 1510
.meas tran vdout0_34ck150 FIND v(dout0_34) AT=1510.05n

* CHECK dout0_35 Vdout0_35ck150 = 1.8 time = 1510
.meas tran vdout0_35ck150 FIND v(dout0_35) AT=1510.05n

* CHECK dout0_36 Vdout0_36ck150 = 0 time = 1510
.meas tran vdout0_36ck150 FIND v(dout0_36) AT=1510.05n

* CHECK dout0_37 Vdout0_37ck150 = 0 time = 1510
.meas tran vdout0_37ck150 FIND v(dout0_37) AT=1510.05n

* CHECK dout0_38 Vdout0_38ck150 = 1.8 time = 1510
.meas tran vdout0_38ck150 FIND v(dout0_38) AT=1510.05n

* CHECK dout0_39 Vdout0_39ck150 = 1.8 time = 1510
.meas tran vdout0_39ck150 FIND v(dout0_39) AT=1510.05n

* CHECK dout0_40 Vdout0_40ck150 = 0 time = 1510
.meas tran vdout0_40ck150 FIND v(dout0_40) AT=1510.05n

* CHECK dout0_41 Vdout0_41ck150 = 1.8 time = 1510
.meas tran vdout0_41ck150 FIND v(dout0_41) AT=1510.05n

* CHECK dout0_42 Vdout0_42ck150 = 0 time = 1510
.meas tran vdout0_42ck150 FIND v(dout0_42) AT=1510.05n

* CHECK dout0_43 Vdout0_43ck150 = 1.8 time = 1510
.meas tran vdout0_43ck150 FIND v(dout0_43) AT=1510.05n

* CHECK dout0_44 Vdout0_44ck150 = 1.8 time = 1510
.meas tran vdout0_44ck150 FIND v(dout0_44) AT=1510.05n

* CHECK dout0_45 Vdout0_45ck150 = 1.8 time = 1510
.meas tran vdout0_45ck150 FIND v(dout0_45) AT=1510.05n

* CHECK dout0_46 Vdout0_46ck150 = 0 time = 1510
.meas tran vdout0_46ck150 FIND v(dout0_46) AT=1510.05n

* CHECK dout0_47 Vdout0_47ck150 = 0 time = 1510
.meas tran vdout0_47ck150 FIND v(dout0_47) AT=1510.05n

* CHECK dout0_48 Vdout0_48ck150 = 1.8 time = 1510
.meas tran vdout0_48ck150 FIND v(dout0_48) AT=1510.05n

* CHECK dout0_49 Vdout0_49ck150 = 1.8 time = 1510
.meas tran vdout0_49ck150 FIND v(dout0_49) AT=1510.05n

* CHECK dout0_50 Vdout0_50ck150 = 0 time = 1510
.meas tran vdout0_50ck150 FIND v(dout0_50) AT=1510.05n

* CHECK dout0_51 Vdout0_51ck150 = 0 time = 1510
.meas tran vdout0_51ck150 FIND v(dout0_51) AT=1510.05n

* CHECK dout0_52 Vdout0_52ck150 = 1.8 time = 1510
.meas tran vdout0_52ck150 FIND v(dout0_52) AT=1510.05n

* CHECK dout0_53 Vdout0_53ck150 = 1.8 time = 1510
.meas tran vdout0_53ck150 FIND v(dout0_53) AT=1510.05n

* CHECK dout0_54 Vdout0_54ck150 = 1.8 time = 1510
.meas tran vdout0_54ck150 FIND v(dout0_54) AT=1510.05n

* CHECK dout0_55 Vdout0_55ck150 = 1.8 time = 1510
.meas tran vdout0_55ck150 FIND v(dout0_55) AT=1510.05n

* CHECK dout0_56 Vdout0_56ck150 = 1.8 time = 1510
.meas tran vdout0_56ck150 FIND v(dout0_56) AT=1510.05n

* CHECK dout0_57 Vdout0_57ck150 = 0 time = 1510
.meas tran vdout0_57ck150 FIND v(dout0_57) AT=1510.05n

* CHECK dout0_58 Vdout0_58ck150 = 0 time = 1510
.meas tran vdout0_58ck150 FIND v(dout0_58) AT=1510.05n

* CHECK dout0_59 Vdout0_59ck150 = 0 time = 1510
.meas tran vdout0_59ck150 FIND v(dout0_59) AT=1510.05n

* CHECK dout0_60 Vdout0_60ck150 = 0 time = 1510
.meas tran vdout0_60ck150 FIND v(dout0_60) AT=1510.05n

* CHECK dout0_61 Vdout0_61ck150 = 1.8 time = 1510
.meas tran vdout0_61ck150 FIND v(dout0_61) AT=1510.05n

* CHECK dout0_62 Vdout0_62ck150 = 1.8 time = 1510
.meas tran vdout0_62ck150 FIND v(dout0_62) AT=1510.05n

* CHECK dout0_63 Vdout0_63ck150 = 1.8 time = 1510
.meas tran vdout0_63ck150 FIND v(dout0_63) AT=1510.05n

* CHECK dout0_64 Vdout0_64ck150 = 0 time = 1510
.meas tran vdout0_64ck150 FIND v(dout0_64) AT=1510.05n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 1520
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=1520.05n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 1520
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=1520.05n

* CHECK dout0_2 Vdout0_2ck151 = 1.8 time = 1520
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=1520.05n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 1520
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=1520.05n

* CHECK dout0_4 Vdout0_4ck151 = 0 time = 1520
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=1520.05n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 1520
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=1520.05n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 1520
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=1520.05n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 1520
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=1520.05n

* CHECK dout0_8 Vdout0_8ck151 = 0 time = 1520
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=1520.05n

* CHECK dout0_9 Vdout0_9ck151 = 0 time = 1520
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=1520.05n

* CHECK dout0_10 Vdout0_10ck151 = 0 time = 1520
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=1520.05n

* CHECK dout0_11 Vdout0_11ck151 = 1.8 time = 1520
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=1520.05n

* CHECK dout0_12 Vdout0_12ck151 = 1.8 time = 1520
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=1520.05n

* CHECK dout0_13 Vdout0_13ck151 = 1.8 time = 1520
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=1520.05n

* CHECK dout0_14 Vdout0_14ck151 = 1.8 time = 1520
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=1520.05n

* CHECK dout0_15 Vdout0_15ck151 = 1.8 time = 1520
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=1520.05n

* CHECK dout0_16 Vdout0_16ck151 = 1.8 time = 1520
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=1520.05n

* CHECK dout0_17 Vdout0_17ck151 = 1.8 time = 1520
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=1520.05n

* CHECK dout0_18 Vdout0_18ck151 = 1.8 time = 1520
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=1520.05n

* CHECK dout0_19 Vdout0_19ck151 = 0 time = 1520
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=1520.05n

* CHECK dout0_20 Vdout0_20ck151 = 1.8 time = 1520
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=1520.05n

* CHECK dout0_21 Vdout0_21ck151 = 1.8 time = 1520
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=1520.05n

* CHECK dout0_22 Vdout0_22ck151 = 1.8 time = 1520
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=1520.05n

* CHECK dout0_23 Vdout0_23ck151 = 0 time = 1520
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=1520.05n

* CHECK dout0_24 Vdout0_24ck151 = 0 time = 1520
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=1520.05n

* CHECK dout0_25 Vdout0_25ck151 = 1.8 time = 1520
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=1520.05n

* CHECK dout0_26 Vdout0_26ck151 = 1.8 time = 1520
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=1520.05n

* CHECK dout0_27 Vdout0_27ck151 = 0 time = 1520
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=1520.05n

* CHECK dout0_28 Vdout0_28ck151 = 0 time = 1520
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=1520.05n

* CHECK dout0_29 Vdout0_29ck151 = 1.8 time = 1520
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=1520.05n

* CHECK dout0_30 Vdout0_30ck151 = 0 time = 1520
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=1520.05n

* CHECK dout0_31 Vdout0_31ck151 = 1.8 time = 1520
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=1520.05n

* CHECK dout0_32 Vdout0_32ck151 = 0 time = 1520
.meas tran vdout0_32ck151 FIND v(dout0_32) AT=1520.05n

* CHECK dout0_33 Vdout0_33ck151 = 1.8 time = 1520
.meas tran vdout0_33ck151 FIND v(dout0_33) AT=1520.05n

* CHECK dout0_34 Vdout0_34ck151 = 0 time = 1520
.meas tran vdout0_34ck151 FIND v(dout0_34) AT=1520.05n

* CHECK dout0_35 Vdout0_35ck151 = 1.8 time = 1520
.meas tran vdout0_35ck151 FIND v(dout0_35) AT=1520.05n

* CHECK dout0_36 Vdout0_36ck151 = 0 time = 1520
.meas tran vdout0_36ck151 FIND v(dout0_36) AT=1520.05n

* CHECK dout0_37 Vdout0_37ck151 = 0 time = 1520
.meas tran vdout0_37ck151 FIND v(dout0_37) AT=1520.05n

* CHECK dout0_38 Vdout0_38ck151 = 1.8 time = 1520
.meas tran vdout0_38ck151 FIND v(dout0_38) AT=1520.05n

* CHECK dout0_39 Vdout0_39ck151 = 1.8 time = 1520
.meas tran vdout0_39ck151 FIND v(dout0_39) AT=1520.05n

* CHECK dout0_40 Vdout0_40ck151 = 0 time = 1520
.meas tran vdout0_40ck151 FIND v(dout0_40) AT=1520.05n

* CHECK dout0_41 Vdout0_41ck151 = 1.8 time = 1520
.meas tran vdout0_41ck151 FIND v(dout0_41) AT=1520.05n

* CHECK dout0_42 Vdout0_42ck151 = 0 time = 1520
.meas tran vdout0_42ck151 FIND v(dout0_42) AT=1520.05n

* CHECK dout0_43 Vdout0_43ck151 = 1.8 time = 1520
.meas tran vdout0_43ck151 FIND v(dout0_43) AT=1520.05n

* CHECK dout0_44 Vdout0_44ck151 = 1.8 time = 1520
.meas tran vdout0_44ck151 FIND v(dout0_44) AT=1520.05n

* CHECK dout0_45 Vdout0_45ck151 = 1.8 time = 1520
.meas tran vdout0_45ck151 FIND v(dout0_45) AT=1520.05n

* CHECK dout0_46 Vdout0_46ck151 = 0 time = 1520
.meas tran vdout0_46ck151 FIND v(dout0_46) AT=1520.05n

* CHECK dout0_47 Vdout0_47ck151 = 0 time = 1520
.meas tran vdout0_47ck151 FIND v(dout0_47) AT=1520.05n

* CHECK dout0_48 Vdout0_48ck151 = 1.8 time = 1520
.meas tran vdout0_48ck151 FIND v(dout0_48) AT=1520.05n

* CHECK dout0_49 Vdout0_49ck151 = 1.8 time = 1520
.meas tran vdout0_49ck151 FIND v(dout0_49) AT=1520.05n

* CHECK dout0_50 Vdout0_50ck151 = 0 time = 1520
.meas tran vdout0_50ck151 FIND v(dout0_50) AT=1520.05n

* CHECK dout0_51 Vdout0_51ck151 = 0 time = 1520
.meas tran vdout0_51ck151 FIND v(dout0_51) AT=1520.05n

* CHECK dout0_52 Vdout0_52ck151 = 1.8 time = 1520
.meas tran vdout0_52ck151 FIND v(dout0_52) AT=1520.05n

* CHECK dout0_53 Vdout0_53ck151 = 1.8 time = 1520
.meas tran vdout0_53ck151 FIND v(dout0_53) AT=1520.05n

* CHECK dout0_54 Vdout0_54ck151 = 1.8 time = 1520
.meas tran vdout0_54ck151 FIND v(dout0_54) AT=1520.05n

* CHECK dout0_55 Vdout0_55ck151 = 1.8 time = 1520
.meas tran vdout0_55ck151 FIND v(dout0_55) AT=1520.05n

* CHECK dout0_56 Vdout0_56ck151 = 1.8 time = 1520
.meas tran vdout0_56ck151 FIND v(dout0_56) AT=1520.05n

* CHECK dout0_57 Vdout0_57ck151 = 0 time = 1520
.meas tran vdout0_57ck151 FIND v(dout0_57) AT=1520.05n

* CHECK dout0_58 Vdout0_58ck151 = 0 time = 1520
.meas tran vdout0_58ck151 FIND v(dout0_58) AT=1520.05n

* CHECK dout0_59 Vdout0_59ck151 = 0 time = 1520
.meas tran vdout0_59ck151 FIND v(dout0_59) AT=1520.05n

* CHECK dout0_60 Vdout0_60ck151 = 0 time = 1520
.meas tran vdout0_60ck151 FIND v(dout0_60) AT=1520.05n

* CHECK dout0_61 Vdout0_61ck151 = 1.8 time = 1520
.meas tran vdout0_61ck151 FIND v(dout0_61) AT=1520.05n

* CHECK dout0_62 Vdout0_62ck151 = 1.8 time = 1520
.meas tran vdout0_62ck151 FIND v(dout0_62) AT=1520.05n

* CHECK dout0_63 Vdout0_63ck151 = 1.8 time = 1520
.meas tran vdout0_63ck151 FIND v(dout0_63) AT=1520.05n

* CHECK dout0_64 Vdout0_64ck151 = 0 time = 1520
.meas tran vdout0_64ck151 FIND v(dout0_64) AT=1520.05n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 1530
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=1530.05n

* CHECK dout0_1 Vdout0_1ck152 = 1.8 time = 1530
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=1530.05n

* CHECK dout0_2 Vdout0_2ck152 = 1.8 time = 1530
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=1530.05n

* CHECK dout0_3 Vdout0_3ck152 = 0 time = 1530
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=1530.05n

* CHECK dout0_4 Vdout0_4ck152 = 0 time = 1530
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=1530.05n

* CHECK dout0_5 Vdout0_5ck152 = 1.8 time = 1530
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=1530.05n

* CHECK dout0_6 Vdout0_6ck152 = 1.8 time = 1530
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=1530.05n

* CHECK dout0_7 Vdout0_7ck152 = 0 time = 1530
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=1530.05n

* CHECK dout0_8 Vdout0_8ck152 = 1.8 time = 1530
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=1530.05n

* CHECK dout0_9 Vdout0_9ck152 = 0 time = 1530
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=1530.05n

* CHECK dout0_10 Vdout0_10ck152 = 1.8 time = 1530
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=1530.05n

* CHECK dout0_11 Vdout0_11ck152 = 1.8 time = 1530
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=1530.05n

* CHECK dout0_12 Vdout0_12ck152 = 0 time = 1530
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=1530.05n

* CHECK dout0_13 Vdout0_13ck152 = 0 time = 1530
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=1530.05n

* CHECK dout0_14 Vdout0_14ck152 = 1.8 time = 1530
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=1530.05n

* CHECK dout0_15 Vdout0_15ck152 = 1.8 time = 1530
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=1530.05n

* CHECK dout0_16 Vdout0_16ck152 = 0 time = 1530
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=1530.05n

* CHECK dout0_17 Vdout0_17ck152 = 0 time = 1530
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=1530.05n

* CHECK dout0_18 Vdout0_18ck152 = 1.8 time = 1530
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=1530.05n

* CHECK dout0_19 Vdout0_19ck152 = 1.8 time = 1530
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=1530.05n

* CHECK dout0_20 Vdout0_20ck152 = 0 time = 1530
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=1530.05n

* CHECK dout0_21 Vdout0_21ck152 = 0 time = 1530
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=1530.05n

* CHECK dout0_22 Vdout0_22ck152 = 1.8 time = 1530
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=1530.05n

* CHECK dout0_23 Vdout0_23ck152 = 0 time = 1530
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=1530.05n

* CHECK dout0_24 Vdout0_24ck152 = 0 time = 1530
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=1530.05n

* CHECK dout0_25 Vdout0_25ck152 = 0 time = 1530
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=1530.05n

* CHECK dout0_26 Vdout0_26ck152 = 1.8 time = 1530
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=1530.05n

* CHECK dout0_27 Vdout0_27ck152 = 1.8 time = 1530
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=1530.05n

* CHECK dout0_28 Vdout0_28ck152 = 1.8 time = 1530
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=1530.05n

* CHECK dout0_29 Vdout0_29ck152 = 1.8 time = 1530
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=1530.05n

* CHECK dout0_30 Vdout0_30ck152 = 0 time = 1530
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=1530.05n

* CHECK dout0_31 Vdout0_31ck152 = 1.8 time = 1530
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=1530.05n

* CHECK dout0_32 Vdout0_32ck152 = 1.8 time = 1530
.meas tran vdout0_32ck152 FIND v(dout0_32) AT=1530.05n

* CHECK dout0_33 Vdout0_33ck152 = 1.8 time = 1530
.meas tran vdout0_33ck152 FIND v(dout0_33) AT=1530.05n

* CHECK dout0_34 Vdout0_34ck152 = 1.8 time = 1530
.meas tran vdout0_34ck152 FIND v(dout0_34) AT=1530.05n

* CHECK dout0_35 Vdout0_35ck152 = 0 time = 1530
.meas tran vdout0_35ck152 FIND v(dout0_35) AT=1530.05n

* CHECK dout0_36 Vdout0_36ck152 = 0 time = 1530
.meas tran vdout0_36ck152 FIND v(dout0_36) AT=1530.05n

* CHECK dout0_37 Vdout0_37ck152 = 1.8 time = 1530
.meas tran vdout0_37ck152 FIND v(dout0_37) AT=1530.05n

* CHECK dout0_38 Vdout0_38ck152 = 0 time = 1530
.meas tran vdout0_38ck152 FIND v(dout0_38) AT=1530.05n

* CHECK dout0_39 Vdout0_39ck152 = 0 time = 1530
.meas tran vdout0_39ck152 FIND v(dout0_39) AT=1530.05n

* CHECK dout0_40 Vdout0_40ck152 = 0 time = 1530
.meas tran vdout0_40ck152 FIND v(dout0_40) AT=1530.05n

* CHECK dout0_41 Vdout0_41ck152 = 0 time = 1530
.meas tran vdout0_41ck152 FIND v(dout0_41) AT=1530.05n

* CHECK dout0_42 Vdout0_42ck152 = 1.8 time = 1530
.meas tran vdout0_42ck152 FIND v(dout0_42) AT=1530.05n

* CHECK dout0_43 Vdout0_43ck152 = 1.8 time = 1530
.meas tran vdout0_43ck152 FIND v(dout0_43) AT=1530.05n

* CHECK dout0_44 Vdout0_44ck152 = 0 time = 1530
.meas tran vdout0_44ck152 FIND v(dout0_44) AT=1530.05n

* CHECK dout0_45 Vdout0_45ck152 = 1.8 time = 1530
.meas tran vdout0_45ck152 FIND v(dout0_45) AT=1530.05n

* CHECK dout0_46 Vdout0_46ck152 = 1.8 time = 1530
.meas tran vdout0_46ck152 FIND v(dout0_46) AT=1530.05n

* CHECK dout0_47 Vdout0_47ck152 = 1.8 time = 1530
.meas tran vdout0_47ck152 FIND v(dout0_47) AT=1530.05n

* CHECK dout0_48 Vdout0_48ck152 = 1.8 time = 1530
.meas tran vdout0_48ck152 FIND v(dout0_48) AT=1530.05n

* CHECK dout0_49 Vdout0_49ck152 = 0 time = 1530
.meas tran vdout0_49ck152 FIND v(dout0_49) AT=1530.05n

* CHECK dout0_50 Vdout0_50ck152 = 1.8 time = 1530
.meas tran vdout0_50ck152 FIND v(dout0_50) AT=1530.05n

* CHECK dout0_51 Vdout0_51ck152 = 0 time = 1530
.meas tran vdout0_51ck152 FIND v(dout0_51) AT=1530.05n

* CHECK dout0_52 Vdout0_52ck152 = 1.8 time = 1530
.meas tran vdout0_52ck152 FIND v(dout0_52) AT=1530.05n

* CHECK dout0_53 Vdout0_53ck152 = 1.8 time = 1530
.meas tran vdout0_53ck152 FIND v(dout0_53) AT=1530.05n

* CHECK dout0_54 Vdout0_54ck152 = 1.8 time = 1530
.meas tran vdout0_54ck152 FIND v(dout0_54) AT=1530.05n

* CHECK dout0_55 Vdout0_55ck152 = 1.8 time = 1530
.meas tran vdout0_55ck152 FIND v(dout0_55) AT=1530.05n

* CHECK dout0_56 Vdout0_56ck152 = 0 time = 1530
.meas tran vdout0_56ck152 FIND v(dout0_56) AT=1530.05n

* CHECK dout0_57 Vdout0_57ck152 = 0 time = 1530
.meas tran vdout0_57ck152 FIND v(dout0_57) AT=1530.05n

* CHECK dout0_58 Vdout0_58ck152 = 1.8 time = 1530
.meas tran vdout0_58ck152 FIND v(dout0_58) AT=1530.05n

* CHECK dout0_59 Vdout0_59ck152 = 1.8 time = 1530
.meas tran vdout0_59ck152 FIND v(dout0_59) AT=1530.05n

* CHECK dout0_60 Vdout0_60ck152 = 1.8 time = 1530
.meas tran vdout0_60ck152 FIND v(dout0_60) AT=1530.05n

* CHECK dout0_61 Vdout0_61ck152 = 1.8 time = 1530
.meas tran vdout0_61ck152 FIND v(dout0_61) AT=1530.05n

* CHECK dout0_62 Vdout0_62ck152 = 0 time = 1530
.meas tran vdout0_62ck152 FIND v(dout0_62) AT=1530.05n

* CHECK dout0_63 Vdout0_63ck152 = 1.8 time = 1530
.meas tran vdout0_63ck152 FIND v(dout0_63) AT=1530.05n

* CHECK dout0_64 Vdout0_64ck152 = 0 time = 1530
.meas tran vdout0_64ck152 FIND v(dout0_64) AT=1530.05n

* CHECK dout0_0 Vdout0_0ck157 = 1.8 time = 1580
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=1580.05n

* CHECK dout0_1 Vdout0_1ck157 = 1.8 time = 1580
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=1580.05n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 1580
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=1580.05n

* CHECK dout0_3 Vdout0_3ck157 = 1.8 time = 1580
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=1580.05n

* CHECK dout0_4 Vdout0_4ck157 = 1.8 time = 1580
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=1580.05n

* CHECK dout0_5 Vdout0_5ck157 = 1.8 time = 1580
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=1580.05n

* CHECK dout0_6 Vdout0_6ck157 = 1.8 time = 1580
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=1580.05n

* CHECK dout0_7 Vdout0_7ck157 = 1.8 time = 1580
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=1580.05n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 1580
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=1580.05n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 1580
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=1580.05n

* CHECK dout0_10 Vdout0_10ck157 = 0 time = 1580
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=1580.05n

* CHECK dout0_11 Vdout0_11ck157 = 1.8 time = 1580
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=1580.05n

* CHECK dout0_12 Vdout0_12ck157 = 1.8 time = 1580
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=1580.05n

* CHECK dout0_13 Vdout0_13ck157 = 1.8 time = 1580
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=1580.05n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 1580
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=1580.05n

* CHECK dout0_15 Vdout0_15ck157 = 1.8 time = 1580
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=1580.05n

* CHECK dout0_16 Vdout0_16ck157 = 0 time = 1580
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=1580.05n

* CHECK dout0_17 Vdout0_17ck157 = 0 time = 1580
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=1580.05n

* CHECK dout0_18 Vdout0_18ck157 = 1.8 time = 1580
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=1580.05n

* CHECK dout0_19 Vdout0_19ck157 = 1.8 time = 1580
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=1580.05n

* CHECK dout0_20 Vdout0_20ck157 = 0 time = 1580
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=1580.05n

* CHECK dout0_21 Vdout0_21ck157 = 0 time = 1580
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=1580.05n

* CHECK dout0_22 Vdout0_22ck157 = 1.8 time = 1580
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=1580.05n

* CHECK dout0_23 Vdout0_23ck157 = 0 time = 1580
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=1580.05n

* CHECK dout0_24 Vdout0_24ck157 = 1.8 time = 1580
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=1580.05n

* CHECK dout0_25 Vdout0_25ck157 = 1.8 time = 1580
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=1580.05n

* CHECK dout0_26 Vdout0_26ck157 = 1.8 time = 1580
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=1580.05n

* CHECK dout0_27 Vdout0_27ck157 = 1.8 time = 1580
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=1580.05n

* CHECK dout0_28 Vdout0_28ck157 = 0 time = 1580
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=1580.05n

* CHECK dout0_29 Vdout0_29ck157 = 1.8 time = 1580
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=1580.05n

* CHECK dout0_30 Vdout0_30ck157 = 0 time = 1580
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=1580.05n

* CHECK dout0_31 Vdout0_31ck157 = 0 time = 1580
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=1580.05n

* CHECK dout0_32 Vdout0_32ck157 = 0 time = 1580
.meas tran vdout0_32ck157 FIND v(dout0_32) AT=1580.05n

* CHECK dout0_33 Vdout0_33ck157 = 0 time = 1580
.meas tran vdout0_33ck157 FIND v(dout0_33) AT=1580.05n

* CHECK dout0_34 Vdout0_34ck157 = 0 time = 1580
.meas tran vdout0_34ck157 FIND v(dout0_34) AT=1580.05n

* CHECK dout0_35 Vdout0_35ck157 = 0 time = 1580
.meas tran vdout0_35ck157 FIND v(dout0_35) AT=1580.05n

* CHECK dout0_36 Vdout0_36ck157 = 0 time = 1580
.meas tran vdout0_36ck157 FIND v(dout0_36) AT=1580.05n

* CHECK dout0_37 Vdout0_37ck157 = 1.8 time = 1580
.meas tran vdout0_37ck157 FIND v(dout0_37) AT=1580.05n

* CHECK dout0_38 Vdout0_38ck157 = 1.8 time = 1580
.meas tran vdout0_38ck157 FIND v(dout0_38) AT=1580.05n

* CHECK dout0_39 Vdout0_39ck157 = 1.8 time = 1580
.meas tran vdout0_39ck157 FIND v(dout0_39) AT=1580.05n

* CHECK dout0_40 Vdout0_40ck157 = 1.8 time = 1580
.meas tran vdout0_40ck157 FIND v(dout0_40) AT=1580.05n

* CHECK dout0_41 Vdout0_41ck157 = 1.8 time = 1580
.meas tran vdout0_41ck157 FIND v(dout0_41) AT=1580.05n

* CHECK dout0_42 Vdout0_42ck157 = 0 time = 1580
.meas tran vdout0_42ck157 FIND v(dout0_42) AT=1580.05n

* CHECK dout0_43 Vdout0_43ck157 = 0 time = 1580
.meas tran vdout0_43ck157 FIND v(dout0_43) AT=1580.05n

* CHECK dout0_44 Vdout0_44ck157 = 1.8 time = 1580
.meas tran vdout0_44ck157 FIND v(dout0_44) AT=1580.05n

* CHECK dout0_45 Vdout0_45ck157 = 0 time = 1580
.meas tran vdout0_45ck157 FIND v(dout0_45) AT=1580.05n

* CHECK dout0_46 Vdout0_46ck157 = 0 time = 1580
.meas tran vdout0_46ck157 FIND v(dout0_46) AT=1580.05n

* CHECK dout0_47 Vdout0_47ck157 = 0 time = 1580
.meas tran vdout0_47ck157 FIND v(dout0_47) AT=1580.05n

* CHECK dout0_48 Vdout0_48ck157 = 0 time = 1580
.meas tran vdout0_48ck157 FIND v(dout0_48) AT=1580.05n

* CHECK dout0_49 Vdout0_49ck157 = 0 time = 1580
.meas tran vdout0_49ck157 FIND v(dout0_49) AT=1580.05n

* CHECK dout0_50 Vdout0_50ck157 = 0 time = 1580
.meas tran vdout0_50ck157 FIND v(dout0_50) AT=1580.05n

* CHECK dout0_51 Vdout0_51ck157 = 1.8 time = 1580
.meas tran vdout0_51ck157 FIND v(dout0_51) AT=1580.05n

* CHECK dout0_52 Vdout0_52ck157 = 1.8 time = 1580
.meas tran vdout0_52ck157 FIND v(dout0_52) AT=1580.05n

* CHECK dout0_53 Vdout0_53ck157 = 1.8 time = 1580
.meas tran vdout0_53ck157 FIND v(dout0_53) AT=1580.05n

* CHECK dout0_54 Vdout0_54ck157 = 1.8 time = 1580
.meas tran vdout0_54ck157 FIND v(dout0_54) AT=1580.05n

* CHECK dout0_55 Vdout0_55ck157 = 1.8 time = 1580
.meas tran vdout0_55ck157 FIND v(dout0_55) AT=1580.05n

* CHECK dout0_56 Vdout0_56ck157 = 0 time = 1580
.meas tran vdout0_56ck157 FIND v(dout0_56) AT=1580.05n

* CHECK dout0_57 Vdout0_57ck157 = 1.8 time = 1580
.meas tran vdout0_57ck157 FIND v(dout0_57) AT=1580.05n

* CHECK dout0_58 Vdout0_58ck157 = 0 time = 1580
.meas tran vdout0_58ck157 FIND v(dout0_58) AT=1580.05n

* CHECK dout0_59 Vdout0_59ck157 = 1.8 time = 1580
.meas tran vdout0_59ck157 FIND v(dout0_59) AT=1580.05n

* CHECK dout0_60 Vdout0_60ck157 = 0 time = 1580
.meas tran vdout0_60ck157 FIND v(dout0_60) AT=1580.05n

* CHECK dout0_61 Vdout0_61ck157 = 1.8 time = 1580
.meas tran vdout0_61ck157 FIND v(dout0_61) AT=1580.05n

* CHECK dout0_62 Vdout0_62ck157 = 0 time = 1580
.meas tran vdout0_62ck157 FIND v(dout0_62) AT=1580.05n

* CHECK dout0_63 Vdout0_63ck157 = 0 time = 1580
.meas tran vdout0_63ck157 FIND v(dout0_63) AT=1580.05n

* CHECK dout0_64 Vdout0_64ck157 = 0 time = 1580
.meas tran vdout0_64ck157 FIND v(dout0_64) AT=1580.05n

* CHECK dout0_0 Vdout0_0ck165 = 1.8 time = 1660
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=1660.05n

* CHECK dout0_1 Vdout0_1ck165 = 0 time = 1660
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=1660.05n

* CHECK dout0_2 Vdout0_2ck165 = 1.8 time = 1660
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=1660.05n

* CHECK dout0_3 Vdout0_3ck165 = 0 time = 1660
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=1660.05n

* CHECK dout0_4 Vdout0_4ck165 = 0 time = 1660
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=1660.05n

* CHECK dout0_5 Vdout0_5ck165 = 1.8 time = 1660
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=1660.05n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 1660
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=1660.05n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 1660
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=1660.05n

* CHECK dout0_8 Vdout0_8ck165 = 1.8 time = 1660
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=1660.05n

* CHECK dout0_9 Vdout0_9ck165 = 1.8 time = 1660
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=1660.05n

* CHECK dout0_10 Vdout0_10ck165 = 1.8 time = 1660
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=1660.05n

* CHECK dout0_11 Vdout0_11ck165 = 1.8 time = 1660
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=1660.05n

* CHECK dout0_12 Vdout0_12ck165 = 0 time = 1660
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=1660.05n

* CHECK dout0_13 Vdout0_13ck165 = 0 time = 1660
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=1660.05n

* CHECK dout0_14 Vdout0_14ck165 = 1.8 time = 1660
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=1660.05n

* CHECK dout0_15 Vdout0_15ck165 = 0 time = 1660
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=1660.05n

* CHECK dout0_16 Vdout0_16ck165 = 0 time = 1660
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=1660.05n

* CHECK dout0_17 Vdout0_17ck165 = 1.8 time = 1660
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=1660.05n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 1660
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=1660.05n

* CHECK dout0_19 Vdout0_19ck165 = 1.8 time = 1660
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=1660.05n

* CHECK dout0_20 Vdout0_20ck165 = 0 time = 1660
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=1660.05n

* CHECK dout0_21 Vdout0_21ck165 = 1.8 time = 1660
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=1660.05n

* CHECK dout0_22 Vdout0_22ck165 = 0 time = 1660
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=1660.05n

* CHECK dout0_23 Vdout0_23ck165 = 1.8 time = 1660
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=1660.05n

* CHECK dout0_24 Vdout0_24ck165 = 1.8 time = 1660
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=1660.05n

* CHECK dout0_25 Vdout0_25ck165 = 0 time = 1660
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=1660.05n

* CHECK dout0_26 Vdout0_26ck165 = 1.8 time = 1660
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=1660.05n

* CHECK dout0_27 Vdout0_27ck165 = 0 time = 1660
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=1660.05n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 1660
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=1660.05n

* CHECK dout0_29 Vdout0_29ck165 = 0 time = 1660
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=1660.05n

* CHECK dout0_30 Vdout0_30ck165 = 0 time = 1660
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=1660.05n

* CHECK dout0_31 Vdout0_31ck165 = 0 time = 1660
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=1660.05n

* CHECK dout0_32 Vdout0_32ck165 = 0 time = 1660
.meas tran vdout0_32ck165 FIND v(dout0_32) AT=1660.05n

* CHECK dout0_33 Vdout0_33ck165 = 0 time = 1660
.meas tran vdout0_33ck165 FIND v(dout0_33) AT=1660.05n

* CHECK dout0_34 Vdout0_34ck165 = 0 time = 1660
.meas tran vdout0_34ck165 FIND v(dout0_34) AT=1660.05n

* CHECK dout0_35 Vdout0_35ck165 = 1.8 time = 1660
.meas tran vdout0_35ck165 FIND v(dout0_35) AT=1660.05n

* CHECK dout0_36 Vdout0_36ck165 = 0 time = 1660
.meas tran vdout0_36ck165 FIND v(dout0_36) AT=1660.05n

* CHECK dout0_37 Vdout0_37ck165 = 0 time = 1660
.meas tran vdout0_37ck165 FIND v(dout0_37) AT=1660.05n

* CHECK dout0_38 Vdout0_38ck165 = 1.8 time = 1660
.meas tran vdout0_38ck165 FIND v(dout0_38) AT=1660.05n

* CHECK dout0_39 Vdout0_39ck165 = 1.8 time = 1660
.meas tran vdout0_39ck165 FIND v(dout0_39) AT=1660.05n

* CHECK dout0_40 Vdout0_40ck165 = 1.8 time = 1660
.meas tran vdout0_40ck165 FIND v(dout0_40) AT=1660.05n

* CHECK dout0_41 Vdout0_41ck165 = 1.8 time = 1660
.meas tran vdout0_41ck165 FIND v(dout0_41) AT=1660.05n

* CHECK dout0_42 Vdout0_42ck165 = 0 time = 1660
.meas tran vdout0_42ck165 FIND v(dout0_42) AT=1660.05n

* CHECK dout0_43 Vdout0_43ck165 = 1.8 time = 1660
.meas tran vdout0_43ck165 FIND v(dout0_43) AT=1660.05n

* CHECK dout0_44 Vdout0_44ck165 = 1.8 time = 1660
.meas tran vdout0_44ck165 FIND v(dout0_44) AT=1660.05n

* CHECK dout0_45 Vdout0_45ck165 = 0 time = 1660
.meas tran vdout0_45ck165 FIND v(dout0_45) AT=1660.05n

* CHECK dout0_46 Vdout0_46ck165 = 1.8 time = 1660
.meas tran vdout0_46ck165 FIND v(dout0_46) AT=1660.05n

* CHECK dout0_47 Vdout0_47ck165 = 1.8 time = 1660
.meas tran vdout0_47ck165 FIND v(dout0_47) AT=1660.05n

* CHECK dout0_48 Vdout0_48ck165 = 0 time = 1660
.meas tran vdout0_48ck165 FIND v(dout0_48) AT=1660.05n

* CHECK dout0_49 Vdout0_49ck165 = 0 time = 1660
.meas tran vdout0_49ck165 FIND v(dout0_49) AT=1660.05n

* CHECK dout0_50 Vdout0_50ck165 = 0 time = 1660
.meas tran vdout0_50ck165 FIND v(dout0_50) AT=1660.05n

* CHECK dout0_51 Vdout0_51ck165 = 0 time = 1660
.meas tran vdout0_51ck165 FIND v(dout0_51) AT=1660.05n

* CHECK dout0_52 Vdout0_52ck165 = 0 time = 1660
.meas tran vdout0_52ck165 FIND v(dout0_52) AT=1660.05n

* CHECK dout0_53 Vdout0_53ck165 = 0 time = 1660
.meas tran vdout0_53ck165 FIND v(dout0_53) AT=1660.05n

* CHECK dout0_54 Vdout0_54ck165 = 0 time = 1660
.meas tran vdout0_54ck165 FIND v(dout0_54) AT=1660.05n

* CHECK dout0_55 Vdout0_55ck165 = 1.8 time = 1660
.meas tran vdout0_55ck165 FIND v(dout0_55) AT=1660.05n

* CHECK dout0_56 Vdout0_56ck165 = 0 time = 1660
.meas tran vdout0_56ck165 FIND v(dout0_56) AT=1660.05n

* CHECK dout0_57 Vdout0_57ck165 = 1.8 time = 1660
.meas tran vdout0_57ck165 FIND v(dout0_57) AT=1660.05n

* CHECK dout0_58 Vdout0_58ck165 = 1.8 time = 1660
.meas tran vdout0_58ck165 FIND v(dout0_58) AT=1660.05n

* CHECK dout0_59 Vdout0_59ck165 = 1.8 time = 1660
.meas tran vdout0_59ck165 FIND v(dout0_59) AT=1660.05n

* CHECK dout0_60 Vdout0_60ck165 = 1.8 time = 1660
.meas tran vdout0_60ck165 FIND v(dout0_60) AT=1660.05n

* CHECK dout0_61 Vdout0_61ck165 = 1.8 time = 1660
.meas tran vdout0_61ck165 FIND v(dout0_61) AT=1660.05n

* CHECK dout0_62 Vdout0_62ck165 = 0 time = 1660
.meas tran vdout0_62ck165 FIND v(dout0_62) AT=1660.05n

* CHECK dout0_63 Vdout0_63ck165 = 1.8 time = 1660
.meas tran vdout0_63ck165 FIND v(dout0_63) AT=1660.05n

* CHECK dout0_64 Vdout0_64ck165 = 0 time = 1660
.meas tran vdout0_64ck165 FIND v(dout0_64) AT=1660.05n

* CHECK dout0_0 Vdout0_0ck166 = 1.8 time = 1670
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=1670.05n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 1670
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=1670.05n

* CHECK dout0_2 Vdout0_2ck166 = 1.8 time = 1670
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=1670.05n

* CHECK dout0_3 Vdout0_3ck166 = 0 time = 1670
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=1670.05n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 1670
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=1670.05n

* CHECK dout0_5 Vdout0_5ck166 = 1.8 time = 1670
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=1670.05n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 1670
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=1670.05n

* CHECK dout0_7 Vdout0_7ck166 = 1.8 time = 1670
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=1670.05n

* CHECK dout0_8 Vdout0_8ck166 = 1.8 time = 1670
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=1670.05n

* CHECK dout0_9 Vdout0_9ck166 = 1.8 time = 1670
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=1670.05n

* CHECK dout0_10 Vdout0_10ck166 = 1.8 time = 1670
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=1670.05n

* CHECK dout0_11 Vdout0_11ck166 = 1.8 time = 1670
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=1670.05n

* CHECK dout0_12 Vdout0_12ck166 = 0 time = 1670
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=1670.05n

* CHECK dout0_13 Vdout0_13ck166 = 0 time = 1670
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=1670.05n

* CHECK dout0_14 Vdout0_14ck166 = 1.8 time = 1670
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=1670.05n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 1670
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=1670.05n

* CHECK dout0_16 Vdout0_16ck166 = 0 time = 1670
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=1670.05n

* CHECK dout0_17 Vdout0_17ck166 = 1.8 time = 1670
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=1670.05n

* CHECK dout0_18 Vdout0_18ck166 = 0 time = 1670
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=1670.05n

* CHECK dout0_19 Vdout0_19ck166 = 1.8 time = 1670
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=1670.05n

* CHECK dout0_20 Vdout0_20ck166 = 0 time = 1670
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=1670.05n

* CHECK dout0_21 Vdout0_21ck166 = 1.8 time = 1670
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=1670.05n

* CHECK dout0_22 Vdout0_22ck166 = 0 time = 1670
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=1670.05n

* CHECK dout0_23 Vdout0_23ck166 = 1.8 time = 1670
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=1670.05n

* CHECK dout0_24 Vdout0_24ck166 = 1.8 time = 1670
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=1670.05n

* CHECK dout0_25 Vdout0_25ck166 = 0 time = 1670
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=1670.05n

* CHECK dout0_26 Vdout0_26ck166 = 1.8 time = 1670
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=1670.05n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 1670
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=1670.05n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 1670
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=1670.05n

* CHECK dout0_29 Vdout0_29ck166 = 0 time = 1670
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=1670.05n

* CHECK dout0_30 Vdout0_30ck166 = 0 time = 1670
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=1670.05n

* CHECK dout0_31 Vdout0_31ck166 = 0 time = 1670
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=1670.05n

* CHECK dout0_32 Vdout0_32ck166 = 0 time = 1670
.meas tran vdout0_32ck166 FIND v(dout0_32) AT=1670.05n

* CHECK dout0_33 Vdout0_33ck166 = 0 time = 1670
.meas tran vdout0_33ck166 FIND v(dout0_33) AT=1670.05n

* CHECK dout0_34 Vdout0_34ck166 = 0 time = 1670
.meas tran vdout0_34ck166 FIND v(dout0_34) AT=1670.05n

* CHECK dout0_35 Vdout0_35ck166 = 1.8 time = 1670
.meas tran vdout0_35ck166 FIND v(dout0_35) AT=1670.05n

* CHECK dout0_36 Vdout0_36ck166 = 0 time = 1670
.meas tran vdout0_36ck166 FIND v(dout0_36) AT=1670.05n

* CHECK dout0_37 Vdout0_37ck166 = 0 time = 1670
.meas tran vdout0_37ck166 FIND v(dout0_37) AT=1670.05n

* CHECK dout0_38 Vdout0_38ck166 = 1.8 time = 1670
.meas tran vdout0_38ck166 FIND v(dout0_38) AT=1670.05n

* CHECK dout0_39 Vdout0_39ck166 = 1.8 time = 1670
.meas tran vdout0_39ck166 FIND v(dout0_39) AT=1670.05n

* CHECK dout0_40 Vdout0_40ck166 = 1.8 time = 1670
.meas tran vdout0_40ck166 FIND v(dout0_40) AT=1670.05n

* CHECK dout0_41 Vdout0_41ck166 = 1.8 time = 1670
.meas tran vdout0_41ck166 FIND v(dout0_41) AT=1670.05n

* CHECK dout0_42 Vdout0_42ck166 = 0 time = 1670
.meas tran vdout0_42ck166 FIND v(dout0_42) AT=1670.05n

* CHECK dout0_43 Vdout0_43ck166 = 1.8 time = 1670
.meas tran vdout0_43ck166 FIND v(dout0_43) AT=1670.05n

* CHECK dout0_44 Vdout0_44ck166 = 1.8 time = 1670
.meas tran vdout0_44ck166 FIND v(dout0_44) AT=1670.05n

* CHECK dout0_45 Vdout0_45ck166 = 0 time = 1670
.meas tran vdout0_45ck166 FIND v(dout0_45) AT=1670.05n

* CHECK dout0_46 Vdout0_46ck166 = 1.8 time = 1670
.meas tran vdout0_46ck166 FIND v(dout0_46) AT=1670.05n

* CHECK dout0_47 Vdout0_47ck166 = 1.8 time = 1670
.meas tran vdout0_47ck166 FIND v(dout0_47) AT=1670.05n

* CHECK dout0_48 Vdout0_48ck166 = 0 time = 1670
.meas tran vdout0_48ck166 FIND v(dout0_48) AT=1670.05n

* CHECK dout0_49 Vdout0_49ck166 = 0 time = 1670
.meas tran vdout0_49ck166 FIND v(dout0_49) AT=1670.05n

* CHECK dout0_50 Vdout0_50ck166 = 0 time = 1670
.meas tran vdout0_50ck166 FIND v(dout0_50) AT=1670.05n

* CHECK dout0_51 Vdout0_51ck166 = 0 time = 1670
.meas tran vdout0_51ck166 FIND v(dout0_51) AT=1670.05n

* CHECK dout0_52 Vdout0_52ck166 = 0 time = 1670
.meas tran vdout0_52ck166 FIND v(dout0_52) AT=1670.05n

* CHECK dout0_53 Vdout0_53ck166 = 0 time = 1670
.meas tran vdout0_53ck166 FIND v(dout0_53) AT=1670.05n

* CHECK dout0_54 Vdout0_54ck166 = 0 time = 1670
.meas tran vdout0_54ck166 FIND v(dout0_54) AT=1670.05n

* CHECK dout0_55 Vdout0_55ck166 = 1.8 time = 1670
.meas tran vdout0_55ck166 FIND v(dout0_55) AT=1670.05n

* CHECK dout0_56 Vdout0_56ck166 = 0 time = 1670
.meas tran vdout0_56ck166 FIND v(dout0_56) AT=1670.05n

* CHECK dout0_57 Vdout0_57ck166 = 1.8 time = 1670
.meas tran vdout0_57ck166 FIND v(dout0_57) AT=1670.05n

* CHECK dout0_58 Vdout0_58ck166 = 1.8 time = 1670
.meas tran vdout0_58ck166 FIND v(dout0_58) AT=1670.05n

* CHECK dout0_59 Vdout0_59ck166 = 1.8 time = 1670
.meas tran vdout0_59ck166 FIND v(dout0_59) AT=1670.05n

* CHECK dout0_60 Vdout0_60ck166 = 1.8 time = 1670
.meas tran vdout0_60ck166 FIND v(dout0_60) AT=1670.05n

* CHECK dout0_61 Vdout0_61ck166 = 1.8 time = 1670
.meas tran vdout0_61ck166 FIND v(dout0_61) AT=1670.05n

* CHECK dout0_62 Vdout0_62ck166 = 0 time = 1670
.meas tran vdout0_62ck166 FIND v(dout0_62) AT=1670.05n

* CHECK dout0_63 Vdout0_63ck166 = 1.8 time = 1670
.meas tran vdout0_63ck166 FIND v(dout0_63) AT=1670.05n

* CHECK dout0_64 Vdout0_64ck166 = 0 time = 1670
.meas tran vdout0_64ck166 FIND v(dout0_64) AT=1670.05n

* CHECK dout0_0 Vdout0_0ck167 = 0 time = 1680
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=1680.05n

* CHECK dout0_1 Vdout0_1ck167 = 0 time = 1680
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=1680.05n

* CHECK dout0_2 Vdout0_2ck167 = 1.8 time = 1680
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=1680.05n

* CHECK dout0_3 Vdout0_3ck167 = 0 time = 1680
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=1680.05n

* CHECK dout0_4 Vdout0_4ck167 = 0 time = 1680
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=1680.05n

* CHECK dout0_5 Vdout0_5ck167 = 0 time = 1680
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=1680.05n

* CHECK dout0_6 Vdout0_6ck167 = 0 time = 1680
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=1680.05n

* CHECK dout0_7 Vdout0_7ck167 = 0 time = 1680
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=1680.05n

* CHECK dout0_8 Vdout0_8ck167 = 0 time = 1680
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=1680.05n

* CHECK dout0_9 Vdout0_9ck167 = 0 time = 1680
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=1680.05n

* CHECK dout0_10 Vdout0_10ck167 = 0 time = 1680
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=1680.05n

* CHECK dout0_11 Vdout0_11ck167 = 1.8 time = 1680
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=1680.05n

* CHECK dout0_12 Vdout0_12ck167 = 1.8 time = 1680
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=1680.05n

* CHECK dout0_13 Vdout0_13ck167 = 1.8 time = 1680
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=1680.05n

* CHECK dout0_14 Vdout0_14ck167 = 1.8 time = 1680
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=1680.05n

* CHECK dout0_15 Vdout0_15ck167 = 1.8 time = 1680
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=1680.05n

* CHECK dout0_16 Vdout0_16ck167 = 1.8 time = 1680
.meas tran vdout0_16ck167 FIND v(dout0_16) AT=1680.05n

* CHECK dout0_17 Vdout0_17ck167 = 1.8 time = 1680
.meas tran vdout0_17ck167 FIND v(dout0_17) AT=1680.05n

* CHECK dout0_18 Vdout0_18ck167 = 1.8 time = 1680
.meas tran vdout0_18ck167 FIND v(dout0_18) AT=1680.05n

* CHECK dout0_19 Vdout0_19ck167 = 0 time = 1680
.meas tran vdout0_19ck167 FIND v(dout0_19) AT=1680.05n

* CHECK dout0_20 Vdout0_20ck167 = 1.8 time = 1680
.meas tran vdout0_20ck167 FIND v(dout0_20) AT=1680.05n

* CHECK dout0_21 Vdout0_21ck167 = 1.8 time = 1680
.meas tran vdout0_21ck167 FIND v(dout0_21) AT=1680.05n

* CHECK dout0_22 Vdout0_22ck167 = 1.8 time = 1680
.meas tran vdout0_22ck167 FIND v(dout0_22) AT=1680.05n

* CHECK dout0_23 Vdout0_23ck167 = 0 time = 1680
.meas tran vdout0_23ck167 FIND v(dout0_23) AT=1680.05n

* CHECK dout0_24 Vdout0_24ck167 = 0 time = 1680
.meas tran vdout0_24ck167 FIND v(dout0_24) AT=1680.05n

* CHECK dout0_25 Vdout0_25ck167 = 1.8 time = 1680
.meas tran vdout0_25ck167 FIND v(dout0_25) AT=1680.05n

* CHECK dout0_26 Vdout0_26ck167 = 1.8 time = 1680
.meas tran vdout0_26ck167 FIND v(dout0_26) AT=1680.05n

* CHECK dout0_27 Vdout0_27ck167 = 0 time = 1680
.meas tran vdout0_27ck167 FIND v(dout0_27) AT=1680.05n

* CHECK dout0_28 Vdout0_28ck167 = 0 time = 1680
.meas tran vdout0_28ck167 FIND v(dout0_28) AT=1680.05n

* CHECK dout0_29 Vdout0_29ck167 = 1.8 time = 1680
.meas tran vdout0_29ck167 FIND v(dout0_29) AT=1680.05n

* CHECK dout0_30 Vdout0_30ck167 = 0 time = 1680
.meas tran vdout0_30ck167 FIND v(dout0_30) AT=1680.05n

* CHECK dout0_31 Vdout0_31ck167 = 1.8 time = 1680
.meas tran vdout0_31ck167 FIND v(dout0_31) AT=1680.05n

* CHECK dout0_32 Vdout0_32ck167 = 0 time = 1680
.meas tran vdout0_32ck167 FIND v(dout0_32) AT=1680.05n

* CHECK dout0_33 Vdout0_33ck167 = 1.8 time = 1680
.meas tran vdout0_33ck167 FIND v(dout0_33) AT=1680.05n

* CHECK dout0_34 Vdout0_34ck167 = 0 time = 1680
.meas tran vdout0_34ck167 FIND v(dout0_34) AT=1680.05n

* CHECK dout0_35 Vdout0_35ck167 = 1.8 time = 1680
.meas tran vdout0_35ck167 FIND v(dout0_35) AT=1680.05n

* CHECK dout0_36 Vdout0_36ck167 = 0 time = 1680
.meas tran vdout0_36ck167 FIND v(dout0_36) AT=1680.05n

* CHECK dout0_37 Vdout0_37ck167 = 0 time = 1680
.meas tran vdout0_37ck167 FIND v(dout0_37) AT=1680.05n

* CHECK dout0_38 Vdout0_38ck167 = 1.8 time = 1680
.meas tran vdout0_38ck167 FIND v(dout0_38) AT=1680.05n

* CHECK dout0_39 Vdout0_39ck167 = 1.8 time = 1680
.meas tran vdout0_39ck167 FIND v(dout0_39) AT=1680.05n

* CHECK dout0_40 Vdout0_40ck167 = 0 time = 1680
.meas tran vdout0_40ck167 FIND v(dout0_40) AT=1680.05n

* CHECK dout0_41 Vdout0_41ck167 = 1.8 time = 1680
.meas tran vdout0_41ck167 FIND v(dout0_41) AT=1680.05n

* CHECK dout0_42 Vdout0_42ck167 = 0 time = 1680
.meas tran vdout0_42ck167 FIND v(dout0_42) AT=1680.05n

* CHECK dout0_43 Vdout0_43ck167 = 1.8 time = 1680
.meas tran vdout0_43ck167 FIND v(dout0_43) AT=1680.05n

* CHECK dout0_44 Vdout0_44ck167 = 1.8 time = 1680
.meas tran vdout0_44ck167 FIND v(dout0_44) AT=1680.05n

* CHECK dout0_45 Vdout0_45ck167 = 1.8 time = 1680
.meas tran vdout0_45ck167 FIND v(dout0_45) AT=1680.05n

* CHECK dout0_46 Vdout0_46ck167 = 0 time = 1680
.meas tran vdout0_46ck167 FIND v(dout0_46) AT=1680.05n

* CHECK dout0_47 Vdout0_47ck167 = 0 time = 1680
.meas tran vdout0_47ck167 FIND v(dout0_47) AT=1680.05n

* CHECK dout0_48 Vdout0_48ck167 = 1.8 time = 1680
.meas tran vdout0_48ck167 FIND v(dout0_48) AT=1680.05n

* CHECK dout0_49 Vdout0_49ck167 = 1.8 time = 1680
.meas tran vdout0_49ck167 FIND v(dout0_49) AT=1680.05n

* CHECK dout0_50 Vdout0_50ck167 = 0 time = 1680
.meas tran vdout0_50ck167 FIND v(dout0_50) AT=1680.05n

* CHECK dout0_51 Vdout0_51ck167 = 0 time = 1680
.meas tran vdout0_51ck167 FIND v(dout0_51) AT=1680.05n

* CHECK dout0_52 Vdout0_52ck167 = 1.8 time = 1680
.meas tran vdout0_52ck167 FIND v(dout0_52) AT=1680.05n

* CHECK dout0_53 Vdout0_53ck167 = 1.8 time = 1680
.meas tran vdout0_53ck167 FIND v(dout0_53) AT=1680.05n

* CHECK dout0_54 Vdout0_54ck167 = 1.8 time = 1680
.meas tran vdout0_54ck167 FIND v(dout0_54) AT=1680.05n

* CHECK dout0_55 Vdout0_55ck167 = 1.8 time = 1680
.meas tran vdout0_55ck167 FIND v(dout0_55) AT=1680.05n

* CHECK dout0_56 Vdout0_56ck167 = 1.8 time = 1680
.meas tran vdout0_56ck167 FIND v(dout0_56) AT=1680.05n

* CHECK dout0_57 Vdout0_57ck167 = 0 time = 1680
.meas tran vdout0_57ck167 FIND v(dout0_57) AT=1680.05n

* CHECK dout0_58 Vdout0_58ck167 = 0 time = 1680
.meas tran vdout0_58ck167 FIND v(dout0_58) AT=1680.05n

* CHECK dout0_59 Vdout0_59ck167 = 0 time = 1680
.meas tran vdout0_59ck167 FIND v(dout0_59) AT=1680.05n

* CHECK dout0_60 Vdout0_60ck167 = 0 time = 1680
.meas tran vdout0_60ck167 FIND v(dout0_60) AT=1680.05n

* CHECK dout0_61 Vdout0_61ck167 = 1.8 time = 1680
.meas tran vdout0_61ck167 FIND v(dout0_61) AT=1680.05n

* CHECK dout0_62 Vdout0_62ck167 = 1.8 time = 1680
.meas tran vdout0_62ck167 FIND v(dout0_62) AT=1680.05n

* CHECK dout0_63 Vdout0_63ck167 = 1.8 time = 1680
.meas tran vdout0_63ck167 FIND v(dout0_63) AT=1680.05n

* CHECK dout0_64 Vdout0_64ck167 = 0 time = 1680
.meas tran vdout0_64ck167 FIND v(dout0_64) AT=1680.05n

* CHECK dout0_0 Vdout0_0ck168 = 1.8 time = 1690
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=1690.05n

* CHECK dout0_1 Vdout0_1ck168 = 1.8 time = 1690
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=1690.05n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 1690
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=1690.05n

* CHECK dout0_3 Vdout0_3ck168 = 1.8 time = 1690
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=1690.05n

* CHECK dout0_4 Vdout0_4ck168 = 1.8 time = 1690
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=1690.05n

* CHECK dout0_5 Vdout0_5ck168 = 1.8 time = 1690
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=1690.05n

* CHECK dout0_6 Vdout0_6ck168 = 1.8 time = 1690
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=1690.05n

* CHECK dout0_7 Vdout0_7ck168 = 1.8 time = 1690
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=1690.05n

* CHECK dout0_8 Vdout0_8ck168 = 1.8 time = 1690
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=1690.05n

* CHECK dout0_9 Vdout0_9ck168 = 1.8 time = 1690
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=1690.05n

* CHECK dout0_10 Vdout0_10ck168 = 1.8 time = 1690
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=1690.05n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 1690
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=1690.05n

* CHECK dout0_12 Vdout0_12ck168 = 0 time = 1690
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=1690.05n

* CHECK dout0_13 Vdout0_13ck168 = 1.8 time = 1690
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=1690.05n

* CHECK dout0_14 Vdout0_14ck168 = 0 time = 1690
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=1690.05n

* CHECK dout0_15 Vdout0_15ck168 = 1.8 time = 1690
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=1690.05n

* CHECK dout0_16 Vdout0_16ck168 = 1.8 time = 1690
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=1690.05n

* CHECK dout0_17 Vdout0_17ck168 = 0 time = 1690
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=1690.05n

* CHECK dout0_18 Vdout0_18ck168 = 1.8 time = 1690
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=1690.05n

* CHECK dout0_19 Vdout0_19ck168 = 0 time = 1690
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=1690.05n

* CHECK dout0_20 Vdout0_20ck168 = 0 time = 1690
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=1690.05n

* CHECK dout0_21 Vdout0_21ck168 = 0 time = 1690
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=1690.05n

* CHECK dout0_22 Vdout0_22ck168 = 1.8 time = 1690
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=1690.05n

* CHECK dout0_23 Vdout0_23ck168 = 1.8 time = 1690
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=1690.05n

* CHECK dout0_24 Vdout0_24ck168 = 0 time = 1690
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=1690.05n

* CHECK dout0_25 Vdout0_25ck168 = 1.8 time = 1690
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=1690.05n

* CHECK dout0_26 Vdout0_26ck168 = 1.8 time = 1690
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=1690.05n

* CHECK dout0_27 Vdout0_27ck168 = 0 time = 1690
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=1690.05n

* CHECK dout0_28 Vdout0_28ck168 = 1.8 time = 1690
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=1690.05n

* CHECK dout0_29 Vdout0_29ck168 = 1.8 time = 1690
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=1690.05n

* CHECK dout0_30 Vdout0_30ck168 = 1.8 time = 1690
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=1690.05n

* CHECK dout0_31 Vdout0_31ck168 = 1.8 time = 1690
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=1690.05n

* CHECK dout0_32 Vdout0_32ck168 = 0 time = 1690
.meas tran vdout0_32ck168 FIND v(dout0_32) AT=1690.05n

* CHECK dout0_33 Vdout0_33ck168 = 1.8 time = 1690
.meas tran vdout0_33ck168 FIND v(dout0_33) AT=1690.05n

* CHECK dout0_34 Vdout0_34ck168 = 0 time = 1690
.meas tran vdout0_34ck168 FIND v(dout0_34) AT=1690.05n

* CHECK dout0_35 Vdout0_35ck168 = 0 time = 1690
.meas tran vdout0_35ck168 FIND v(dout0_35) AT=1690.05n

* CHECK dout0_36 Vdout0_36ck168 = 0 time = 1690
.meas tran vdout0_36ck168 FIND v(dout0_36) AT=1690.05n

* CHECK dout0_37 Vdout0_37ck168 = 1.8 time = 1690
.meas tran vdout0_37ck168 FIND v(dout0_37) AT=1690.05n

* CHECK dout0_38 Vdout0_38ck168 = 0 time = 1690
.meas tran vdout0_38ck168 FIND v(dout0_38) AT=1690.05n

* CHECK dout0_39 Vdout0_39ck168 = 1.8 time = 1690
.meas tran vdout0_39ck168 FIND v(dout0_39) AT=1690.05n

* CHECK dout0_40 Vdout0_40ck168 = 0 time = 1690
.meas tran vdout0_40ck168 FIND v(dout0_40) AT=1690.05n

* CHECK dout0_41 Vdout0_41ck168 = 1.8 time = 1690
.meas tran vdout0_41ck168 FIND v(dout0_41) AT=1690.05n

* CHECK dout0_42 Vdout0_42ck168 = 1.8 time = 1690
.meas tran vdout0_42ck168 FIND v(dout0_42) AT=1690.05n

* CHECK dout0_43 Vdout0_43ck168 = 0 time = 1690
.meas tran vdout0_43ck168 FIND v(dout0_43) AT=1690.05n

* CHECK dout0_44 Vdout0_44ck168 = 0 time = 1690
.meas tran vdout0_44ck168 FIND v(dout0_44) AT=1690.05n

* CHECK dout0_45 Vdout0_45ck168 = 0 time = 1690
.meas tran vdout0_45ck168 FIND v(dout0_45) AT=1690.05n

* CHECK dout0_46 Vdout0_46ck168 = 0 time = 1690
.meas tran vdout0_46ck168 FIND v(dout0_46) AT=1690.05n

* CHECK dout0_47 Vdout0_47ck168 = 1.8 time = 1690
.meas tran vdout0_47ck168 FIND v(dout0_47) AT=1690.05n

* CHECK dout0_48 Vdout0_48ck168 = 0 time = 1690
.meas tran vdout0_48ck168 FIND v(dout0_48) AT=1690.05n

* CHECK dout0_49 Vdout0_49ck168 = 0 time = 1690
.meas tran vdout0_49ck168 FIND v(dout0_49) AT=1690.05n

* CHECK dout0_50 Vdout0_50ck168 = 0 time = 1690
.meas tran vdout0_50ck168 FIND v(dout0_50) AT=1690.05n

* CHECK dout0_51 Vdout0_51ck168 = 1.8 time = 1690
.meas tran vdout0_51ck168 FIND v(dout0_51) AT=1690.05n

* CHECK dout0_52 Vdout0_52ck168 = 1.8 time = 1690
.meas tran vdout0_52ck168 FIND v(dout0_52) AT=1690.05n

* CHECK dout0_53 Vdout0_53ck168 = 1.8 time = 1690
.meas tran vdout0_53ck168 FIND v(dout0_53) AT=1690.05n

* CHECK dout0_54 Vdout0_54ck168 = 1.8 time = 1690
.meas tran vdout0_54ck168 FIND v(dout0_54) AT=1690.05n

* CHECK dout0_55 Vdout0_55ck168 = 1.8 time = 1690
.meas tran vdout0_55ck168 FIND v(dout0_55) AT=1690.05n

* CHECK dout0_56 Vdout0_56ck168 = 0 time = 1690
.meas tran vdout0_56ck168 FIND v(dout0_56) AT=1690.05n

* CHECK dout0_57 Vdout0_57ck168 = 0 time = 1690
.meas tran vdout0_57ck168 FIND v(dout0_57) AT=1690.05n

* CHECK dout0_58 Vdout0_58ck168 = 0 time = 1690
.meas tran vdout0_58ck168 FIND v(dout0_58) AT=1690.05n

* CHECK dout0_59 Vdout0_59ck168 = 1.8 time = 1690
.meas tran vdout0_59ck168 FIND v(dout0_59) AT=1690.05n

* CHECK dout0_60 Vdout0_60ck168 = 0 time = 1690
.meas tran vdout0_60ck168 FIND v(dout0_60) AT=1690.05n

* CHECK dout0_61 Vdout0_61ck168 = 0 time = 1690
.meas tran vdout0_61ck168 FIND v(dout0_61) AT=1690.05n

* CHECK dout0_62 Vdout0_62ck168 = 1.8 time = 1690
.meas tran vdout0_62ck168 FIND v(dout0_62) AT=1690.05n

* CHECK dout0_63 Vdout0_63ck168 = 1.8 time = 1690
.meas tran vdout0_63ck168 FIND v(dout0_63) AT=1690.05n

* CHECK dout0_64 Vdout0_64ck168 = 0 time = 1690
.meas tran vdout0_64ck168 FIND v(dout0_64) AT=1690.05n

* CHECK dout0_0 Vdout0_0ck171 = 0 time = 1720
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=1720.05n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 1720
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=1720.05n

* CHECK dout0_2 Vdout0_2ck171 = 1.8 time = 1720
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=1720.05n

* CHECK dout0_3 Vdout0_3ck171 = 0 time = 1720
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=1720.05n

* CHECK dout0_4 Vdout0_4ck171 = 0 time = 1720
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=1720.05n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 1720
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=1720.05n

* CHECK dout0_6 Vdout0_6ck171 = 0 time = 1720
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=1720.05n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 1720
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=1720.05n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 1720
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=1720.05n

* CHECK dout0_9 Vdout0_9ck171 = 0 time = 1720
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=1720.05n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 1720
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=1720.05n

* CHECK dout0_11 Vdout0_11ck171 = 1.8 time = 1720
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=1720.05n

* CHECK dout0_12 Vdout0_12ck171 = 1.8 time = 1720
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=1720.05n

* CHECK dout0_13 Vdout0_13ck171 = 1.8 time = 1720
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=1720.05n

* CHECK dout0_14 Vdout0_14ck171 = 1.8 time = 1720
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=1720.05n

* CHECK dout0_15 Vdout0_15ck171 = 1.8 time = 1720
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=1720.05n

* CHECK dout0_16 Vdout0_16ck171 = 1.8 time = 1720
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=1720.05n

* CHECK dout0_17 Vdout0_17ck171 = 1.8 time = 1720
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=1720.05n

* CHECK dout0_18 Vdout0_18ck171 = 1.8 time = 1720
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=1720.05n

* CHECK dout0_19 Vdout0_19ck171 = 0 time = 1720
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=1720.05n

* CHECK dout0_20 Vdout0_20ck171 = 1.8 time = 1720
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=1720.05n

* CHECK dout0_21 Vdout0_21ck171 = 1.8 time = 1720
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=1720.05n

* CHECK dout0_22 Vdout0_22ck171 = 1.8 time = 1720
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=1720.05n

* CHECK dout0_23 Vdout0_23ck171 = 0 time = 1720
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=1720.05n

* CHECK dout0_24 Vdout0_24ck171 = 0 time = 1720
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=1720.05n

* CHECK dout0_25 Vdout0_25ck171 = 1.8 time = 1720
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=1720.05n

* CHECK dout0_26 Vdout0_26ck171 = 1.8 time = 1720
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=1720.05n

* CHECK dout0_27 Vdout0_27ck171 = 0 time = 1720
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=1720.05n

* CHECK dout0_28 Vdout0_28ck171 = 0 time = 1720
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=1720.05n

* CHECK dout0_29 Vdout0_29ck171 = 1.8 time = 1720
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=1720.05n

* CHECK dout0_30 Vdout0_30ck171 = 0 time = 1720
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=1720.05n

* CHECK dout0_31 Vdout0_31ck171 = 1.8 time = 1720
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=1720.05n

* CHECK dout0_32 Vdout0_32ck171 = 0 time = 1720
.meas tran vdout0_32ck171 FIND v(dout0_32) AT=1720.05n

* CHECK dout0_33 Vdout0_33ck171 = 1.8 time = 1720
.meas tran vdout0_33ck171 FIND v(dout0_33) AT=1720.05n

* CHECK dout0_34 Vdout0_34ck171 = 0 time = 1720
.meas tran vdout0_34ck171 FIND v(dout0_34) AT=1720.05n

* CHECK dout0_35 Vdout0_35ck171 = 1.8 time = 1720
.meas tran vdout0_35ck171 FIND v(dout0_35) AT=1720.05n

* CHECK dout0_36 Vdout0_36ck171 = 0 time = 1720
.meas tran vdout0_36ck171 FIND v(dout0_36) AT=1720.05n

* CHECK dout0_37 Vdout0_37ck171 = 0 time = 1720
.meas tran vdout0_37ck171 FIND v(dout0_37) AT=1720.05n

* CHECK dout0_38 Vdout0_38ck171 = 1.8 time = 1720
.meas tran vdout0_38ck171 FIND v(dout0_38) AT=1720.05n

* CHECK dout0_39 Vdout0_39ck171 = 1.8 time = 1720
.meas tran vdout0_39ck171 FIND v(dout0_39) AT=1720.05n

* CHECK dout0_40 Vdout0_40ck171 = 0 time = 1720
.meas tran vdout0_40ck171 FIND v(dout0_40) AT=1720.05n

* CHECK dout0_41 Vdout0_41ck171 = 1.8 time = 1720
.meas tran vdout0_41ck171 FIND v(dout0_41) AT=1720.05n

* CHECK dout0_42 Vdout0_42ck171 = 0 time = 1720
.meas tran vdout0_42ck171 FIND v(dout0_42) AT=1720.05n

* CHECK dout0_43 Vdout0_43ck171 = 1.8 time = 1720
.meas tran vdout0_43ck171 FIND v(dout0_43) AT=1720.05n

* CHECK dout0_44 Vdout0_44ck171 = 1.8 time = 1720
.meas tran vdout0_44ck171 FIND v(dout0_44) AT=1720.05n

* CHECK dout0_45 Vdout0_45ck171 = 1.8 time = 1720
.meas tran vdout0_45ck171 FIND v(dout0_45) AT=1720.05n

* CHECK dout0_46 Vdout0_46ck171 = 0 time = 1720
.meas tran vdout0_46ck171 FIND v(dout0_46) AT=1720.05n

* CHECK dout0_47 Vdout0_47ck171 = 0 time = 1720
.meas tran vdout0_47ck171 FIND v(dout0_47) AT=1720.05n

* CHECK dout0_48 Vdout0_48ck171 = 1.8 time = 1720
.meas tran vdout0_48ck171 FIND v(dout0_48) AT=1720.05n

* CHECK dout0_49 Vdout0_49ck171 = 1.8 time = 1720
.meas tran vdout0_49ck171 FIND v(dout0_49) AT=1720.05n

* CHECK dout0_50 Vdout0_50ck171 = 0 time = 1720
.meas tran vdout0_50ck171 FIND v(dout0_50) AT=1720.05n

* CHECK dout0_51 Vdout0_51ck171 = 0 time = 1720
.meas tran vdout0_51ck171 FIND v(dout0_51) AT=1720.05n

* CHECK dout0_52 Vdout0_52ck171 = 1.8 time = 1720
.meas tran vdout0_52ck171 FIND v(dout0_52) AT=1720.05n

* CHECK dout0_53 Vdout0_53ck171 = 1.8 time = 1720
.meas tran vdout0_53ck171 FIND v(dout0_53) AT=1720.05n

* CHECK dout0_54 Vdout0_54ck171 = 1.8 time = 1720
.meas tran vdout0_54ck171 FIND v(dout0_54) AT=1720.05n

* CHECK dout0_55 Vdout0_55ck171 = 1.8 time = 1720
.meas tran vdout0_55ck171 FIND v(dout0_55) AT=1720.05n

* CHECK dout0_56 Vdout0_56ck171 = 1.8 time = 1720
.meas tran vdout0_56ck171 FIND v(dout0_56) AT=1720.05n

* CHECK dout0_57 Vdout0_57ck171 = 0 time = 1720
.meas tran vdout0_57ck171 FIND v(dout0_57) AT=1720.05n

* CHECK dout0_58 Vdout0_58ck171 = 0 time = 1720
.meas tran vdout0_58ck171 FIND v(dout0_58) AT=1720.05n

* CHECK dout0_59 Vdout0_59ck171 = 0 time = 1720
.meas tran vdout0_59ck171 FIND v(dout0_59) AT=1720.05n

* CHECK dout0_60 Vdout0_60ck171 = 0 time = 1720
.meas tran vdout0_60ck171 FIND v(dout0_60) AT=1720.05n

* CHECK dout0_61 Vdout0_61ck171 = 1.8 time = 1720
.meas tran vdout0_61ck171 FIND v(dout0_61) AT=1720.05n

* CHECK dout0_62 Vdout0_62ck171 = 1.8 time = 1720
.meas tran vdout0_62ck171 FIND v(dout0_62) AT=1720.05n

* CHECK dout0_63 Vdout0_63ck171 = 1.8 time = 1720
.meas tran vdout0_63ck171 FIND v(dout0_63) AT=1720.05n

* CHECK dout0_64 Vdout0_64ck171 = 0 time = 1720
.meas tran vdout0_64ck171 FIND v(dout0_64) AT=1720.05n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 1730
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=1730.05n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 1730
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=1730.05n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 1730
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=1730.05n

* CHECK dout0_3 Vdout0_3ck172 = 0 time = 1730
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=1730.05n

* CHECK dout0_4 Vdout0_4ck172 = 1.8 time = 1730
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=1730.05n

* CHECK dout0_5 Vdout0_5ck172 = 1.8 time = 1730
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=1730.05n

* CHECK dout0_6 Vdout0_6ck172 = 1.8 time = 1730
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=1730.05n

* CHECK dout0_7 Vdout0_7ck172 = 1.8 time = 1730
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=1730.05n

* CHECK dout0_8 Vdout0_8ck172 = 1.8 time = 1730
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=1730.05n

* CHECK dout0_9 Vdout0_9ck172 = 1.8 time = 1730
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=1730.05n

* CHECK dout0_10 Vdout0_10ck172 = 1.8 time = 1730
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=1730.05n

* CHECK dout0_11 Vdout0_11ck172 = 1.8 time = 1730
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=1730.05n

* CHECK dout0_12 Vdout0_12ck172 = 1.8 time = 1730
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=1730.05n

* CHECK dout0_13 Vdout0_13ck172 = 0 time = 1730
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=1730.05n

* CHECK dout0_14 Vdout0_14ck172 = 1.8 time = 1730
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=1730.05n

* CHECK dout0_15 Vdout0_15ck172 = 1.8 time = 1730
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=1730.05n

* CHECK dout0_16 Vdout0_16ck172 = 1.8 time = 1730
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=1730.05n

* CHECK dout0_17 Vdout0_17ck172 = 0 time = 1730
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=1730.05n

* CHECK dout0_18 Vdout0_18ck172 = 0 time = 1730
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=1730.05n

* CHECK dout0_19 Vdout0_19ck172 = 0 time = 1730
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=1730.05n

* CHECK dout0_20 Vdout0_20ck172 = 0 time = 1730
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=1730.05n

* CHECK dout0_21 Vdout0_21ck172 = 1.8 time = 1730
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=1730.05n

* CHECK dout0_22 Vdout0_22ck172 = 0 time = 1730
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=1730.05n

* CHECK dout0_23 Vdout0_23ck172 = 0 time = 1730
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=1730.05n

* CHECK dout0_24 Vdout0_24ck172 = 0 time = 1730
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=1730.05n

* CHECK dout0_25 Vdout0_25ck172 = 1.8 time = 1730
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=1730.05n

* CHECK dout0_26 Vdout0_26ck172 = 0 time = 1730
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=1730.05n

* CHECK dout0_27 Vdout0_27ck172 = 0 time = 1730
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=1730.05n

* CHECK dout0_28 Vdout0_28ck172 = 0 time = 1730
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=1730.05n

* CHECK dout0_29 Vdout0_29ck172 = 0 time = 1730
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=1730.05n

* CHECK dout0_30 Vdout0_30ck172 = 0 time = 1730
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=1730.05n

* CHECK dout0_31 Vdout0_31ck172 = 0 time = 1730
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=1730.05n

* CHECK dout0_32 Vdout0_32ck172 = 1.8 time = 1730
.meas tran vdout0_32ck172 FIND v(dout0_32) AT=1730.05n

* CHECK dout0_33 Vdout0_33ck172 = 1.8 time = 1730
.meas tran vdout0_33ck172 FIND v(dout0_33) AT=1730.05n

* CHECK dout0_34 Vdout0_34ck172 = 1.8 time = 1730
.meas tran vdout0_34ck172 FIND v(dout0_34) AT=1730.05n

* CHECK dout0_35 Vdout0_35ck172 = 1.8 time = 1730
.meas tran vdout0_35ck172 FIND v(dout0_35) AT=1730.05n

* CHECK dout0_36 Vdout0_36ck172 = 1.8 time = 1730
.meas tran vdout0_36ck172 FIND v(dout0_36) AT=1730.05n

* CHECK dout0_37 Vdout0_37ck172 = 1.8 time = 1730
.meas tran vdout0_37ck172 FIND v(dout0_37) AT=1730.05n

* CHECK dout0_38 Vdout0_38ck172 = 0 time = 1730
.meas tran vdout0_38ck172 FIND v(dout0_38) AT=1730.05n

* CHECK dout0_39 Vdout0_39ck172 = 1.8 time = 1730
.meas tran vdout0_39ck172 FIND v(dout0_39) AT=1730.05n

* CHECK dout0_40 Vdout0_40ck172 = 0 time = 1730
.meas tran vdout0_40ck172 FIND v(dout0_40) AT=1730.05n

* CHECK dout0_41 Vdout0_41ck172 = 0 time = 1730
.meas tran vdout0_41ck172 FIND v(dout0_41) AT=1730.05n

* CHECK dout0_42 Vdout0_42ck172 = 0 time = 1730
.meas tran vdout0_42ck172 FIND v(dout0_42) AT=1730.05n

* CHECK dout0_43 Vdout0_43ck172 = 0 time = 1730
.meas tran vdout0_43ck172 FIND v(dout0_43) AT=1730.05n

* CHECK dout0_44 Vdout0_44ck172 = 1.8 time = 1730
.meas tran vdout0_44ck172 FIND v(dout0_44) AT=1730.05n

* CHECK dout0_45 Vdout0_45ck172 = 1.8 time = 1730
.meas tran vdout0_45ck172 FIND v(dout0_45) AT=1730.05n

* CHECK dout0_46 Vdout0_46ck172 = 1.8 time = 1730
.meas tran vdout0_46ck172 FIND v(dout0_46) AT=1730.05n

* CHECK dout0_47 Vdout0_47ck172 = 0 time = 1730
.meas tran vdout0_47ck172 FIND v(dout0_47) AT=1730.05n

* CHECK dout0_48 Vdout0_48ck172 = 0 time = 1730
.meas tran vdout0_48ck172 FIND v(dout0_48) AT=1730.05n

* CHECK dout0_49 Vdout0_49ck172 = 0 time = 1730
.meas tran vdout0_49ck172 FIND v(dout0_49) AT=1730.05n

* CHECK dout0_50 Vdout0_50ck172 = 0 time = 1730
.meas tran vdout0_50ck172 FIND v(dout0_50) AT=1730.05n

* CHECK dout0_51 Vdout0_51ck172 = 0 time = 1730
.meas tran vdout0_51ck172 FIND v(dout0_51) AT=1730.05n

* CHECK dout0_52 Vdout0_52ck172 = 1.8 time = 1730
.meas tran vdout0_52ck172 FIND v(dout0_52) AT=1730.05n

* CHECK dout0_53 Vdout0_53ck172 = 0 time = 1730
.meas tran vdout0_53ck172 FIND v(dout0_53) AT=1730.05n

* CHECK dout0_54 Vdout0_54ck172 = 1.8 time = 1730
.meas tran vdout0_54ck172 FIND v(dout0_54) AT=1730.05n

* CHECK dout0_55 Vdout0_55ck172 = 0 time = 1730
.meas tran vdout0_55ck172 FIND v(dout0_55) AT=1730.05n

* CHECK dout0_56 Vdout0_56ck172 = 0 time = 1730
.meas tran vdout0_56ck172 FIND v(dout0_56) AT=1730.05n

* CHECK dout0_57 Vdout0_57ck172 = 1.8 time = 1730
.meas tran vdout0_57ck172 FIND v(dout0_57) AT=1730.05n

* CHECK dout0_58 Vdout0_58ck172 = 0 time = 1730
.meas tran vdout0_58ck172 FIND v(dout0_58) AT=1730.05n

* CHECK dout0_59 Vdout0_59ck172 = 1.8 time = 1730
.meas tran vdout0_59ck172 FIND v(dout0_59) AT=1730.05n

* CHECK dout0_60 Vdout0_60ck172 = 0 time = 1730
.meas tran vdout0_60ck172 FIND v(dout0_60) AT=1730.05n

* CHECK dout0_61 Vdout0_61ck172 = 1.8 time = 1730
.meas tran vdout0_61ck172 FIND v(dout0_61) AT=1730.05n

* CHECK dout0_62 Vdout0_62ck172 = 0 time = 1730
.meas tran vdout0_62ck172 FIND v(dout0_62) AT=1730.05n

* CHECK dout0_63 Vdout0_63ck172 = 1.8 time = 1730
.meas tran vdout0_63ck172 FIND v(dout0_63) AT=1730.05n

* CHECK dout0_64 Vdout0_64ck172 = 0 time = 1730
.meas tran vdout0_64ck172 FIND v(dout0_64) AT=1730.05n

* CHECK dout0_0 Vdout0_0ck173 = 1.8 time = 1740
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=1740.05n

* CHECK dout0_1 Vdout0_1ck173 = 0 time = 1740
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=1740.05n

* CHECK dout0_2 Vdout0_2ck173 = 1.8 time = 1740
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=1740.05n

* CHECK dout0_3 Vdout0_3ck173 = 0 time = 1740
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=1740.05n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 1740
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=1740.05n

* CHECK dout0_5 Vdout0_5ck173 = 1.8 time = 1740
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=1740.05n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 1740
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=1740.05n

* CHECK dout0_7 Vdout0_7ck173 = 1.8 time = 1740
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=1740.05n

* CHECK dout0_8 Vdout0_8ck173 = 1.8 time = 1740
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=1740.05n

* CHECK dout0_9 Vdout0_9ck173 = 1.8 time = 1740
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=1740.05n

* CHECK dout0_10 Vdout0_10ck173 = 1.8 time = 1740
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=1740.05n

* CHECK dout0_11 Vdout0_11ck173 = 1.8 time = 1740
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=1740.05n

* CHECK dout0_12 Vdout0_12ck173 = 0 time = 1740
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=1740.05n

* CHECK dout0_13 Vdout0_13ck173 = 0 time = 1740
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=1740.05n

* CHECK dout0_14 Vdout0_14ck173 = 1.8 time = 1740
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=1740.05n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 1740
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=1740.05n

* CHECK dout0_16 Vdout0_16ck173 = 0 time = 1740
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=1740.05n

* CHECK dout0_17 Vdout0_17ck173 = 1.8 time = 1740
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=1740.05n

* CHECK dout0_18 Vdout0_18ck173 = 0 time = 1740
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=1740.05n

* CHECK dout0_19 Vdout0_19ck173 = 1.8 time = 1740
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=1740.05n

* CHECK dout0_20 Vdout0_20ck173 = 0 time = 1740
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=1740.05n

* CHECK dout0_21 Vdout0_21ck173 = 1.8 time = 1740
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=1740.05n

* CHECK dout0_22 Vdout0_22ck173 = 0 time = 1740
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=1740.05n

* CHECK dout0_23 Vdout0_23ck173 = 1.8 time = 1740
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=1740.05n

* CHECK dout0_24 Vdout0_24ck173 = 1.8 time = 1740
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=1740.05n

* CHECK dout0_25 Vdout0_25ck173 = 0 time = 1740
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=1740.05n

* CHECK dout0_26 Vdout0_26ck173 = 1.8 time = 1740
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=1740.05n

* CHECK dout0_27 Vdout0_27ck173 = 0 time = 1740
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=1740.05n

* CHECK dout0_28 Vdout0_28ck173 = 0 time = 1740
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=1740.05n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 1740
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=1740.05n

* CHECK dout0_30 Vdout0_30ck173 = 0 time = 1740
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=1740.05n

* CHECK dout0_31 Vdout0_31ck173 = 0 time = 1740
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=1740.05n

* CHECK dout0_32 Vdout0_32ck173 = 0 time = 1740
.meas tran vdout0_32ck173 FIND v(dout0_32) AT=1740.05n

* CHECK dout0_33 Vdout0_33ck173 = 0 time = 1740
.meas tran vdout0_33ck173 FIND v(dout0_33) AT=1740.05n

* CHECK dout0_34 Vdout0_34ck173 = 0 time = 1740
.meas tran vdout0_34ck173 FIND v(dout0_34) AT=1740.05n

* CHECK dout0_35 Vdout0_35ck173 = 1.8 time = 1740
.meas tran vdout0_35ck173 FIND v(dout0_35) AT=1740.05n

* CHECK dout0_36 Vdout0_36ck173 = 0 time = 1740
.meas tran vdout0_36ck173 FIND v(dout0_36) AT=1740.05n

* CHECK dout0_37 Vdout0_37ck173 = 0 time = 1740
.meas tran vdout0_37ck173 FIND v(dout0_37) AT=1740.05n

* CHECK dout0_38 Vdout0_38ck173 = 1.8 time = 1740
.meas tran vdout0_38ck173 FIND v(dout0_38) AT=1740.05n

* CHECK dout0_39 Vdout0_39ck173 = 1.8 time = 1740
.meas tran vdout0_39ck173 FIND v(dout0_39) AT=1740.05n

* CHECK dout0_40 Vdout0_40ck173 = 1.8 time = 1740
.meas tran vdout0_40ck173 FIND v(dout0_40) AT=1740.05n

* CHECK dout0_41 Vdout0_41ck173 = 1.8 time = 1740
.meas tran vdout0_41ck173 FIND v(dout0_41) AT=1740.05n

* CHECK dout0_42 Vdout0_42ck173 = 0 time = 1740
.meas tran vdout0_42ck173 FIND v(dout0_42) AT=1740.05n

* CHECK dout0_43 Vdout0_43ck173 = 1.8 time = 1740
.meas tran vdout0_43ck173 FIND v(dout0_43) AT=1740.05n

* CHECK dout0_44 Vdout0_44ck173 = 1.8 time = 1740
.meas tran vdout0_44ck173 FIND v(dout0_44) AT=1740.05n

* CHECK dout0_45 Vdout0_45ck173 = 0 time = 1740
.meas tran vdout0_45ck173 FIND v(dout0_45) AT=1740.05n

* CHECK dout0_46 Vdout0_46ck173 = 1.8 time = 1740
.meas tran vdout0_46ck173 FIND v(dout0_46) AT=1740.05n

* CHECK dout0_47 Vdout0_47ck173 = 1.8 time = 1740
.meas tran vdout0_47ck173 FIND v(dout0_47) AT=1740.05n

* CHECK dout0_48 Vdout0_48ck173 = 0 time = 1740
.meas tran vdout0_48ck173 FIND v(dout0_48) AT=1740.05n

* CHECK dout0_49 Vdout0_49ck173 = 0 time = 1740
.meas tran vdout0_49ck173 FIND v(dout0_49) AT=1740.05n

* CHECK dout0_50 Vdout0_50ck173 = 0 time = 1740
.meas tran vdout0_50ck173 FIND v(dout0_50) AT=1740.05n

* CHECK dout0_51 Vdout0_51ck173 = 0 time = 1740
.meas tran vdout0_51ck173 FIND v(dout0_51) AT=1740.05n

* CHECK dout0_52 Vdout0_52ck173 = 0 time = 1740
.meas tran vdout0_52ck173 FIND v(dout0_52) AT=1740.05n

* CHECK dout0_53 Vdout0_53ck173 = 0 time = 1740
.meas tran vdout0_53ck173 FIND v(dout0_53) AT=1740.05n

* CHECK dout0_54 Vdout0_54ck173 = 0 time = 1740
.meas tran vdout0_54ck173 FIND v(dout0_54) AT=1740.05n

* CHECK dout0_55 Vdout0_55ck173 = 1.8 time = 1740
.meas tran vdout0_55ck173 FIND v(dout0_55) AT=1740.05n

* CHECK dout0_56 Vdout0_56ck173 = 0 time = 1740
.meas tran vdout0_56ck173 FIND v(dout0_56) AT=1740.05n

* CHECK dout0_57 Vdout0_57ck173 = 1.8 time = 1740
.meas tran vdout0_57ck173 FIND v(dout0_57) AT=1740.05n

* CHECK dout0_58 Vdout0_58ck173 = 1.8 time = 1740
.meas tran vdout0_58ck173 FIND v(dout0_58) AT=1740.05n

* CHECK dout0_59 Vdout0_59ck173 = 1.8 time = 1740
.meas tran vdout0_59ck173 FIND v(dout0_59) AT=1740.05n

* CHECK dout0_60 Vdout0_60ck173 = 1.8 time = 1740
.meas tran vdout0_60ck173 FIND v(dout0_60) AT=1740.05n

* CHECK dout0_61 Vdout0_61ck173 = 1.8 time = 1740
.meas tran vdout0_61ck173 FIND v(dout0_61) AT=1740.05n

* CHECK dout0_62 Vdout0_62ck173 = 0 time = 1740
.meas tran vdout0_62ck173 FIND v(dout0_62) AT=1740.05n

* CHECK dout0_63 Vdout0_63ck173 = 1.8 time = 1740
.meas tran vdout0_63ck173 FIND v(dout0_63) AT=1740.05n

* CHECK dout0_64 Vdout0_64ck173 = 0 time = 1740
.meas tran vdout0_64ck173 FIND v(dout0_64) AT=1740.05n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 1750
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=1750.05n

* CHECK dout0_1 Vdout0_1ck174 = 0 time = 1750
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=1750.05n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 1750
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=1750.05n

* CHECK dout0_3 Vdout0_3ck174 = 0 time = 1750
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=1750.05n

* CHECK dout0_4 Vdout0_4ck174 = 1.8 time = 1750
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=1750.05n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 1750
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=1750.05n

* CHECK dout0_6 Vdout0_6ck174 = 1.8 time = 1750
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=1750.05n

* CHECK dout0_7 Vdout0_7ck174 = 1.8 time = 1750
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=1750.05n

* CHECK dout0_8 Vdout0_8ck174 = 0 time = 1750
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=1750.05n

* CHECK dout0_9 Vdout0_9ck174 = 1.8 time = 1750
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=1750.05n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 1750
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=1750.05n

* CHECK dout0_11 Vdout0_11ck174 = 1.8 time = 1750
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=1750.05n

* CHECK dout0_12 Vdout0_12ck174 = 0 time = 1750
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=1750.05n

* CHECK dout0_13 Vdout0_13ck174 = 1.8 time = 1750
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=1750.05n

* CHECK dout0_14 Vdout0_14ck174 = 1.8 time = 1750
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=1750.05n

* CHECK dout0_15 Vdout0_15ck174 = 1.8 time = 1750
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=1750.05n

* CHECK dout0_16 Vdout0_16ck174 = 0 time = 1750
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=1750.05n

* CHECK dout0_17 Vdout0_17ck174 = 1.8 time = 1750
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=1750.05n

* CHECK dout0_18 Vdout0_18ck174 = 1.8 time = 1750
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=1750.05n

* CHECK dout0_19 Vdout0_19ck174 = 1.8 time = 1750
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=1750.05n

* CHECK dout0_20 Vdout0_20ck174 = 0 time = 1750
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=1750.05n

* CHECK dout0_21 Vdout0_21ck174 = 0 time = 1750
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=1750.05n

* CHECK dout0_22 Vdout0_22ck174 = 1.8 time = 1750
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=1750.05n

* CHECK dout0_23 Vdout0_23ck174 = 1.8 time = 1750
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=1750.05n

* CHECK dout0_24 Vdout0_24ck174 = 0 time = 1750
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=1750.05n

* CHECK dout0_25 Vdout0_25ck174 = 1.8 time = 1750
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=1750.05n

* CHECK dout0_26 Vdout0_26ck174 = 1.8 time = 1750
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=1750.05n

* CHECK dout0_27 Vdout0_27ck174 = 1.8 time = 1750
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=1750.05n

* CHECK dout0_28 Vdout0_28ck174 = 1.8 time = 1750
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=1750.05n

* CHECK dout0_29 Vdout0_29ck174 = 0 time = 1750
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=1750.05n

* CHECK dout0_30 Vdout0_30ck174 = 0 time = 1750
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=1750.05n

* CHECK dout0_31 Vdout0_31ck174 = 1.8 time = 1750
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=1750.05n

* CHECK dout0_32 Vdout0_32ck174 = 1.8 time = 1750
.meas tran vdout0_32ck174 FIND v(dout0_32) AT=1750.05n

* CHECK dout0_33 Vdout0_33ck174 = 1.8 time = 1750
.meas tran vdout0_33ck174 FIND v(dout0_33) AT=1750.05n

* CHECK dout0_34 Vdout0_34ck174 = 0 time = 1750
.meas tran vdout0_34ck174 FIND v(dout0_34) AT=1750.05n

* CHECK dout0_35 Vdout0_35ck174 = 0 time = 1750
.meas tran vdout0_35ck174 FIND v(dout0_35) AT=1750.05n

* CHECK dout0_36 Vdout0_36ck174 = 1.8 time = 1750
.meas tran vdout0_36ck174 FIND v(dout0_36) AT=1750.05n

* CHECK dout0_37 Vdout0_37ck174 = 1.8 time = 1750
.meas tran vdout0_37ck174 FIND v(dout0_37) AT=1750.05n

* CHECK dout0_38 Vdout0_38ck174 = 1.8 time = 1750
.meas tran vdout0_38ck174 FIND v(dout0_38) AT=1750.05n

* CHECK dout0_39 Vdout0_39ck174 = 0 time = 1750
.meas tran vdout0_39ck174 FIND v(dout0_39) AT=1750.05n

* CHECK dout0_40 Vdout0_40ck174 = 1.8 time = 1750
.meas tran vdout0_40ck174 FIND v(dout0_40) AT=1750.05n

* CHECK dout0_41 Vdout0_41ck174 = 0 time = 1750
.meas tran vdout0_41ck174 FIND v(dout0_41) AT=1750.05n

* CHECK dout0_42 Vdout0_42ck174 = 1.8 time = 1750
.meas tran vdout0_42ck174 FIND v(dout0_42) AT=1750.05n

* CHECK dout0_43 Vdout0_43ck174 = 1.8 time = 1750
.meas tran vdout0_43ck174 FIND v(dout0_43) AT=1750.05n

* CHECK dout0_44 Vdout0_44ck174 = 0 time = 1750
.meas tran vdout0_44ck174 FIND v(dout0_44) AT=1750.05n

* CHECK dout0_45 Vdout0_45ck174 = 1.8 time = 1750
.meas tran vdout0_45ck174 FIND v(dout0_45) AT=1750.05n

* CHECK dout0_46 Vdout0_46ck174 = 1.8 time = 1750
.meas tran vdout0_46ck174 FIND v(dout0_46) AT=1750.05n

* CHECK dout0_47 Vdout0_47ck174 = 0 time = 1750
.meas tran vdout0_47ck174 FIND v(dout0_47) AT=1750.05n

* CHECK dout0_48 Vdout0_48ck174 = 1.8 time = 1750
.meas tran vdout0_48ck174 FIND v(dout0_48) AT=1750.05n

* CHECK dout0_49 Vdout0_49ck174 = 0 time = 1750
.meas tran vdout0_49ck174 FIND v(dout0_49) AT=1750.05n

* CHECK dout0_50 Vdout0_50ck174 = 0 time = 1750
.meas tran vdout0_50ck174 FIND v(dout0_50) AT=1750.05n

* CHECK dout0_51 Vdout0_51ck174 = 0 time = 1750
.meas tran vdout0_51ck174 FIND v(dout0_51) AT=1750.05n

* CHECK dout0_52 Vdout0_52ck174 = 0 time = 1750
.meas tran vdout0_52ck174 FIND v(dout0_52) AT=1750.05n

* CHECK dout0_53 Vdout0_53ck174 = 1.8 time = 1750
.meas tran vdout0_53ck174 FIND v(dout0_53) AT=1750.05n

* CHECK dout0_54 Vdout0_54ck174 = 1.8 time = 1750
.meas tran vdout0_54ck174 FIND v(dout0_54) AT=1750.05n

* CHECK dout0_55 Vdout0_55ck174 = 1.8 time = 1750
.meas tran vdout0_55ck174 FIND v(dout0_55) AT=1750.05n

* CHECK dout0_56 Vdout0_56ck174 = 0 time = 1750
.meas tran vdout0_56ck174 FIND v(dout0_56) AT=1750.05n

* CHECK dout0_57 Vdout0_57ck174 = 0 time = 1750
.meas tran vdout0_57ck174 FIND v(dout0_57) AT=1750.05n

* CHECK dout0_58 Vdout0_58ck174 = 1.8 time = 1750
.meas tran vdout0_58ck174 FIND v(dout0_58) AT=1750.05n

* CHECK dout0_59 Vdout0_59ck174 = 0 time = 1750
.meas tran vdout0_59ck174 FIND v(dout0_59) AT=1750.05n

* CHECK dout0_60 Vdout0_60ck174 = 0 time = 1750
.meas tran vdout0_60ck174 FIND v(dout0_60) AT=1750.05n

* CHECK dout0_61 Vdout0_61ck174 = 0 time = 1750
.meas tran vdout0_61ck174 FIND v(dout0_61) AT=1750.05n

* CHECK dout0_62 Vdout0_62ck174 = 1.8 time = 1750
.meas tran vdout0_62ck174 FIND v(dout0_62) AT=1750.05n

* CHECK dout0_63 Vdout0_63ck174 = 0 time = 1750
.meas tran vdout0_63ck174 FIND v(dout0_63) AT=1750.05n

* CHECK dout0_64 Vdout0_64ck174 = 0 time = 1750
.meas tran vdout0_64ck174 FIND v(dout0_64) AT=1750.05n

* CHECK dout0_0 Vdout0_0ck182 = 1.8 time = 1830
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=1830.05n

* CHECK dout0_1 Vdout0_1ck182 = 1.8 time = 1830
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=1830.05n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 1830
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=1830.05n

* CHECK dout0_3 Vdout0_3ck182 = 0 time = 1830
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=1830.05n

* CHECK dout0_4 Vdout0_4ck182 = 1.8 time = 1830
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=1830.05n

* CHECK dout0_5 Vdout0_5ck182 = 1.8 time = 1830
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=1830.05n

* CHECK dout0_6 Vdout0_6ck182 = 0 time = 1830
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=1830.05n

* CHECK dout0_7 Vdout0_7ck182 = 0 time = 1830
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=1830.05n

* CHECK dout0_8 Vdout0_8ck182 = 1.8 time = 1830
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=1830.05n

* CHECK dout0_9 Vdout0_9ck182 = 1.8 time = 1830
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=1830.05n

* CHECK dout0_10 Vdout0_10ck182 = 1.8 time = 1830
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=1830.05n

* CHECK dout0_11 Vdout0_11ck182 = 0 time = 1830
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=1830.05n

* CHECK dout0_12 Vdout0_12ck182 = 1.8 time = 1830
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=1830.05n

* CHECK dout0_13 Vdout0_13ck182 = 1.8 time = 1830
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=1830.05n

* CHECK dout0_14 Vdout0_14ck182 = 1.8 time = 1830
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=1830.05n

* CHECK dout0_15 Vdout0_15ck182 = 1.8 time = 1830
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=1830.05n

* CHECK dout0_16 Vdout0_16ck182 = 0 time = 1830
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=1830.05n

* CHECK dout0_17 Vdout0_17ck182 = 0 time = 1830
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=1830.05n

* CHECK dout0_18 Vdout0_18ck182 = 1.8 time = 1830
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=1830.05n

* CHECK dout0_19 Vdout0_19ck182 = 0 time = 1830
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=1830.05n

* CHECK dout0_20 Vdout0_20ck182 = 0 time = 1830
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=1830.05n

* CHECK dout0_21 Vdout0_21ck182 = 0 time = 1830
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=1830.05n

* CHECK dout0_22 Vdout0_22ck182 = 1.8 time = 1830
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=1830.05n

* CHECK dout0_23 Vdout0_23ck182 = 1.8 time = 1830
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=1830.05n

* CHECK dout0_24 Vdout0_24ck182 = 0 time = 1830
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=1830.05n

* CHECK dout0_25 Vdout0_25ck182 = 0 time = 1830
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=1830.05n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 1830
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=1830.05n

* CHECK dout0_27 Vdout0_27ck182 = 0 time = 1830
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=1830.05n

* CHECK dout0_28 Vdout0_28ck182 = 1.8 time = 1830
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=1830.05n

* CHECK dout0_29 Vdout0_29ck182 = 1.8 time = 1830
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=1830.05n

* CHECK dout0_30 Vdout0_30ck182 = 0 time = 1830
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=1830.05n

* CHECK dout0_31 Vdout0_31ck182 = 1.8 time = 1830
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=1830.05n

* CHECK dout0_32 Vdout0_32ck182 = 1.8 time = 1830
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=1830.05n

* CHECK dout0_33 Vdout0_33ck182 = 1.8 time = 1830
.meas tran vdout0_33ck182 FIND v(dout0_33) AT=1830.05n

* CHECK dout0_34 Vdout0_34ck182 = 1.8 time = 1830
.meas tran vdout0_34ck182 FIND v(dout0_34) AT=1830.05n

* CHECK dout0_35 Vdout0_35ck182 = 1.8 time = 1830
.meas tran vdout0_35ck182 FIND v(dout0_35) AT=1830.05n

* CHECK dout0_36 Vdout0_36ck182 = 0 time = 1830
.meas tran vdout0_36ck182 FIND v(dout0_36) AT=1830.05n

* CHECK dout0_37 Vdout0_37ck182 = 1.8 time = 1830
.meas tran vdout0_37ck182 FIND v(dout0_37) AT=1830.05n

* CHECK dout0_38 Vdout0_38ck182 = 0 time = 1830
.meas tran vdout0_38ck182 FIND v(dout0_38) AT=1830.05n

* CHECK dout0_39 Vdout0_39ck182 = 0 time = 1830
.meas tran vdout0_39ck182 FIND v(dout0_39) AT=1830.05n

* CHECK dout0_40 Vdout0_40ck182 = 0 time = 1830
.meas tran vdout0_40ck182 FIND v(dout0_40) AT=1830.05n

* CHECK dout0_41 Vdout0_41ck182 = 1.8 time = 1830
.meas tran vdout0_41ck182 FIND v(dout0_41) AT=1830.05n

* CHECK dout0_42 Vdout0_42ck182 = 1.8 time = 1830
.meas tran vdout0_42ck182 FIND v(dout0_42) AT=1830.05n

* CHECK dout0_43 Vdout0_43ck182 = 0 time = 1830
.meas tran vdout0_43ck182 FIND v(dout0_43) AT=1830.05n

* CHECK dout0_44 Vdout0_44ck182 = 1.8 time = 1830
.meas tran vdout0_44ck182 FIND v(dout0_44) AT=1830.05n

* CHECK dout0_45 Vdout0_45ck182 = 0 time = 1830
.meas tran vdout0_45ck182 FIND v(dout0_45) AT=1830.05n

* CHECK dout0_46 Vdout0_46ck182 = 0 time = 1830
.meas tran vdout0_46ck182 FIND v(dout0_46) AT=1830.05n

* CHECK dout0_47 Vdout0_47ck182 = 0 time = 1830
.meas tran vdout0_47ck182 FIND v(dout0_47) AT=1830.05n

* CHECK dout0_48 Vdout0_48ck182 = 1.8 time = 1830
.meas tran vdout0_48ck182 FIND v(dout0_48) AT=1830.05n

* CHECK dout0_49 Vdout0_49ck182 = 1.8 time = 1830
.meas tran vdout0_49ck182 FIND v(dout0_49) AT=1830.05n

* CHECK dout0_50 Vdout0_50ck182 = 1.8 time = 1830
.meas tran vdout0_50ck182 FIND v(dout0_50) AT=1830.05n

* CHECK dout0_51 Vdout0_51ck182 = 1.8 time = 1830
.meas tran vdout0_51ck182 FIND v(dout0_51) AT=1830.05n

* CHECK dout0_52 Vdout0_52ck182 = 1.8 time = 1830
.meas tran vdout0_52ck182 FIND v(dout0_52) AT=1830.05n

* CHECK dout0_53 Vdout0_53ck182 = 0 time = 1830
.meas tran vdout0_53ck182 FIND v(dout0_53) AT=1830.05n

* CHECK dout0_54 Vdout0_54ck182 = 0 time = 1830
.meas tran vdout0_54ck182 FIND v(dout0_54) AT=1830.05n

* CHECK dout0_55 Vdout0_55ck182 = 1.8 time = 1830
.meas tran vdout0_55ck182 FIND v(dout0_55) AT=1830.05n

* CHECK dout0_56 Vdout0_56ck182 = 1.8 time = 1830
.meas tran vdout0_56ck182 FIND v(dout0_56) AT=1830.05n

* CHECK dout0_57 Vdout0_57ck182 = 0 time = 1830
.meas tran vdout0_57ck182 FIND v(dout0_57) AT=1830.05n

* CHECK dout0_58 Vdout0_58ck182 = 1.8 time = 1830
.meas tran vdout0_58ck182 FIND v(dout0_58) AT=1830.05n

* CHECK dout0_59 Vdout0_59ck182 = 0 time = 1830
.meas tran vdout0_59ck182 FIND v(dout0_59) AT=1830.05n

* CHECK dout0_60 Vdout0_60ck182 = 1.8 time = 1830
.meas tran vdout0_60ck182 FIND v(dout0_60) AT=1830.05n

* CHECK dout0_61 Vdout0_61ck182 = 0 time = 1830
.meas tran vdout0_61ck182 FIND v(dout0_61) AT=1830.05n

* CHECK dout0_62 Vdout0_62ck182 = 1.8 time = 1830
.meas tran vdout0_62ck182 FIND v(dout0_62) AT=1830.05n

* CHECK dout0_63 Vdout0_63ck182 = 0 time = 1830
.meas tran vdout0_63ck182 FIND v(dout0_63) AT=1830.05n

* CHECK dout0_64 Vdout0_64ck182 = 0 time = 1830
.meas tran vdout0_64ck182 FIND v(dout0_64) AT=1830.05n

* CHECK dout0_0 Vdout0_0ck186 = 0 time = 1870
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=1870.05n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 1870
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=1870.05n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 1870
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=1870.05n

* CHECK dout0_3 Vdout0_3ck186 = 0 time = 1870
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=1870.05n

* CHECK dout0_4 Vdout0_4ck186 = 1.8 time = 1870
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=1870.05n

* CHECK dout0_5 Vdout0_5ck186 = 1.8 time = 1870
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=1870.05n

* CHECK dout0_6 Vdout0_6ck186 = 1.8 time = 1870
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=1870.05n

* CHECK dout0_7 Vdout0_7ck186 = 1.8 time = 1870
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=1870.05n

* CHECK dout0_8 Vdout0_8ck186 = 1.8 time = 1870
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=1870.05n

* CHECK dout0_9 Vdout0_9ck186 = 1.8 time = 1870
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=1870.05n

* CHECK dout0_10 Vdout0_10ck186 = 1.8 time = 1870
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=1870.05n

* CHECK dout0_11 Vdout0_11ck186 = 1.8 time = 1870
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=1870.05n

* CHECK dout0_12 Vdout0_12ck186 = 1.8 time = 1870
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=1870.05n

* CHECK dout0_13 Vdout0_13ck186 = 0 time = 1870
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=1870.05n

* CHECK dout0_14 Vdout0_14ck186 = 1.8 time = 1870
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=1870.05n

* CHECK dout0_15 Vdout0_15ck186 = 1.8 time = 1870
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=1870.05n

* CHECK dout0_16 Vdout0_16ck186 = 1.8 time = 1870
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=1870.05n

* CHECK dout0_17 Vdout0_17ck186 = 0 time = 1870
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=1870.05n

* CHECK dout0_18 Vdout0_18ck186 = 0 time = 1870
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=1870.05n

* CHECK dout0_19 Vdout0_19ck186 = 0 time = 1870
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=1870.05n

* CHECK dout0_20 Vdout0_20ck186 = 0 time = 1870
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=1870.05n

* CHECK dout0_21 Vdout0_21ck186 = 1.8 time = 1870
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=1870.05n

* CHECK dout0_22 Vdout0_22ck186 = 0 time = 1870
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=1870.05n

* CHECK dout0_23 Vdout0_23ck186 = 0 time = 1870
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=1870.05n

* CHECK dout0_24 Vdout0_24ck186 = 0 time = 1870
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=1870.05n

* CHECK dout0_25 Vdout0_25ck186 = 1.8 time = 1870
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=1870.05n

* CHECK dout0_26 Vdout0_26ck186 = 0 time = 1870
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=1870.05n

* CHECK dout0_27 Vdout0_27ck186 = 0 time = 1870
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=1870.05n

* CHECK dout0_28 Vdout0_28ck186 = 0 time = 1870
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=1870.05n

* CHECK dout0_29 Vdout0_29ck186 = 0 time = 1870
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=1870.05n

* CHECK dout0_30 Vdout0_30ck186 = 0 time = 1870
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=1870.05n

* CHECK dout0_31 Vdout0_31ck186 = 0 time = 1870
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=1870.05n

* CHECK dout0_32 Vdout0_32ck186 = 1.8 time = 1870
.meas tran vdout0_32ck186 FIND v(dout0_32) AT=1870.05n

* CHECK dout0_33 Vdout0_33ck186 = 1.8 time = 1870
.meas tran vdout0_33ck186 FIND v(dout0_33) AT=1870.05n

* CHECK dout0_34 Vdout0_34ck186 = 1.8 time = 1870
.meas tran vdout0_34ck186 FIND v(dout0_34) AT=1870.05n

* CHECK dout0_35 Vdout0_35ck186 = 1.8 time = 1870
.meas tran vdout0_35ck186 FIND v(dout0_35) AT=1870.05n

* CHECK dout0_36 Vdout0_36ck186 = 1.8 time = 1870
.meas tran vdout0_36ck186 FIND v(dout0_36) AT=1870.05n

* CHECK dout0_37 Vdout0_37ck186 = 1.8 time = 1870
.meas tran vdout0_37ck186 FIND v(dout0_37) AT=1870.05n

* CHECK dout0_38 Vdout0_38ck186 = 0 time = 1870
.meas tran vdout0_38ck186 FIND v(dout0_38) AT=1870.05n

* CHECK dout0_39 Vdout0_39ck186 = 1.8 time = 1870
.meas tran vdout0_39ck186 FIND v(dout0_39) AT=1870.05n

* CHECK dout0_40 Vdout0_40ck186 = 0 time = 1870
.meas tran vdout0_40ck186 FIND v(dout0_40) AT=1870.05n

* CHECK dout0_41 Vdout0_41ck186 = 0 time = 1870
.meas tran vdout0_41ck186 FIND v(dout0_41) AT=1870.05n

* CHECK dout0_42 Vdout0_42ck186 = 0 time = 1870
.meas tran vdout0_42ck186 FIND v(dout0_42) AT=1870.05n

* CHECK dout0_43 Vdout0_43ck186 = 0 time = 1870
.meas tran vdout0_43ck186 FIND v(dout0_43) AT=1870.05n

* CHECK dout0_44 Vdout0_44ck186 = 1.8 time = 1870
.meas tran vdout0_44ck186 FIND v(dout0_44) AT=1870.05n

* CHECK dout0_45 Vdout0_45ck186 = 1.8 time = 1870
.meas tran vdout0_45ck186 FIND v(dout0_45) AT=1870.05n

* CHECK dout0_46 Vdout0_46ck186 = 1.8 time = 1870
.meas tran vdout0_46ck186 FIND v(dout0_46) AT=1870.05n

* CHECK dout0_47 Vdout0_47ck186 = 0 time = 1870
.meas tran vdout0_47ck186 FIND v(dout0_47) AT=1870.05n

* CHECK dout0_48 Vdout0_48ck186 = 0 time = 1870
.meas tran vdout0_48ck186 FIND v(dout0_48) AT=1870.05n

* CHECK dout0_49 Vdout0_49ck186 = 0 time = 1870
.meas tran vdout0_49ck186 FIND v(dout0_49) AT=1870.05n

* CHECK dout0_50 Vdout0_50ck186 = 0 time = 1870
.meas tran vdout0_50ck186 FIND v(dout0_50) AT=1870.05n

* CHECK dout0_51 Vdout0_51ck186 = 0 time = 1870
.meas tran vdout0_51ck186 FIND v(dout0_51) AT=1870.05n

* CHECK dout0_52 Vdout0_52ck186 = 1.8 time = 1870
.meas tran vdout0_52ck186 FIND v(dout0_52) AT=1870.05n

* CHECK dout0_53 Vdout0_53ck186 = 0 time = 1870
.meas tran vdout0_53ck186 FIND v(dout0_53) AT=1870.05n

* CHECK dout0_54 Vdout0_54ck186 = 1.8 time = 1870
.meas tran vdout0_54ck186 FIND v(dout0_54) AT=1870.05n

* CHECK dout0_55 Vdout0_55ck186 = 0 time = 1870
.meas tran vdout0_55ck186 FIND v(dout0_55) AT=1870.05n

* CHECK dout0_56 Vdout0_56ck186 = 0 time = 1870
.meas tran vdout0_56ck186 FIND v(dout0_56) AT=1870.05n

* CHECK dout0_57 Vdout0_57ck186 = 1.8 time = 1870
.meas tran vdout0_57ck186 FIND v(dout0_57) AT=1870.05n

* CHECK dout0_58 Vdout0_58ck186 = 0 time = 1870
.meas tran vdout0_58ck186 FIND v(dout0_58) AT=1870.05n

* CHECK dout0_59 Vdout0_59ck186 = 1.8 time = 1870
.meas tran vdout0_59ck186 FIND v(dout0_59) AT=1870.05n

* CHECK dout0_60 Vdout0_60ck186 = 0 time = 1870
.meas tran vdout0_60ck186 FIND v(dout0_60) AT=1870.05n

* CHECK dout0_61 Vdout0_61ck186 = 1.8 time = 1870
.meas tran vdout0_61ck186 FIND v(dout0_61) AT=1870.05n

* CHECK dout0_62 Vdout0_62ck186 = 0 time = 1870
.meas tran vdout0_62ck186 FIND v(dout0_62) AT=1870.05n

* CHECK dout0_63 Vdout0_63ck186 = 1.8 time = 1870
.meas tran vdout0_63ck186 FIND v(dout0_63) AT=1870.05n

* CHECK dout0_64 Vdout0_64ck186 = 0 time = 1870
.meas tran vdout0_64ck186 FIND v(dout0_64) AT=1870.05n

* CHECK dout0_0 Vdout0_0ck188 = 1.8 time = 1890
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=1890.05n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 1890
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=1890.05n

* CHECK dout0_2 Vdout0_2ck188 = 1.8 time = 1890
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=1890.05n

* CHECK dout0_3 Vdout0_3ck188 = 0 time = 1890
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=1890.05n

* CHECK dout0_4 Vdout0_4ck188 = 0 time = 1890
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=1890.05n

* CHECK dout0_5 Vdout0_5ck188 = 1.8 time = 1890
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=1890.05n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 1890
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=1890.05n

* CHECK dout0_7 Vdout0_7ck188 = 1.8 time = 1890
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=1890.05n

* CHECK dout0_8 Vdout0_8ck188 = 1.8 time = 1890
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=1890.05n

* CHECK dout0_9 Vdout0_9ck188 = 1.8 time = 1890
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=1890.05n

* CHECK dout0_10 Vdout0_10ck188 = 1.8 time = 1890
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=1890.05n

* CHECK dout0_11 Vdout0_11ck188 = 1.8 time = 1890
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=1890.05n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 1890
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=1890.05n

* CHECK dout0_13 Vdout0_13ck188 = 0 time = 1890
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=1890.05n

* CHECK dout0_14 Vdout0_14ck188 = 1.8 time = 1890
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=1890.05n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 1890
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=1890.05n

* CHECK dout0_16 Vdout0_16ck188 = 0 time = 1890
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=1890.05n

* CHECK dout0_17 Vdout0_17ck188 = 1.8 time = 1890
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=1890.05n

* CHECK dout0_18 Vdout0_18ck188 = 0 time = 1890
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=1890.05n

* CHECK dout0_19 Vdout0_19ck188 = 1.8 time = 1890
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=1890.05n

* CHECK dout0_20 Vdout0_20ck188 = 0 time = 1890
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=1890.05n

* CHECK dout0_21 Vdout0_21ck188 = 1.8 time = 1890
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=1890.05n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 1890
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=1890.05n

* CHECK dout0_23 Vdout0_23ck188 = 1.8 time = 1890
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=1890.05n

* CHECK dout0_24 Vdout0_24ck188 = 1.8 time = 1890
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=1890.05n

* CHECK dout0_25 Vdout0_25ck188 = 0 time = 1890
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=1890.05n

* CHECK dout0_26 Vdout0_26ck188 = 1.8 time = 1890
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=1890.05n

* CHECK dout0_27 Vdout0_27ck188 = 0 time = 1890
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=1890.05n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 1890
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=1890.05n

* CHECK dout0_29 Vdout0_29ck188 = 0 time = 1890
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=1890.05n

* CHECK dout0_30 Vdout0_30ck188 = 0 time = 1890
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=1890.05n

* CHECK dout0_31 Vdout0_31ck188 = 0 time = 1890
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=1890.05n

* CHECK dout0_32 Vdout0_32ck188 = 0 time = 1890
.meas tran vdout0_32ck188 FIND v(dout0_32) AT=1890.05n

* CHECK dout0_33 Vdout0_33ck188 = 0 time = 1890
.meas tran vdout0_33ck188 FIND v(dout0_33) AT=1890.05n

* CHECK dout0_34 Vdout0_34ck188 = 0 time = 1890
.meas tran vdout0_34ck188 FIND v(dout0_34) AT=1890.05n

* CHECK dout0_35 Vdout0_35ck188 = 1.8 time = 1890
.meas tran vdout0_35ck188 FIND v(dout0_35) AT=1890.05n

* CHECK dout0_36 Vdout0_36ck188 = 0 time = 1890
.meas tran vdout0_36ck188 FIND v(dout0_36) AT=1890.05n

* CHECK dout0_37 Vdout0_37ck188 = 0 time = 1890
.meas tran vdout0_37ck188 FIND v(dout0_37) AT=1890.05n

* CHECK dout0_38 Vdout0_38ck188 = 1.8 time = 1890
.meas tran vdout0_38ck188 FIND v(dout0_38) AT=1890.05n

* CHECK dout0_39 Vdout0_39ck188 = 1.8 time = 1890
.meas tran vdout0_39ck188 FIND v(dout0_39) AT=1890.05n

* CHECK dout0_40 Vdout0_40ck188 = 1.8 time = 1890
.meas tran vdout0_40ck188 FIND v(dout0_40) AT=1890.05n

* CHECK dout0_41 Vdout0_41ck188 = 1.8 time = 1890
.meas tran vdout0_41ck188 FIND v(dout0_41) AT=1890.05n

* CHECK dout0_42 Vdout0_42ck188 = 0 time = 1890
.meas tran vdout0_42ck188 FIND v(dout0_42) AT=1890.05n

* CHECK dout0_43 Vdout0_43ck188 = 1.8 time = 1890
.meas tran vdout0_43ck188 FIND v(dout0_43) AT=1890.05n

* CHECK dout0_44 Vdout0_44ck188 = 1.8 time = 1890
.meas tran vdout0_44ck188 FIND v(dout0_44) AT=1890.05n

* CHECK dout0_45 Vdout0_45ck188 = 0 time = 1890
.meas tran vdout0_45ck188 FIND v(dout0_45) AT=1890.05n

* CHECK dout0_46 Vdout0_46ck188 = 1.8 time = 1890
.meas tran vdout0_46ck188 FIND v(dout0_46) AT=1890.05n

* CHECK dout0_47 Vdout0_47ck188 = 1.8 time = 1890
.meas tran vdout0_47ck188 FIND v(dout0_47) AT=1890.05n

* CHECK dout0_48 Vdout0_48ck188 = 0 time = 1890
.meas tran vdout0_48ck188 FIND v(dout0_48) AT=1890.05n

* CHECK dout0_49 Vdout0_49ck188 = 0 time = 1890
.meas tran vdout0_49ck188 FIND v(dout0_49) AT=1890.05n

* CHECK dout0_50 Vdout0_50ck188 = 0 time = 1890
.meas tran vdout0_50ck188 FIND v(dout0_50) AT=1890.05n

* CHECK dout0_51 Vdout0_51ck188 = 0 time = 1890
.meas tran vdout0_51ck188 FIND v(dout0_51) AT=1890.05n

* CHECK dout0_52 Vdout0_52ck188 = 0 time = 1890
.meas tran vdout0_52ck188 FIND v(dout0_52) AT=1890.05n

* CHECK dout0_53 Vdout0_53ck188 = 0 time = 1890
.meas tran vdout0_53ck188 FIND v(dout0_53) AT=1890.05n

* CHECK dout0_54 Vdout0_54ck188 = 0 time = 1890
.meas tran vdout0_54ck188 FIND v(dout0_54) AT=1890.05n

* CHECK dout0_55 Vdout0_55ck188 = 1.8 time = 1890
.meas tran vdout0_55ck188 FIND v(dout0_55) AT=1890.05n

* CHECK dout0_56 Vdout0_56ck188 = 0 time = 1890
.meas tran vdout0_56ck188 FIND v(dout0_56) AT=1890.05n

* CHECK dout0_57 Vdout0_57ck188 = 1.8 time = 1890
.meas tran vdout0_57ck188 FIND v(dout0_57) AT=1890.05n

* CHECK dout0_58 Vdout0_58ck188 = 1.8 time = 1890
.meas tran vdout0_58ck188 FIND v(dout0_58) AT=1890.05n

* CHECK dout0_59 Vdout0_59ck188 = 1.8 time = 1890
.meas tran vdout0_59ck188 FIND v(dout0_59) AT=1890.05n

* CHECK dout0_60 Vdout0_60ck188 = 1.8 time = 1890
.meas tran vdout0_60ck188 FIND v(dout0_60) AT=1890.05n

* CHECK dout0_61 Vdout0_61ck188 = 1.8 time = 1890
.meas tran vdout0_61ck188 FIND v(dout0_61) AT=1890.05n

* CHECK dout0_62 Vdout0_62ck188 = 0 time = 1890
.meas tran vdout0_62ck188 FIND v(dout0_62) AT=1890.05n

* CHECK dout0_63 Vdout0_63ck188 = 1.8 time = 1890
.meas tran vdout0_63ck188 FIND v(dout0_63) AT=1890.05n

* CHECK dout0_64 Vdout0_64ck188 = 0 time = 1890
.meas tran vdout0_64ck188 FIND v(dout0_64) AT=1890.05n

* CHECK dout0_0 Vdout0_0ck190 = 1.8 time = 1910
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=1910.05n

* CHECK dout0_1 Vdout0_1ck190 = 1.8 time = 1910
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=1910.05n

* CHECK dout0_2 Vdout0_2ck190 = 0 time = 1910
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=1910.05n

* CHECK dout0_3 Vdout0_3ck190 = 1.8 time = 1910
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=1910.05n

* CHECK dout0_4 Vdout0_4ck190 = 1.8 time = 1910
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=1910.05n

* CHECK dout0_5 Vdout0_5ck190 = 1.8 time = 1910
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=1910.05n

* CHECK dout0_6 Vdout0_6ck190 = 1.8 time = 1910
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=1910.05n

* CHECK dout0_7 Vdout0_7ck190 = 1.8 time = 1910
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=1910.05n

* CHECK dout0_8 Vdout0_8ck190 = 1.8 time = 1910
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=1910.05n

* CHECK dout0_9 Vdout0_9ck190 = 1.8 time = 1910
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=1910.05n

* CHECK dout0_10 Vdout0_10ck190 = 1.8 time = 1910
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=1910.05n

* CHECK dout0_11 Vdout0_11ck190 = 1.8 time = 1910
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=1910.05n

* CHECK dout0_12 Vdout0_12ck190 = 0 time = 1910
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=1910.05n

* CHECK dout0_13 Vdout0_13ck190 = 1.8 time = 1910
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=1910.05n

* CHECK dout0_14 Vdout0_14ck190 = 0 time = 1910
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=1910.05n

* CHECK dout0_15 Vdout0_15ck190 = 1.8 time = 1910
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=1910.05n

* CHECK dout0_16 Vdout0_16ck190 = 1.8 time = 1910
.meas tran vdout0_16ck190 FIND v(dout0_16) AT=1910.05n

* CHECK dout0_17 Vdout0_17ck190 = 0 time = 1910
.meas tran vdout0_17ck190 FIND v(dout0_17) AT=1910.05n

* CHECK dout0_18 Vdout0_18ck190 = 1.8 time = 1910
.meas tran vdout0_18ck190 FIND v(dout0_18) AT=1910.05n

* CHECK dout0_19 Vdout0_19ck190 = 0 time = 1910
.meas tran vdout0_19ck190 FIND v(dout0_19) AT=1910.05n

* CHECK dout0_20 Vdout0_20ck190 = 0 time = 1910
.meas tran vdout0_20ck190 FIND v(dout0_20) AT=1910.05n

* CHECK dout0_21 Vdout0_21ck190 = 0 time = 1910
.meas tran vdout0_21ck190 FIND v(dout0_21) AT=1910.05n

* CHECK dout0_22 Vdout0_22ck190 = 1.8 time = 1910
.meas tran vdout0_22ck190 FIND v(dout0_22) AT=1910.05n

* CHECK dout0_23 Vdout0_23ck190 = 1.8 time = 1910
.meas tran vdout0_23ck190 FIND v(dout0_23) AT=1910.05n

* CHECK dout0_24 Vdout0_24ck190 = 0 time = 1910
.meas tran vdout0_24ck190 FIND v(dout0_24) AT=1910.05n

* CHECK dout0_25 Vdout0_25ck190 = 1.8 time = 1910
.meas tran vdout0_25ck190 FIND v(dout0_25) AT=1910.05n

* CHECK dout0_26 Vdout0_26ck190 = 1.8 time = 1910
.meas tran vdout0_26ck190 FIND v(dout0_26) AT=1910.05n

* CHECK dout0_27 Vdout0_27ck190 = 0 time = 1910
.meas tran vdout0_27ck190 FIND v(dout0_27) AT=1910.05n

* CHECK dout0_28 Vdout0_28ck190 = 1.8 time = 1910
.meas tran vdout0_28ck190 FIND v(dout0_28) AT=1910.05n

* CHECK dout0_29 Vdout0_29ck190 = 1.8 time = 1910
.meas tran vdout0_29ck190 FIND v(dout0_29) AT=1910.05n

* CHECK dout0_30 Vdout0_30ck190 = 1.8 time = 1910
.meas tran vdout0_30ck190 FIND v(dout0_30) AT=1910.05n

* CHECK dout0_31 Vdout0_31ck190 = 1.8 time = 1910
.meas tran vdout0_31ck190 FIND v(dout0_31) AT=1910.05n

* CHECK dout0_32 Vdout0_32ck190 = 0 time = 1910
.meas tran vdout0_32ck190 FIND v(dout0_32) AT=1910.05n

* CHECK dout0_33 Vdout0_33ck190 = 1.8 time = 1910
.meas tran vdout0_33ck190 FIND v(dout0_33) AT=1910.05n

* CHECK dout0_34 Vdout0_34ck190 = 0 time = 1910
.meas tran vdout0_34ck190 FIND v(dout0_34) AT=1910.05n

* CHECK dout0_35 Vdout0_35ck190 = 0 time = 1910
.meas tran vdout0_35ck190 FIND v(dout0_35) AT=1910.05n

* CHECK dout0_36 Vdout0_36ck190 = 0 time = 1910
.meas tran vdout0_36ck190 FIND v(dout0_36) AT=1910.05n

* CHECK dout0_37 Vdout0_37ck190 = 1.8 time = 1910
.meas tran vdout0_37ck190 FIND v(dout0_37) AT=1910.05n

* CHECK dout0_38 Vdout0_38ck190 = 0 time = 1910
.meas tran vdout0_38ck190 FIND v(dout0_38) AT=1910.05n

* CHECK dout0_39 Vdout0_39ck190 = 1.8 time = 1910
.meas tran vdout0_39ck190 FIND v(dout0_39) AT=1910.05n

* CHECK dout0_40 Vdout0_40ck190 = 0 time = 1910
.meas tran vdout0_40ck190 FIND v(dout0_40) AT=1910.05n

* CHECK dout0_41 Vdout0_41ck190 = 1.8 time = 1910
.meas tran vdout0_41ck190 FIND v(dout0_41) AT=1910.05n

* CHECK dout0_42 Vdout0_42ck190 = 1.8 time = 1910
.meas tran vdout0_42ck190 FIND v(dout0_42) AT=1910.05n

* CHECK dout0_43 Vdout0_43ck190 = 0 time = 1910
.meas tran vdout0_43ck190 FIND v(dout0_43) AT=1910.05n

* CHECK dout0_44 Vdout0_44ck190 = 0 time = 1910
.meas tran vdout0_44ck190 FIND v(dout0_44) AT=1910.05n

* CHECK dout0_45 Vdout0_45ck190 = 0 time = 1910
.meas tran vdout0_45ck190 FIND v(dout0_45) AT=1910.05n

* CHECK dout0_46 Vdout0_46ck190 = 0 time = 1910
.meas tran vdout0_46ck190 FIND v(dout0_46) AT=1910.05n

* CHECK dout0_47 Vdout0_47ck190 = 1.8 time = 1910
.meas tran vdout0_47ck190 FIND v(dout0_47) AT=1910.05n

* CHECK dout0_48 Vdout0_48ck190 = 0 time = 1910
.meas tran vdout0_48ck190 FIND v(dout0_48) AT=1910.05n

* CHECK dout0_49 Vdout0_49ck190 = 0 time = 1910
.meas tran vdout0_49ck190 FIND v(dout0_49) AT=1910.05n

* CHECK dout0_50 Vdout0_50ck190 = 0 time = 1910
.meas tran vdout0_50ck190 FIND v(dout0_50) AT=1910.05n

* CHECK dout0_51 Vdout0_51ck190 = 1.8 time = 1910
.meas tran vdout0_51ck190 FIND v(dout0_51) AT=1910.05n

* CHECK dout0_52 Vdout0_52ck190 = 1.8 time = 1910
.meas tran vdout0_52ck190 FIND v(dout0_52) AT=1910.05n

* CHECK dout0_53 Vdout0_53ck190 = 1.8 time = 1910
.meas tran vdout0_53ck190 FIND v(dout0_53) AT=1910.05n

* CHECK dout0_54 Vdout0_54ck190 = 1.8 time = 1910
.meas tran vdout0_54ck190 FIND v(dout0_54) AT=1910.05n

* CHECK dout0_55 Vdout0_55ck190 = 1.8 time = 1910
.meas tran vdout0_55ck190 FIND v(dout0_55) AT=1910.05n

* CHECK dout0_56 Vdout0_56ck190 = 0 time = 1910
.meas tran vdout0_56ck190 FIND v(dout0_56) AT=1910.05n

* CHECK dout0_57 Vdout0_57ck190 = 0 time = 1910
.meas tran vdout0_57ck190 FIND v(dout0_57) AT=1910.05n

* CHECK dout0_58 Vdout0_58ck190 = 0 time = 1910
.meas tran vdout0_58ck190 FIND v(dout0_58) AT=1910.05n

* CHECK dout0_59 Vdout0_59ck190 = 1.8 time = 1910
.meas tran vdout0_59ck190 FIND v(dout0_59) AT=1910.05n

* CHECK dout0_60 Vdout0_60ck190 = 0 time = 1910
.meas tran vdout0_60ck190 FIND v(dout0_60) AT=1910.05n

* CHECK dout0_61 Vdout0_61ck190 = 0 time = 1910
.meas tran vdout0_61ck190 FIND v(dout0_61) AT=1910.05n

* CHECK dout0_62 Vdout0_62ck190 = 1.8 time = 1910
.meas tran vdout0_62ck190 FIND v(dout0_62) AT=1910.05n

* CHECK dout0_63 Vdout0_63ck190 = 1.8 time = 1910
.meas tran vdout0_63ck190 FIND v(dout0_63) AT=1910.05n

* CHECK dout0_64 Vdout0_64ck190 = 0 time = 1910
.meas tran vdout0_64ck190 FIND v(dout0_64) AT=1910.05n

* CHECK dout0_0 Vdout0_0ck191 = 1.8 time = 1920
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=1920.05n

* CHECK dout0_1 Vdout0_1ck191 = 0 time = 1920
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=1920.05n

* CHECK dout0_2 Vdout0_2ck191 = 1.8 time = 1920
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=1920.05n

* CHECK dout0_3 Vdout0_3ck191 = 0 time = 1920
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=1920.05n

* CHECK dout0_4 Vdout0_4ck191 = 0 time = 1920
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=1920.05n

* CHECK dout0_5 Vdout0_5ck191 = 1.8 time = 1920
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=1920.05n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 1920
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=1920.05n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 1920
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=1920.05n

* CHECK dout0_8 Vdout0_8ck191 = 1.8 time = 1920
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=1920.05n

* CHECK dout0_9 Vdout0_9ck191 = 1.8 time = 1920
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=1920.05n

* CHECK dout0_10 Vdout0_10ck191 = 1.8 time = 1920
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=1920.05n

* CHECK dout0_11 Vdout0_11ck191 = 1.8 time = 1920
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=1920.05n

* CHECK dout0_12 Vdout0_12ck191 = 0 time = 1920
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=1920.05n

* CHECK dout0_13 Vdout0_13ck191 = 0 time = 1920
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=1920.05n

* CHECK dout0_14 Vdout0_14ck191 = 1.8 time = 1920
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=1920.05n

* CHECK dout0_15 Vdout0_15ck191 = 0 time = 1920
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=1920.05n

* CHECK dout0_16 Vdout0_16ck191 = 0 time = 1920
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=1920.05n

* CHECK dout0_17 Vdout0_17ck191 = 1.8 time = 1920
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=1920.05n

* CHECK dout0_18 Vdout0_18ck191 = 0 time = 1920
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=1920.05n

* CHECK dout0_19 Vdout0_19ck191 = 1.8 time = 1920
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=1920.05n

* CHECK dout0_20 Vdout0_20ck191 = 0 time = 1920
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=1920.05n

* CHECK dout0_21 Vdout0_21ck191 = 1.8 time = 1920
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=1920.05n

* CHECK dout0_22 Vdout0_22ck191 = 0 time = 1920
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=1920.05n

* CHECK dout0_23 Vdout0_23ck191 = 1.8 time = 1920
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=1920.05n

* CHECK dout0_24 Vdout0_24ck191 = 1.8 time = 1920
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=1920.05n

* CHECK dout0_25 Vdout0_25ck191 = 0 time = 1920
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=1920.05n

* CHECK dout0_26 Vdout0_26ck191 = 1.8 time = 1920
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=1920.05n

* CHECK dout0_27 Vdout0_27ck191 = 0 time = 1920
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=1920.05n

* CHECK dout0_28 Vdout0_28ck191 = 0 time = 1920
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=1920.05n

* CHECK dout0_29 Vdout0_29ck191 = 0 time = 1920
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=1920.05n

* CHECK dout0_30 Vdout0_30ck191 = 0 time = 1920
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=1920.05n

* CHECK dout0_31 Vdout0_31ck191 = 0 time = 1920
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=1920.05n

* CHECK dout0_32 Vdout0_32ck191 = 0 time = 1920
.meas tran vdout0_32ck191 FIND v(dout0_32) AT=1920.05n

* CHECK dout0_33 Vdout0_33ck191 = 0 time = 1920
.meas tran vdout0_33ck191 FIND v(dout0_33) AT=1920.05n

* CHECK dout0_34 Vdout0_34ck191 = 0 time = 1920
.meas tran vdout0_34ck191 FIND v(dout0_34) AT=1920.05n

* CHECK dout0_35 Vdout0_35ck191 = 1.8 time = 1920
.meas tran vdout0_35ck191 FIND v(dout0_35) AT=1920.05n

* CHECK dout0_36 Vdout0_36ck191 = 0 time = 1920
.meas tran vdout0_36ck191 FIND v(dout0_36) AT=1920.05n

* CHECK dout0_37 Vdout0_37ck191 = 0 time = 1920
.meas tran vdout0_37ck191 FIND v(dout0_37) AT=1920.05n

* CHECK dout0_38 Vdout0_38ck191 = 1.8 time = 1920
.meas tran vdout0_38ck191 FIND v(dout0_38) AT=1920.05n

* CHECK dout0_39 Vdout0_39ck191 = 1.8 time = 1920
.meas tran vdout0_39ck191 FIND v(dout0_39) AT=1920.05n

* CHECK dout0_40 Vdout0_40ck191 = 1.8 time = 1920
.meas tran vdout0_40ck191 FIND v(dout0_40) AT=1920.05n

* CHECK dout0_41 Vdout0_41ck191 = 1.8 time = 1920
.meas tran vdout0_41ck191 FIND v(dout0_41) AT=1920.05n

* CHECK dout0_42 Vdout0_42ck191 = 0 time = 1920
.meas tran vdout0_42ck191 FIND v(dout0_42) AT=1920.05n

* CHECK dout0_43 Vdout0_43ck191 = 1.8 time = 1920
.meas tran vdout0_43ck191 FIND v(dout0_43) AT=1920.05n

* CHECK dout0_44 Vdout0_44ck191 = 1.8 time = 1920
.meas tran vdout0_44ck191 FIND v(dout0_44) AT=1920.05n

* CHECK dout0_45 Vdout0_45ck191 = 0 time = 1920
.meas tran vdout0_45ck191 FIND v(dout0_45) AT=1920.05n

* CHECK dout0_46 Vdout0_46ck191 = 1.8 time = 1920
.meas tran vdout0_46ck191 FIND v(dout0_46) AT=1920.05n

* CHECK dout0_47 Vdout0_47ck191 = 1.8 time = 1920
.meas tran vdout0_47ck191 FIND v(dout0_47) AT=1920.05n

* CHECK dout0_48 Vdout0_48ck191 = 0 time = 1920
.meas tran vdout0_48ck191 FIND v(dout0_48) AT=1920.05n

* CHECK dout0_49 Vdout0_49ck191 = 0 time = 1920
.meas tran vdout0_49ck191 FIND v(dout0_49) AT=1920.05n

* CHECK dout0_50 Vdout0_50ck191 = 0 time = 1920
.meas tran vdout0_50ck191 FIND v(dout0_50) AT=1920.05n

* CHECK dout0_51 Vdout0_51ck191 = 0 time = 1920
.meas tran vdout0_51ck191 FIND v(dout0_51) AT=1920.05n

* CHECK dout0_52 Vdout0_52ck191 = 0 time = 1920
.meas tran vdout0_52ck191 FIND v(dout0_52) AT=1920.05n

* CHECK dout0_53 Vdout0_53ck191 = 0 time = 1920
.meas tran vdout0_53ck191 FIND v(dout0_53) AT=1920.05n

* CHECK dout0_54 Vdout0_54ck191 = 0 time = 1920
.meas tran vdout0_54ck191 FIND v(dout0_54) AT=1920.05n

* CHECK dout0_55 Vdout0_55ck191 = 1.8 time = 1920
.meas tran vdout0_55ck191 FIND v(dout0_55) AT=1920.05n

* CHECK dout0_56 Vdout0_56ck191 = 0 time = 1920
.meas tran vdout0_56ck191 FIND v(dout0_56) AT=1920.05n

* CHECK dout0_57 Vdout0_57ck191 = 1.8 time = 1920
.meas tran vdout0_57ck191 FIND v(dout0_57) AT=1920.05n

* CHECK dout0_58 Vdout0_58ck191 = 1.8 time = 1920
.meas tran vdout0_58ck191 FIND v(dout0_58) AT=1920.05n

* CHECK dout0_59 Vdout0_59ck191 = 1.8 time = 1920
.meas tran vdout0_59ck191 FIND v(dout0_59) AT=1920.05n

* CHECK dout0_60 Vdout0_60ck191 = 1.8 time = 1920
.meas tran vdout0_60ck191 FIND v(dout0_60) AT=1920.05n

* CHECK dout0_61 Vdout0_61ck191 = 1.8 time = 1920
.meas tran vdout0_61ck191 FIND v(dout0_61) AT=1920.05n

* CHECK dout0_62 Vdout0_62ck191 = 0 time = 1920
.meas tran vdout0_62ck191 FIND v(dout0_62) AT=1920.05n

* CHECK dout0_63 Vdout0_63ck191 = 1.8 time = 1920
.meas tran vdout0_63ck191 FIND v(dout0_63) AT=1920.05n

* CHECK dout0_64 Vdout0_64ck191 = 0 time = 1920
.meas tran vdout0_64ck191 FIND v(dout0_64) AT=1920.05n

* CHECK dout0_0 Vdout0_0ck194 = 1.8 time = 1950
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=1950.05n

* CHECK dout0_1 Vdout0_1ck194 = 0 time = 1950
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=1950.05n

* CHECK dout0_2 Vdout0_2ck194 = 1.8 time = 1950
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=1950.05n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 1950
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=1950.05n

* CHECK dout0_4 Vdout0_4ck194 = 0 time = 1950
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=1950.05n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 1950
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=1950.05n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 1950
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=1950.05n

* CHECK dout0_7 Vdout0_7ck194 = 1.8 time = 1950
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=1950.05n

* CHECK dout0_8 Vdout0_8ck194 = 1.8 time = 1950
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=1950.05n

* CHECK dout0_9 Vdout0_9ck194 = 1.8 time = 1950
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=1950.05n

* CHECK dout0_10 Vdout0_10ck194 = 1.8 time = 1950
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=1950.05n

* CHECK dout0_11 Vdout0_11ck194 = 1.8 time = 1950
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=1950.05n

* CHECK dout0_12 Vdout0_12ck194 = 0 time = 1950
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=1950.05n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 1950
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=1950.05n

* CHECK dout0_14 Vdout0_14ck194 = 1.8 time = 1950
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=1950.05n

* CHECK dout0_15 Vdout0_15ck194 = 0 time = 1950
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=1950.05n

* CHECK dout0_16 Vdout0_16ck194 = 0 time = 1950
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=1950.05n

* CHECK dout0_17 Vdout0_17ck194 = 1.8 time = 1950
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=1950.05n

* CHECK dout0_18 Vdout0_18ck194 = 0 time = 1950
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=1950.05n

* CHECK dout0_19 Vdout0_19ck194 = 1.8 time = 1950
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=1950.05n

* CHECK dout0_20 Vdout0_20ck194 = 0 time = 1950
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=1950.05n

* CHECK dout0_21 Vdout0_21ck194 = 1.8 time = 1950
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=1950.05n

* CHECK dout0_22 Vdout0_22ck194 = 0 time = 1950
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=1950.05n

* CHECK dout0_23 Vdout0_23ck194 = 1.8 time = 1950
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=1950.05n

* CHECK dout0_24 Vdout0_24ck194 = 1.8 time = 1950
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=1950.05n

* CHECK dout0_25 Vdout0_25ck194 = 0 time = 1950
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=1950.05n

* CHECK dout0_26 Vdout0_26ck194 = 1.8 time = 1950
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=1950.05n

* CHECK dout0_27 Vdout0_27ck194 = 0 time = 1950
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=1950.05n

* CHECK dout0_28 Vdout0_28ck194 = 0 time = 1950
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=1950.05n

* CHECK dout0_29 Vdout0_29ck194 = 0 time = 1950
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=1950.05n

* CHECK dout0_30 Vdout0_30ck194 = 0 time = 1950
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=1950.05n

* CHECK dout0_31 Vdout0_31ck194 = 0 time = 1950
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=1950.05n

* CHECK dout0_32 Vdout0_32ck194 = 0 time = 1950
.meas tran vdout0_32ck194 FIND v(dout0_32) AT=1950.05n

* CHECK dout0_33 Vdout0_33ck194 = 0 time = 1950
.meas tran vdout0_33ck194 FIND v(dout0_33) AT=1950.05n

* CHECK dout0_34 Vdout0_34ck194 = 0 time = 1950
.meas tran vdout0_34ck194 FIND v(dout0_34) AT=1950.05n

* CHECK dout0_35 Vdout0_35ck194 = 1.8 time = 1950
.meas tran vdout0_35ck194 FIND v(dout0_35) AT=1950.05n

* CHECK dout0_36 Vdout0_36ck194 = 0 time = 1950
.meas tran vdout0_36ck194 FIND v(dout0_36) AT=1950.05n

* CHECK dout0_37 Vdout0_37ck194 = 0 time = 1950
.meas tran vdout0_37ck194 FIND v(dout0_37) AT=1950.05n

* CHECK dout0_38 Vdout0_38ck194 = 1.8 time = 1950
.meas tran vdout0_38ck194 FIND v(dout0_38) AT=1950.05n

* CHECK dout0_39 Vdout0_39ck194 = 1.8 time = 1950
.meas tran vdout0_39ck194 FIND v(dout0_39) AT=1950.05n

* CHECK dout0_40 Vdout0_40ck194 = 1.8 time = 1950
.meas tran vdout0_40ck194 FIND v(dout0_40) AT=1950.05n

* CHECK dout0_41 Vdout0_41ck194 = 1.8 time = 1950
.meas tran vdout0_41ck194 FIND v(dout0_41) AT=1950.05n

* CHECK dout0_42 Vdout0_42ck194 = 0 time = 1950
.meas tran vdout0_42ck194 FIND v(dout0_42) AT=1950.05n

* CHECK dout0_43 Vdout0_43ck194 = 1.8 time = 1950
.meas tran vdout0_43ck194 FIND v(dout0_43) AT=1950.05n

* CHECK dout0_44 Vdout0_44ck194 = 1.8 time = 1950
.meas tran vdout0_44ck194 FIND v(dout0_44) AT=1950.05n

* CHECK dout0_45 Vdout0_45ck194 = 0 time = 1950
.meas tran vdout0_45ck194 FIND v(dout0_45) AT=1950.05n

* CHECK dout0_46 Vdout0_46ck194 = 1.8 time = 1950
.meas tran vdout0_46ck194 FIND v(dout0_46) AT=1950.05n

* CHECK dout0_47 Vdout0_47ck194 = 1.8 time = 1950
.meas tran vdout0_47ck194 FIND v(dout0_47) AT=1950.05n

* CHECK dout0_48 Vdout0_48ck194 = 0 time = 1950
.meas tran vdout0_48ck194 FIND v(dout0_48) AT=1950.05n

* CHECK dout0_49 Vdout0_49ck194 = 0 time = 1950
.meas tran vdout0_49ck194 FIND v(dout0_49) AT=1950.05n

* CHECK dout0_50 Vdout0_50ck194 = 0 time = 1950
.meas tran vdout0_50ck194 FIND v(dout0_50) AT=1950.05n

* CHECK dout0_51 Vdout0_51ck194 = 0 time = 1950
.meas tran vdout0_51ck194 FIND v(dout0_51) AT=1950.05n

* CHECK dout0_52 Vdout0_52ck194 = 0 time = 1950
.meas tran vdout0_52ck194 FIND v(dout0_52) AT=1950.05n

* CHECK dout0_53 Vdout0_53ck194 = 0 time = 1950
.meas tran vdout0_53ck194 FIND v(dout0_53) AT=1950.05n

* CHECK dout0_54 Vdout0_54ck194 = 0 time = 1950
.meas tran vdout0_54ck194 FIND v(dout0_54) AT=1950.05n

* CHECK dout0_55 Vdout0_55ck194 = 1.8 time = 1950
.meas tran vdout0_55ck194 FIND v(dout0_55) AT=1950.05n

* CHECK dout0_56 Vdout0_56ck194 = 0 time = 1950
.meas tran vdout0_56ck194 FIND v(dout0_56) AT=1950.05n

* CHECK dout0_57 Vdout0_57ck194 = 1.8 time = 1950
.meas tran vdout0_57ck194 FIND v(dout0_57) AT=1950.05n

* CHECK dout0_58 Vdout0_58ck194 = 1.8 time = 1950
.meas tran vdout0_58ck194 FIND v(dout0_58) AT=1950.05n

* CHECK dout0_59 Vdout0_59ck194 = 1.8 time = 1950
.meas tran vdout0_59ck194 FIND v(dout0_59) AT=1950.05n

* CHECK dout0_60 Vdout0_60ck194 = 1.8 time = 1950
.meas tran vdout0_60ck194 FIND v(dout0_60) AT=1950.05n

* CHECK dout0_61 Vdout0_61ck194 = 1.8 time = 1950
.meas tran vdout0_61ck194 FIND v(dout0_61) AT=1950.05n

* CHECK dout0_62 Vdout0_62ck194 = 0 time = 1950
.meas tran vdout0_62ck194 FIND v(dout0_62) AT=1950.05n

* CHECK dout0_63 Vdout0_63ck194 = 1.8 time = 1950
.meas tran vdout0_63ck194 FIND v(dout0_63) AT=1950.05n

* CHECK dout0_64 Vdout0_64ck194 = 0 time = 1950
.meas tran vdout0_64ck194 FIND v(dout0_64) AT=1950.05n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 1960
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=1960.05n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 1960
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=1960.05n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 1960
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=1960.05n

* CHECK dout0_3 Vdout0_3ck195 = 1.8 time = 1960
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=1960.05n

* CHECK dout0_4 Vdout0_4ck195 = 0 time = 1960
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=1960.05n

* CHECK dout0_5 Vdout0_5ck195 = 0 time = 1960
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=1960.05n

* CHECK dout0_6 Vdout0_6ck195 = 0 time = 1960
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=1960.05n

* CHECK dout0_7 Vdout0_7ck195 = 0 time = 1960
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=1960.05n

* CHECK dout0_8 Vdout0_8ck195 = 0 time = 1960
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=1960.05n

* CHECK dout0_9 Vdout0_9ck195 = 0 time = 1960
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=1960.05n

* CHECK dout0_10 Vdout0_10ck195 = 1.8 time = 1960
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=1960.05n

* CHECK dout0_11 Vdout0_11ck195 = 0 time = 1960
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=1960.05n

* CHECK dout0_12 Vdout0_12ck195 = 0 time = 1960
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=1960.05n

* CHECK dout0_13 Vdout0_13ck195 = 1.8 time = 1960
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=1960.05n

* CHECK dout0_14 Vdout0_14ck195 = 1.8 time = 1960
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=1960.05n

* CHECK dout0_15 Vdout0_15ck195 = 1.8 time = 1960
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=1960.05n

* CHECK dout0_16 Vdout0_16ck195 = 0 time = 1960
.meas tran vdout0_16ck195 FIND v(dout0_16) AT=1960.05n

* CHECK dout0_17 Vdout0_17ck195 = 1.8 time = 1960
.meas tran vdout0_17ck195 FIND v(dout0_17) AT=1960.05n

* CHECK dout0_18 Vdout0_18ck195 = 0 time = 1960
.meas tran vdout0_18ck195 FIND v(dout0_18) AT=1960.05n

* CHECK dout0_19 Vdout0_19ck195 = 1.8 time = 1960
.meas tran vdout0_19ck195 FIND v(dout0_19) AT=1960.05n

* CHECK dout0_20 Vdout0_20ck195 = 1.8 time = 1960
.meas tran vdout0_20ck195 FIND v(dout0_20) AT=1960.05n

* CHECK dout0_21 Vdout0_21ck195 = 0 time = 1960
.meas tran vdout0_21ck195 FIND v(dout0_21) AT=1960.05n

* CHECK dout0_22 Vdout0_22ck195 = 0 time = 1960
.meas tran vdout0_22ck195 FIND v(dout0_22) AT=1960.05n

* CHECK dout0_23 Vdout0_23ck195 = 1.8 time = 1960
.meas tran vdout0_23ck195 FIND v(dout0_23) AT=1960.05n

* CHECK dout0_24 Vdout0_24ck195 = 1.8 time = 1960
.meas tran vdout0_24ck195 FIND v(dout0_24) AT=1960.05n

* CHECK dout0_25 Vdout0_25ck195 = 0 time = 1960
.meas tran vdout0_25ck195 FIND v(dout0_25) AT=1960.05n

* CHECK dout0_26 Vdout0_26ck195 = 0 time = 1960
.meas tran vdout0_26ck195 FIND v(dout0_26) AT=1960.05n

* CHECK dout0_27 Vdout0_27ck195 = 0 time = 1960
.meas tran vdout0_27ck195 FIND v(dout0_27) AT=1960.05n

* CHECK dout0_28 Vdout0_28ck195 = 1.8 time = 1960
.meas tran vdout0_28ck195 FIND v(dout0_28) AT=1960.05n

* CHECK dout0_29 Vdout0_29ck195 = 1.8 time = 1960
.meas tran vdout0_29ck195 FIND v(dout0_29) AT=1960.05n

* CHECK dout0_30 Vdout0_30ck195 = 0 time = 1960
.meas tran vdout0_30ck195 FIND v(dout0_30) AT=1960.05n

* CHECK dout0_31 Vdout0_31ck195 = 0 time = 1960
.meas tran vdout0_31ck195 FIND v(dout0_31) AT=1960.05n

* CHECK dout0_32 Vdout0_32ck195 = 1.8 time = 1960
.meas tran vdout0_32ck195 FIND v(dout0_32) AT=1960.05n

* CHECK dout0_33 Vdout0_33ck195 = 0 time = 1960
.meas tran vdout0_33ck195 FIND v(dout0_33) AT=1960.05n

* CHECK dout0_34 Vdout0_34ck195 = 0 time = 1960
.meas tran vdout0_34ck195 FIND v(dout0_34) AT=1960.05n

* CHECK dout0_35 Vdout0_35ck195 = 1.8 time = 1960
.meas tran vdout0_35ck195 FIND v(dout0_35) AT=1960.05n

* CHECK dout0_36 Vdout0_36ck195 = 0 time = 1960
.meas tran vdout0_36ck195 FIND v(dout0_36) AT=1960.05n

* CHECK dout0_37 Vdout0_37ck195 = 0 time = 1960
.meas tran vdout0_37ck195 FIND v(dout0_37) AT=1960.05n

* CHECK dout0_38 Vdout0_38ck195 = 1.8 time = 1960
.meas tran vdout0_38ck195 FIND v(dout0_38) AT=1960.05n

* CHECK dout0_39 Vdout0_39ck195 = 1.8 time = 1960
.meas tran vdout0_39ck195 FIND v(dout0_39) AT=1960.05n

* CHECK dout0_40 Vdout0_40ck195 = 1.8 time = 1960
.meas tran vdout0_40ck195 FIND v(dout0_40) AT=1960.05n

* CHECK dout0_41 Vdout0_41ck195 = 1.8 time = 1960
.meas tran vdout0_41ck195 FIND v(dout0_41) AT=1960.05n

* CHECK dout0_42 Vdout0_42ck195 = 1.8 time = 1960
.meas tran vdout0_42ck195 FIND v(dout0_42) AT=1960.05n

* CHECK dout0_43 Vdout0_43ck195 = 0 time = 1960
.meas tran vdout0_43ck195 FIND v(dout0_43) AT=1960.05n

* CHECK dout0_44 Vdout0_44ck195 = 1.8 time = 1960
.meas tran vdout0_44ck195 FIND v(dout0_44) AT=1960.05n

* CHECK dout0_45 Vdout0_45ck195 = 0 time = 1960
.meas tran vdout0_45ck195 FIND v(dout0_45) AT=1960.05n

* CHECK dout0_46 Vdout0_46ck195 = 1.8 time = 1960
.meas tran vdout0_46ck195 FIND v(dout0_46) AT=1960.05n

* CHECK dout0_47 Vdout0_47ck195 = 1.8 time = 1960
.meas tran vdout0_47ck195 FIND v(dout0_47) AT=1960.05n

* CHECK dout0_48 Vdout0_48ck195 = 1.8 time = 1960
.meas tran vdout0_48ck195 FIND v(dout0_48) AT=1960.05n

* CHECK dout0_49 Vdout0_49ck195 = 0 time = 1960
.meas tran vdout0_49ck195 FIND v(dout0_49) AT=1960.05n

* CHECK dout0_50 Vdout0_50ck195 = 1.8 time = 1960
.meas tran vdout0_50ck195 FIND v(dout0_50) AT=1960.05n

* CHECK dout0_51 Vdout0_51ck195 = 1.8 time = 1960
.meas tran vdout0_51ck195 FIND v(dout0_51) AT=1960.05n

* CHECK dout0_52 Vdout0_52ck195 = 1.8 time = 1960
.meas tran vdout0_52ck195 FIND v(dout0_52) AT=1960.05n

* CHECK dout0_53 Vdout0_53ck195 = 1.8 time = 1960
.meas tran vdout0_53ck195 FIND v(dout0_53) AT=1960.05n

* CHECK dout0_54 Vdout0_54ck195 = 1.8 time = 1960
.meas tran vdout0_54ck195 FIND v(dout0_54) AT=1960.05n

* CHECK dout0_55 Vdout0_55ck195 = 0 time = 1960
.meas tran vdout0_55ck195 FIND v(dout0_55) AT=1960.05n

* CHECK dout0_56 Vdout0_56ck195 = 0 time = 1960
.meas tran vdout0_56ck195 FIND v(dout0_56) AT=1960.05n

* CHECK dout0_57 Vdout0_57ck195 = 1.8 time = 1960
.meas tran vdout0_57ck195 FIND v(dout0_57) AT=1960.05n

* CHECK dout0_58 Vdout0_58ck195 = 0 time = 1960
.meas tran vdout0_58ck195 FIND v(dout0_58) AT=1960.05n

* CHECK dout0_59 Vdout0_59ck195 = 1.8 time = 1960
.meas tran vdout0_59ck195 FIND v(dout0_59) AT=1960.05n

* CHECK dout0_60 Vdout0_60ck195 = 1.8 time = 1960
.meas tran vdout0_60ck195 FIND v(dout0_60) AT=1960.05n

* CHECK dout0_61 Vdout0_61ck195 = 0 time = 1960
.meas tran vdout0_61ck195 FIND v(dout0_61) AT=1960.05n

* CHECK dout0_62 Vdout0_62ck195 = 0 time = 1960
.meas tran vdout0_62ck195 FIND v(dout0_62) AT=1960.05n

* CHECK dout0_63 Vdout0_63ck195 = 0 time = 1960
.meas tran vdout0_63ck195 FIND v(dout0_63) AT=1960.05n

* CHECK dout0_64 Vdout0_64ck195 = 0 time = 1960
.meas tran vdout0_64ck195 FIND v(dout0_64) AT=1960.05n

* CHECK dout0_0 Vdout0_0ck201 = 1.8 time = 2020
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=2020.05n

* CHECK dout0_1 Vdout0_1ck201 = 1.8 time = 2020
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=2020.05n

* CHECK dout0_2 Vdout0_2ck201 = 1.8 time = 2020
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=2020.05n

* CHECK dout0_3 Vdout0_3ck201 = 1.8 time = 2020
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=2020.05n

* CHECK dout0_4 Vdout0_4ck201 = 1.8 time = 2020
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=2020.05n

* CHECK dout0_5 Vdout0_5ck201 = 0 time = 2020
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=2020.05n

* CHECK dout0_6 Vdout0_6ck201 = 0 time = 2020
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=2020.05n

* CHECK dout0_7 Vdout0_7ck201 = 1.8 time = 2020
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=2020.05n

* CHECK dout0_8 Vdout0_8ck201 = 1.8 time = 2020
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=2020.05n

* CHECK dout0_9 Vdout0_9ck201 = 0 time = 2020
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=2020.05n

* CHECK dout0_10 Vdout0_10ck201 = 0 time = 2020
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=2020.05n

* CHECK dout0_11 Vdout0_11ck201 = 1.8 time = 2020
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=2020.05n

* CHECK dout0_12 Vdout0_12ck201 = 1.8 time = 2020
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=2020.05n

* CHECK dout0_13 Vdout0_13ck201 = 1.8 time = 2020
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=2020.05n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 2020
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=2020.05n

* CHECK dout0_15 Vdout0_15ck201 = 0 time = 2020
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=2020.05n

* CHECK dout0_16 Vdout0_16ck201 = 1.8 time = 2020
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=2020.05n

* CHECK dout0_17 Vdout0_17ck201 = 1.8 time = 2020
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=2020.05n

* CHECK dout0_18 Vdout0_18ck201 = 1.8 time = 2020
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=2020.05n

* CHECK dout0_19 Vdout0_19ck201 = 1.8 time = 2020
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=2020.05n

* CHECK dout0_20 Vdout0_20ck201 = 0 time = 2020
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=2020.05n

* CHECK dout0_21 Vdout0_21ck201 = 0 time = 2020
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=2020.05n

* CHECK dout0_22 Vdout0_22ck201 = 1.8 time = 2020
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=2020.05n

* CHECK dout0_23 Vdout0_23ck201 = 0 time = 2020
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=2020.05n

* CHECK dout0_24 Vdout0_24ck201 = 0 time = 2020
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=2020.05n

* CHECK dout0_25 Vdout0_25ck201 = 0 time = 2020
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=2020.05n

* CHECK dout0_26 Vdout0_26ck201 = 0 time = 2020
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=2020.05n

* CHECK dout0_27 Vdout0_27ck201 = 0 time = 2020
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=2020.05n

* CHECK dout0_28 Vdout0_28ck201 = 0 time = 2020
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=2020.05n

* CHECK dout0_29 Vdout0_29ck201 = 0 time = 2020
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=2020.05n

* CHECK dout0_30 Vdout0_30ck201 = 0 time = 2020
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=2020.05n

* CHECK dout0_31 Vdout0_31ck201 = 0 time = 2020
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=2020.05n

* CHECK dout0_32 Vdout0_32ck201 = 0 time = 2020
.meas tran vdout0_32ck201 FIND v(dout0_32) AT=2020.05n

* CHECK dout0_33 Vdout0_33ck201 = 0 time = 2020
.meas tran vdout0_33ck201 FIND v(dout0_33) AT=2020.05n

* CHECK dout0_34 Vdout0_34ck201 = 1.8 time = 2020
.meas tran vdout0_34ck201 FIND v(dout0_34) AT=2020.05n

* CHECK dout0_35 Vdout0_35ck201 = 0 time = 2020
.meas tran vdout0_35ck201 FIND v(dout0_35) AT=2020.05n

* CHECK dout0_36 Vdout0_36ck201 = 0 time = 2020
.meas tran vdout0_36ck201 FIND v(dout0_36) AT=2020.05n

* CHECK dout0_37 Vdout0_37ck201 = 0 time = 2020
.meas tran vdout0_37ck201 FIND v(dout0_37) AT=2020.05n

* CHECK dout0_38 Vdout0_38ck201 = 0 time = 2020
.meas tran vdout0_38ck201 FIND v(dout0_38) AT=2020.05n

* CHECK dout0_39 Vdout0_39ck201 = 1.8 time = 2020
.meas tran vdout0_39ck201 FIND v(dout0_39) AT=2020.05n

* CHECK dout0_40 Vdout0_40ck201 = 0 time = 2020
.meas tran vdout0_40ck201 FIND v(dout0_40) AT=2020.05n

* CHECK dout0_41 Vdout0_41ck201 = 1.8 time = 2020
.meas tran vdout0_41ck201 FIND v(dout0_41) AT=2020.05n

* CHECK dout0_42 Vdout0_42ck201 = 1.8 time = 2020
.meas tran vdout0_42ck201 FIND v(dout0_42) AT=2020.05n

* CHECK dout0_43 Vdout0_43ck201 = 0 time = 2020
.meas tran vdout0_43ck201 FIND v(dout0_43) AT=2020.05n

* CHECK dout0_44 Vdout0_44ck201 = 1.8 time = 2020
.meas tran vdout0_44ck201 FIND v(dout0_44) AT=2020.05n

* CHECK dout0_45 Vdout0_45ck201 = 1.8 time = 2020
.meas tran vdout0_45ck201 FIND v(dout0_45) AT=2020.05n

* CHECK dout0_46 Vdout0_46ck201 = 1.8 time = 2020
.meas tran vdout0_46ck201 FIND v(dout0_46) AT=2020.05n

* CHECK dout0_47 Vdout0_47ck201 = 0 time = 2020
.meas tran vdout0_47ck201 FIND v(dout0_47) AT=2020.05n

* CHECK dout0_48 Vdout0_48ck201 = 0 time = 2020
.meas tran vdout0_48ck201 FIND v(dout0_48) AT=2020.05n

* CHECK dout0_49 Vdout0_49ck201 = 1.8 time = 2020
.meas tran vdout0_49ck201 FIND v(dout0_49) AT=2020.05n

* CHECK dout0_50 Vdout0_50ck201 = 1.8 time = 2020
.meas tran vdout0_50ck201 FIND v(dout0_50) AT=2020.05n

* CHECK dout0_51 Vdout0_51ck201 = 1.8 time = 2020
.meas tran vdout0_51ck201 FIND v(dout0_51) AT=2020.05n

* CHECK dout0_52 Vdout0_52ck201 = 1.8 time = 2020
.meas tran vdout0_52ck201 FIND v(dout0_52) AT=2020.05n

* CHECK dout0_53 Vdout0_53ck201 = 1.8 time = 2020
.meas tran vdout0_53ck201 FIND v(dout0_53) AT=2020.05n

* CHECK dout0_54 Vdout0_54ck201 = 1.8 time = 2020
.meas tran vdout0_54ck201 FIND v(dout0_54) AT=2020.05n

* CHECK dout0_55 Vdout0_55ck201 = 0 time = 2020
.meas tran vdout0_55ck201 FIND v(dout0_55) AT=2020.05n

* CHECK dout0_56 Vdout0_56ck201 = 0 time = 2020
.meas tran vdout0_56ck201 FIND v(dout0_56) AT=2020.05n

* CHECK dout0_57 Vdout0_57ck201 = 1.8 time = 2020
.meas tran vdout0_57ck201 FIND v(dout0_57) AT=2020.05n

* CHECK dout0_58 Vdout0_58ck201 = 0 time = 2020
.meas tran vdout0_58ck201 FIND v(dout0_58) AT=2020.05n

* CHECK dout0_59 Vdout0_59ck201 = 1.8 time = 2020
.meas tran vdout0_59ck201 FIND v(dout0_59) AT=2020.05n

* CHECK dout0_60 Vdout0_60ck201 = 1.8 time = 2020
.meas tran vdout0_60ck201 FIND v(dout0_60) AT=2020.05n

* CHECK dout0_61 Vdout0_61ck201 = 0 time = 2020
.meas tran vdout0_61ck201 FIND v(dout0_61) AT=2020.05n

* CHECK dout0_62 Vdout0_62ck201 = 0 time = 2020
.meas tran vdout0_62ck201 FIND v(dout0_62) AT=2020.05n

* CHECK dout0_63 Vdout0_63ck201 = 1.8 time = 2020
.meas tran vdout0_63ck201 FIND v(dout0_63) AT=2020.05n

* CHECK dout0_64 Vdout0_64ck201 = 0 time = 2020
.meas tran vdout0_64ck201 FIND v(dout0_64) AT=2020.05n

* CHECK dout0_0 Vdout0_0ck204 = 1.8 time = 2050
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=2050.05n

* CHECK dout0_1 Vdout0_1ck204 = 0 time = 2050
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=2050.05n

* CHECK dout0_2 Vdout0_2ck204 = 0 time = 2050
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=2050.05n

* CHECK dout0_3 Vdout0_3ck204 = 1.8 time = 2050
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=2050.05n

* CHECK dout0_4 Vdout0_4ck204 = 0 time = 2050
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=2050.05n

* CHECK dout0_5 Vdout0_5ck204 = 0 time = 2050
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=2050.05n

* CHECK dout0_6 Vdout0_6ck204 = 0 time = 2050
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=2050.05n

* CHECK dout0_7 Vdout0_7ck204 = 1.8 time = 2050
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=2050.05n

* CHECK dout0_8 Vdout0_8ck204 = 1.8 time = 2050
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=2050.05n

* CHECK dout0_9 Vdout0_9ck204 = 0 time = 2050
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=2050.05n

* CHECK dout0_10 Vdout0_10ck204 = 0 time = 2050
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=2050.05n

* CHECK dout0_11 Vdout0_11ck204 = 0 time = 2050
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=2050.05n

* CHECK dout0_12 Vdout0_12ck204 = 1.8 time = 2050
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=2050.05n

* CHECK dout0_13 Vdout0_13ck204 = 1.8 time = 2050
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=2050.05n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 2050
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=2050.05n

* CHECK dout0_15 Vdout0_15ck204 = 0 time = 2050
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=2050.05n

* CHECK dout0_16 Vdout0_16ck204 = 0 time = 2050
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=2050.05n

* CHECK dout0_17 Vdout0_17ck204 = 1.8 time = 2050
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=2050.05n

* CHECK dout0_18 Vdout0_18ck204 = 1.8 time = 2050
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=2050.05n

* CHECK dout0_19 Vdout0_19ck204 = 1.8 time = 2050
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=2050.05n

* CHECK dout0_20 Vdout0_20ck204 = 0 time = 2050
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=2050.05n

* CHECK dout0_21 Vdout0_21ck204 = 0 time = 2050
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=2050.05n

* CHECK dout0_22 Vdout0_22ck204 = 1.8 time = 2050
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=2050.05n

* CHECK dout0_23 Vdout0_23ck204 = 1.8 time = 2050
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=2050.05n

* CHECK dout0_24 Vdout0_24ck204 = 0 time = 2050
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=2050.05n

* CHECK dout0_25 Vdout0_25ck204 = 1.8 time = 2050
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=2050.05n

* CHECK dout0_26 Vdout0_26ck204 = 1.8 time = 2050
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=2050.05n

* CHECK dout0_27 Vdout0_27ck204 = 1.8 time = 2050
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=2050.05n

* CHECK dout0_28 Vdout0_28ck204 = 1.8 time = 2050
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=2050.05n

* CHECK dout0_29 Vdout0_29ck204 = 0 time = 2050
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=2050.05n

* CHECK dout0_30 Vdout0_30ck204 = 0 time = 2050
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=2050.05n

* CHECK dout0_31 Vdout0_31ck204 = 1.8 time = 2050
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=2050.05n

* CHECK dout0_32 Vdout0_32ck204 = 0 time = 2050
.meas tran vdout0_32ck204 FIND v(dout0_32) AT=2050.05n

* CHECK dout0_33 Vdout0_33ck204 = 0 time = 2050
.meas tran vdout0_33ck204 FIND v(dout0_33) AT=2050.05n

* CHECK dout0_34 Vdout0_34ck204 = 1.8 time = 2050
.meas tran vdout0_34ck204 FIND v(dout0_34) AT=2050.05n

* CHECK dout0_35 Vdout0_35ck204 = 0 time = 2050
.meas tran vdout0_35ck204 FIND v(dout0_35) AT=2050.05n

* CHECK dout0_36 Vdout0_36ck204 = 1.8 time = 2050
.meas tran vdout0_36ck204 FIND v(dout0_36) AT=2050.05n

* CHECK dout0_37 Vdout0_37ck204 = 1.8 time = 2050
.meas tran vdout0_37ck204 FIND v(dout0_37) AT=2050.05n

* CHECK dout0_38 Vdout0_38ck204 = 0 time = 2050
.meas tran vdout0_38ck204 FIND v(dout0_38) AT=2050.05n

* CHECK dout0_39 Vdout0_39ck204 = 1.8 time = 2050
.meas tran vdout0_39ck204 FIND v(dout0_39) AT=2050.05n

* CHECK dout0_40 Vdout0_40ck204 = 0 time = 2050
.meas tran vdout0_40ck204 FIND v(dout0_40) AT=2050.05n

* CHECK dout0_41 Vdout0_41ck204 = 1.8 time = 2050
.meas tran vdout0_41ck204 FIND v(dout0_41) AT=2050.05n

* CHECK dout0_42 Vdout0_42ck204 = 1.8 time = 2050
.meas tran vdout0_42ck204 FIND v(dout0_42) AT=2050.05n

* CHECK dout0_43 Vdout0_43ck204 = 1.8 time = 2050
.meas tran vdout0_43ck204 FIND v(dout0_43) AT=2050.05n

* CHECK dout0_44 Vdout0_44ck204 = 0 time = 2050
.meas tran vdout0_44ck204 FIND v(dout0_44) AT=2050.05n

* CHECK dout0_45 Vdout0_45ck204 = 0 time = 2050
.meas tran vdout0_45ck204 FIND v(dout0_45) AT=2050.05n

* CHECK dout0_46 Vdout0_46ck204 = 1.8 time = 2050
.meas tran vdout0_46ck204 FIND v(dout0_46) AT=2050.05n

* CHECK dout0_47 Vdout0_47ck204 = 0 time = 2050
.meas tran vdout0_47ck204 FIND v(dout0_47) AT=2050.05n

* CHECK dout0_48 Vdout0_48ck204 = 1.8 time = 2050
.meas tran vdout0_48ck204 FIND v(dout0_48) AT=2050.05n

* CHECK dout0_49 Vdout0_49ck204 = 0 time = 2050
.meas tran vdout0_49ck204 FIND v(dout0_49) AT=2050.05n

* CHECK dout0_50 Vdout0_50ck204 = 0 time = 2050
.meas tran vdout0_50ck204 FIND v(dout0_50) AT=2050.05n

* CHECK dout0_51 Vdout0_51ck204 = 0 time = 2050
.meas tran vdout0_51ck204 FIND v(dout0_51) AT=2050.05n

* CHECK dout0_52 Vdout0_52ck204 = 0 time = 2050
.meas tran vdout0_52ck204 FIND v(dout0_52) AT=2050.05n

* CHECK dout0_53 Vdout0_53ck204 = 1.8 time = 2050
.meas tran vdout0_53ck204 FIND v(dout0_53) AT=2050.05n

* CHECK dout0_54 Vdout0_54ck204 = 1.8 time = 2050
.meas tran vdout0_54ck204 FIND v(dout0_54) AT=2050.05n

* CHECK dout0_55 Vdout0_55ck204 = 1.8 time = 2050
.meas tran vdout0_55ck204 FIND v(dout0_55) AT=2050.05n

* CHECK dout0_56 Vdout0_56ck204 = 0 time = 2050
.meas tran vdout0_56ck204 FIND v(dout0_56) AT=2050.05n

* CHECK dout0_57 Vdout0_57ck204 = 0 time = 2050
.meas tran vdout0_57ck204 FIND v(dout0_57) AT=2050.05n

* CHECK dout0_58 Vdout0_58ck204 = 1.8 time = 2050
.meas tran vdout0_58ck204 FIND v(dout0_58) AT=2050.05n

* CHECK dout0_59 Vdout0_59ck204 = 0 time = 2050
.meas tran vdout0_59ck204 FIND v(dout0_59) AT=2050.05n

* CHECK dout0_60 Vdout0_60ck204 = 0 time = 2050
.meas tran vdout0_60ck204 FIND v(dout0_60) AT=2050.05n

* CHECK dout0_61 Vdout0_61ck204 = 0 time = 2050
.meas tran vdout0_61ck204 FIND v(dout0_61) AT=2050.05n

* CHECK dout0_62 Vdout0_62ck204 = 1.8 time = 2050
.meas tran vdout0_62ck204 FIND v(dout0_62) AT=2050.05n

* CHECK dout0_63 Vdout0_63ck204 = 0 time = 2050
.meas tran vdout0_63ck204 FIND v(dout0_63) AT=2050.05n

* CHECK dout0_64 Vdout0_64ck204 = 0 time = 2050
.meas tran vdout0_64ck204 FIND v(dout0_64) AT=2050.05n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
